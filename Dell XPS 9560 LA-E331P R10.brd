# Allegro board Dell XPS 9560 LA-E331P R10.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D41: length 100.8
  IN1 w0.079: v2(234.66,20.41) 235.15,20.9 235.15,24.29 233.28,26.16 233.21,26.16 231.75,27.63 231.75,28.29 229,31.04 223.31,31.04 223.23,31.11 223.23,31.68 223.15,31.76 223,31.76 222.92,31.68 222.92,31.11 222.84,31.04 222.68,31.04 222.6,31.11 222.6,31.68 222.52,31.76 222.37,31.76 222.29,31.68 222.29,31.14 222.18,31.04 222.03,31.04 221.93,31.14 221.93,31.65 221.8,31.78 209.31,31.78 208.08,33 204.47,33 192.53,44.93 176.02,44.93 173.98,46.98 173.98,49.42 171.21,52.19 171.21,53.09 169.47,54.83 166.07,58.23 166.07,63.22 v2(165.82,63.47)
  BOTTOM w0.089: v2(165.82,63.47) 165.54,63.47 UH1.W7
  BOTTOM w0.14: JDIMM2.194 233.94,19.51 234.66,20.23 v2(234.66,20.41)
DDR_B_D42: length 100.7
  IN1 w0.079: v2(166.7,65.92) 167.1,65.52 167.1,64.37 167.29,64.18 167.29,63.46 167.64,63.12 167.64,59.11 172.1,54.65 172.39,54.65 174.13,52.91 174.13,52.31 175.28,51.16 175.79,51.16 176.13,50.83 176.13,49.52 176.42,49.22 176.53,49.22 176.86,49.55 176.97,49.55 177.08,49.43 177.08,49.32 176.76,49 176.76,48.89 176.87,48.78 176.98,48.78 177.3,49.1 177.41,49.1 177.53,48.99 177.53,48.88 177.2,48.55 177.2,48.44 177.31,48.33 177.42,48.33 177.75,48.65 177.86,48.65 177.97,48.54 177.97,48.43 177.65,48.11 177.65,48 177.76,47.88 177.87,47.88 178.13,48.15 178.24,48.15 178.35,48.03 178.35,47.92 178.09,47.66 178.09,47.55 178.56,47.08 193.42,47.08 205.35,35.15 209.02,35.15 210.24,33.92 224.02,33.92 224.77,33.18 229.96,33.18 234.62,28.52 234.62,27.87 237.29,25.2 237.29,24.82 v2(237.89,24.22)
  BOTTOM w0.089: v2(166.7,65.92) 166.6,65.92 UH1.V10
  BOTTOM w0.14: JDIMM2.207 237.18,24.89 237.85,24.22 v2(237.89,24.22)
DDR_B_D43: length 101
  IN1 w0.079: v2(166.71,66.57) 167.28,66 167.28,64.53 167.58,64.23 167.58,63.42 167.82,63.19 167.82,59.17 172.11,54.88 172.4,54.88 174.3,52.98 174.3,52.54 175.39,51.44 175.68,51.44 175.91,51.45 180,47.36 193.54,47.36 205.47,35.43 209.13,35.43 210.35,34.21 224.14,34.21 224.88,33.46 230.08,33.46 234.9,28.64 234.9,27.99 238.64,24.25 238.64,21.16 v2(237.89,20.41)
  BOTTOM w0.089: UH1.V11 166.6,66.57 v2(166.71,66.57)
  BOTTOM w0.14: v2(237.89,20.41) 237.89,19.78 237.42,19.31 JDIMM2.208
DDR_B_D44: length 100.9
  IN1 w0.079: v2(165.82,65.92) 165.42,65.52 165.42,64.33 165.24,64.14 165.24,63.31 165.69,62.86 165.69,58.1 170.88,52.91 170.88,51.73 173.42,49.19 173.42,46.74 175.79,44.37 192.3,44.37 204.23,32.44 207.85,32.44 209.07,31.21 217.31,31.21 217.44,31.09 217.44,30.64 217.55,30.53 217.71,30.53 217.82,30.64 217.82,31.11 217.92,31.21 218.07,31.21 218.18,31.11 218.18,30.55 218.26,30.47 228.76,30.47 231.18,28.05 231.18,27.39 234.15,24.42 234.15,23.46 v2(234.66,22.95)
  BOTTOM w0.076: UH1.W11 165.49,66.25 v2(165.82,65.92)
  BOTTOM w0.14: v2(234.66,22.95) 233.18,24.44 JDIMM2.191
DDR_B_D45: length 100.9
  IN1 w0.079: v2(164.92,65.38) 165.06,65.24 165.06,63.25 165.49,62.83 165.49,58.05 170.71,52.83 170.71,51.5 173.14,49.07 173.14,46.63 175.67,44.09 192.18,44.09 204.11,32.15 207.73,32.15 208.96,30.93 216.7,30.93 217.45,30.19 228.65,30.19 230.9,27.94 230.9,27.28 233.87,24.31 233.87,21.6 234,21.47 234.45,21.47 v2(234.66,21.68)
  BOTTOM w0.076: v2(164.92,65.38) 165.14,65.6 UH1.W10
  BOTTOM w0.14: JDIMM2.190 232.94,19.16 234.11,20.33 234.11,21.13 v2(234.66,21.68)
DDR_B_D46: length 100.8
  IN1 w0.079: v2(166.73,64.62) 166.73,64.49 167.12,64.11 167.12,63.37 167.44,63.05 167.44,58.95 172.76,53.63 173,53.63 173.83,52.8 173.83,52.21 175.85,50.19 175.85,48.72 176.09,48.47 176.21,48.47 176.43,48.7 176.55,48.7 176.66,48.59 176.66,48.48 176.43,48.25 176.43,48.14 176.54,48.02 176.65,48.02 176.88,48.25 176.99,48.25 177.1,48.14 177.1,48.03 176.87,47.8 176.87,47.69 176.98,47.58 177.1,47.58 177.33,47.81 177.44,47.81 177.55,47.7 177.55,47.59 177.32,47.36 177.32,47.24 177.77,46.8 193.3,46.8 205.24,34.86 208.9,34.86 210.12,33.64 223.91,33.64 224.65,32.9 229.85,32.9 234.34,28.41 234.34,27.76 237.01,25.08 237.01,23.6 237.66,22.95 v2(237.89,22.95)
  BOTTOM w0.089: v2(166.73,64.62) 166.6,64.62 UH1.V8
  BOTTOM w0.14: v2(237.89,22.95) 236.18,24.67 JDIMM2.203
DDR_B_D47: length 100.8
  IN1 w0.079: v2(166.73,63.97) 166.65,63.88 166.65,58.47 172.3,52.82 172.83,52.82 175.56,50.08 175.56,48.02 175.9,47.68 176.01,47.68 176.19,47.86 176.3,47.86 176.41,47.75 176.41,47.64 176.24,47.46 176.24,47.35 176.35,47.24 176.46,47.24 176.64,47.42 176.75,47.42 176.86,47.3 176.86,47.19 176.68,47.02 176.68,46.9 177.07,46.52 193.19,46.52 205.12,34.58 208.78,34.58 210,33.36 223.79,33.36 224.53,32.62 229.73,32.62 234.06,28.29 234.06,27.64 236.73,24.97 236.73,23.31 237.24,22.81 237.24,22.34 v2(237.89,21.68)
  BOTTOM w0.089: UH1.V7 166.6,63.97 v2(166.73,63.97)
  BOTTOM w0.14: JDIMM2.204 236.42,19.31 237.31,20.19 237.31,21.09 v2(237.89,21.68)
DDR_B_D48: length 101.4
  IN1 w0.079: v2(168.56,66.57) 168.17,66.18 168.17,65.78 168.02,65.63 168.02,64.45 167.84,64.27 167.84,63.63 168.2,63.27 168.2,59.03 172.18,55.04 172.48,55.04 175.59,51.93 176.11,51.93 180.2,47.85 193.74,47.85 205.63,35.95 209.29,35.95 210.56,34.69 224.34,34.69 225.08,33.95 230.45,33.95 236.6,27.8 236.6,26.98 239.12,24.45 239.12,21.47 v2(240.18,20.41)
  BOTTOM w0.089: UH1.R11 168.43,66.57 v2(168.56,66.57)
  BOTTOM w0.14: v2(240.18,20.41) 240.18,19.86 239.42,19.11 JDIMM2.216
DDR_B_D49: length 101.1
  IN1 w0.079: v2(240.18,24.22) 240.18,24.6 237.45,27.33 237.45,28.15 230.8,34.79 230.13,34.79 230.04,34.89 230.04,35.44 229.96,35.52 229.8,35.52 229.72,35.44 229.72,34.89 229.64,34.81 229.49,34.81 229.41,34.89 229.41,35.44 229.33,35.52 229.17,35.52 229.09,35.44 229.09,34.89 229.01,34.81 228.86,34.81 228.78,34.89 228.78,35.44 228.7,35.52 228.54,35.52 228.46,35.44 228.46,34.89 228.38,34.81 228.23,34.81 228.15,34.89 228.15,35.44 228.07,35.52 227.91,35.52 227.83,35.44 227.83,34.89 227.75,34.81 227.6,34.81 227.52,34.89 227.52,35.44 227.44,35.52 227.28,35.52 227.2,35.44 227.2,34.89 227.12,34.81 226.96,34.81 226.85,34.92 226.85,35.41 226.72,35.54 210.91,35.54 209.65,36.8 205.98,36.8 194.09,48.69 180.61,48.69 176.53,52.78 175.94,52.78 173.17,55.55 172.39,55.55 168.73,59.21 168.73,63.81 v2(168.56,63.97)
  BOTTOM w0.089: v2(168.56,63.97) 168.43,63.97 UH1.R7
  BOTTOM w0.14: JDIMM2.215 239.18,25.22 v2(240.18,24.22)
DDR_B_D50: length 101.3
  IN1 w0.079: v2(243.48,20.41) 242.4,20.41 242.29,20.52 242.29,24.72 239.71,27.3 239.71,28.12 230.72,37.12 213.23,37.12 212.61,37.74 210.94,37.74 210.72,37.96 210.72,37.96 210.3,38.38 206.82,38.38 199.95,45.25 199.95,46.19 198.22,47.92 197.1,47.92 196.18,48.84 196.18,48.84 194.75,50.27 181.27,50.27 176.75,54.8 175.79,54.8 174.37,56.22 173.23,56.22 170.11,59.34 170.11,62.09 169.48,62.73 v2(169.48,63.97)
  BOTTOM w0.089: v2(169.48,63.97) 169.35,63.97 UH1.P7
  BOTTOM w0.14: v2(243.48,20.41) 243.23,20.41 242.42,19.61 JDIMM2.228
DDR_B_D51: length 101.2
  IN1 w0.079: v2(243.48,24.22) 243.48,24.73 240.56,27.65 240.56,28.47 231.07,37.97 214.88,37.97 214.8,38.04 214.8,38.51 214.72,38.59 214.57,38.59 214.49,38.51 214.49,38.04 214.41,37.97 214.25,37.97 214.17,38.04 214.17,38.51 214.09,38.59 213.94,38.59 213.86,38.51 213.86,38.04 213.78,37.97 213.58,37.97 213.45,38.09 213.45,38.46 213.33,38.59 211.29,38.59 210.65,39.23 208.11,39.23 198.57,48.76 197.45,48.76 195.09,51.13 181.61,51.13 175.89,56.85 173.33,56.85 170.75,59.43 170.75,62.2 170.2,62.76 170.2,64.48 170.02,64.66 170.02,66.03 169.85,66.2 v2(169.48,66.57)
  BOTTOM w0.089: v2(169.48,66.57) 169.35,66.57 UH1.P11
  BOTTOM w0.14: v2(243.48,24.22) 242.67,25.03 JDIMM2.229
DDR_B_D52: length 101.2
  IN1 w0.079: v2(168.56,64.62) 168.56,64.49 168.19,64.12 168.19,63.78 168.55,63.42 168.55,59.15 172.32,55.38 172.94,55.38 175.83,52.49 176.41,52.49 180.28,48.62 180.5,48.41 193.97,48.41 205.87,36.52 209.53,36.52 210.79,35.26 225.06,35.26 225.19,35.13 225.19,34.64 225.31,34.52 225.47,34.52 225.59,34.64 225.59,35.16 225.67,35.24 225.83,35.24 225.9,35.16 225.9,34.59 225.98,34.51 226.14,34.51 226.22,34.59 226.22,35.16 226.3,35.24 226.45,35.24 226.53,35.16 226.53,34.59 226.61,34.51 230.69,34.51 237.17,28.03 237.17,27.21 239.69,24.69 239.69,23.44 v2(240.18,22.95)
  BOTTOM w0.089: v2(168.56,64.62) 168.43,64.62 UH1.R8
  BOTTOM w0.14: JDIMM2.211 238.18,25.55 239.25,24.48 239.25,23.88 v2(240.18,22.95)
DDR_B_D53: length 101.2
  IN1 w0.079: v2(240.18,21.68) 239.89,21.68 239.41,22.16 239.41,24.57 236.88,27.09 236.88,27.92 230.57,34.23 225.2,34.23 224.46,34.97 210.67,34.97 209.41,36.23 205.75,36.23 193.86,48.13 180.38,48.13 180.27,48.24 180.26,48.24 176.3,52.21 175.71,52.21 172.71,55.21 172.25,55.21 168.37,59.09 168.37,63.35 168.02,63.71 168.02,64.2 168.19,64.38 168.19,65.55 v2(168.56,65.92)
  BOTTOM w0.089: UH1.R10 168.43,65.92 v2(168.56,65.92)
  BOTTOM w0.14: JDIMM2.212 238.42,19.18 239.11,19.86 239.11,20.61 v2(240.18,21.68)
DDR_B_D54: length 101.6
  IN1 w0.079: v2(169.48,64.62) 169.85,64.25 169.85,62.61 170.31,62.14 170.31,59.37 173.26,56.42 174.45,56.42 175.82,55.05 176.89,55.05 181.39,50.56 194.86,50.56 195.75,49.67 197.22,48.2 198.33,48.2 207.87,38.66 210.42,38.66 211.06,38.03 212.72,38.03 213.35,37.4 230.83,37.4 240,28.24 240,27.42 242.57,24.84 242.57,22.04 242.93,21.68 v2(243.48,21.68)
  BOTTOM w0.089: UH1.P8 169.35,64.62 v2(169.48,64.62)
  BOTTOM w0.14: JDIMM2.224 241.42,19.88 243.23,21.68 v2(243.48,21.68)
DDR_B_D55: length 101.1
  IN1 w0.079: v2(243.48,22.95) 243.31,22.95 242.86,23.41 242.86,24.96 240.28,27.53 240.28,28.36 230.95,37.68 213.46,37.68 212.84,38.31 211.17,38.31 210.53,38.94 207.99,38.94 198.45,48.48 197.34,48.48 194.97,50.84 181.5,50.84 175.72,56.63 173.3,56.63 170.52,59.41 170.52,62.19 170.02,62.68 170.02,64.38 169.85,64.56 169.85,65.55 v2(169.48,65.92)
  BOTTOM w0.089: v2(169.48,65.92) 169.35,65.92 UH1.P10
  BOTTOM w0.14: v2(243.48,22.95) 242.36,24.07 242.36,24.79 241.67,25.47 JDIMM2.225
DDR_B_D56: length 103
  IN1 w0.079: v2(245.77,24.22) 245.38,24.22 245.3,24.14 245.3,22.66 245.22,22.58 244.99,22.58 244.91,22.66 244.91,24.89 245.31,25.29 245.31,25.4 245.2,25.51 245.09,25.51 244.69,25.11 244.58,25.11 244.47,25.23 244.47,25.34 244.87,25.73 244.87,25.85 244.75,25.96 244.64,25.96 244.25,25.56 244.13,25.56 242.79,26.9 242.79,28.12 231.9,39.01 215.78,39.01 214.85,39.95 214.52,40.28 209.08,40.28 199.03,50.32 197.38,50.32 195.53,52.18 195.06,52.18 192.94,52.18 190.37,54.75 190.37,56.4 187.14,59.63 183.9,59.63 183.72,59.44 180.98,59.44 180.79,59.63 174.04,59.63 172.97,60.69 172.97,61.13 172.62,61.48 172.62,62.69 172.18,63.13 171.41,63.13 v2(171.24,63.3)
  BOTTOM w0.076: UH1.M7 171.2,63.3 v2(171.24,63.3)
  BOTTOM w0.14: v2(245.77,24.22) 245.14,24.22 244.67,24.69 JDIMM2.237
DDR_B_D57: length 103.1
  IN1 w0.079: v2(171.31,66.57) 170.75,66.02 170.75,64.93 170.71,64.89 170.71,62.72 171.3,62.13 171.3,61.41 171.71,61.01 172.3,61.01 172.57,60.74 172.57,60.49 175.06,58 175.43,58 181.82,51.61 195.29,51.61 197.15,49.76 198.8,49.76 208.84,39.71 214.29,39.71 215.55,38.45 231.67,38.45 242.23,27.89 242.23,26.67 244.1,24.8 244.1,22.08 v2(245.77,20.41)
  BOTTOM w0.089: UH1.M11 171.17,66.57 v2(171.31,66.57)
  BOTTOM w0.14: v2(245.77,20.41) 245.57,20.41 244.42,19.27 JDIMM2.236
DDR_B_D58: length 103.3
  IN1 w0.079: v2(248.81,24.22) 248.81,25.93 233.02,41.72 219.26,41.72 219.18,41.8 219.18,42.6 219.1,42.68 218.94,42.68 218.87,42.6 218.87,41.8 218.79,41.72 218.63,41.72 218.55,41.8 218.55,42.6 218.47,42.68 218.31,42.68 218.24,42.6 218.24,41.8 218.16,41.72 217.98,41.72 217.9,41.8 217.9,42.91 217.82,42.99 211.24,42.99 208.53,45.69 207.5,45.69 200.16,53.03 198.73,53.03 196.78,54.98 196.35,54.98 189,62.34 185.07,62.34 184.8,62.61 183.16,62.61 183.14,62.63 177.3,62.63 176.66,63.27 174.91,63.27 174.42,63.76 174.42,64.39 173.95,64.86 173.58,64.86 172.66,65.78 172.66,66.1 v2(172.19,66.57)
  BOTTOM w0.089: UH1.L11 172.09,66.57 v2(172.19,66.57)
  BOTTOM w0.14: v2(248.81,24.22) 248.3,24.22 247.68,24.85 JDIMM2.249
DDR_B_D59: length 103.1
  IN1 w0.079: v2(248.81,20.41) 248.16,19.76 247.59,19.76 247.46,19.88 247.46,20.14 247.59,20.27 247.84,20.27 248,20.43 248,22.82 247.78,23.05 247.78,25.77 232.67,40.88 216.64,40.88 215.8,41.72 215.38,42.14 209.85,42.14 199.81,52.19 198.38,52.19 196.43,54.14 196,54.14 194.07,56.06 188.65,61.49 184.39,61.49 184.16,61.72 176.83,61.72 176.49,61.39 175.76,61.39 173.69,63.46 172.79,63.46 172.17,64.07 v2(172.17,64.08)
  BOTTOM w0.14: v2(172.17,64.08) 172.12,64.08 UH1.L7 ; JDIMM2.250 247.93,19.58 248.75,20.41 248.81,20.41 v2(248.81,20.41)
DDR_B_D60: length 103.2
  IN1 w0.079: v2(171.31,65.92) 170.93,65.55 170.93,64.87 170.88,64.82 170.88,62.79 171.34,62.33 172.23,62.33 172.44,62.12 172.44,61.29 172.76,60.96 172.76,60.6 175.17,58.19 175.64,58.19 181.93,51.89 195.18,51.89 195.41,51.89 197.26,50.04 198.92,50.04 208.96,39.99 214.4,39.99 214.57,39.83 214.57,39.83 215.67,38.73 231.78,38.73 242.51,28 242.51,26.79 244.38,24.92 244.38,22.4 245.09,21.68 v2(245.77,21.68)
  BOTTOM w0.089: UH1.M10 171.17,65.92 v2(171.31,65.92)
  BOTTOM w0.14: v2(245.77,21.68) 243.42,19.34 JDIMM2.232
DDR_B_D61: length 103.2
  IN1 w0.079: v2(245.77,22.95) 246.2,23.38 246.2,24.99 244.74,26.45 244.62,26.45 244.19,26.02 244.08,26.02 243.97,26.13 243.97,26.24 244.4,26.67 244.4,26.78 244.29,26.89 244.18,26.89 243.74,26.46 243.63,26.46 243.52,26.57 243.52,26.68 243.96,27.12 243.96,27.23 243.83,27.36 243.37,27.36 243.07,27.65 243.07,28.24 232.02,39.3 215.9,39.3 214.64,40.56 209.19,40.56 199.15,50.6 197.5,50.6 195.64,52.46 194.94,52.46 193.06,52.46 190.66,54.86 190.66,56.51 187.26,59.91 183.66,59.91 183.52,59.76 181.12,59.76 180.98,59.91 174.07,59.91 173.14,60.84 173.14,61.28 172.81,61.6 172.81,62.73 172.25,63.3 171.88,63.3 v2(171.24,63.94)
  BOTTOM w0.089: v2(171.24,63.94) 171.2,63.94 UH1.M8
  BOTTOM w0.14: JDIMM2.233 243.67,25.04 v2(245.77,22.95)
DDR_B_D62: length 103.4
  IN1 w0.079: v2(172.19,65.92) 172.73,65.38 172.73,64.93 175.32,62.34 183.03,62.34 183.04,62.32 184.64,62.32 184.91,62.05 188.88,62.05 196.23,54.7 196.66,54.7 198.62,52.75 200.04,52.75 207.38,45.41 208.42,45.41 211.12,42.7 216.21,42.7 216.29,42.63 216.29,42.19 216.37,42.11 216.52,42.11 216.6,42.19 216.6,42.63 216.68,42.7 216.84,42.7 216.92,42.63 216.92,42.19 217,42.11 217.15,42.11 217.23,42.19 217.23,42.48 217.31,42.55 217.54,42.55 217.62,42.48 217.62,41.52 217.69,41.44 232.91,41.44 248.34,26 248.34,23.42 v2(248.81,22.95)
  BOTTOM w0.089: UH1.L10 172.09,65.92 v2(172.19,65.92)
  BOTTOM w0.14: JDIMM2.245 246.67,25.62 247.1,25.19 247.1,24.66 v2(248.81,22.95)
DDR_B_D63: length 103.4
  IN1 w0.079: v2(172.19,64.62) 172.81,64.62 175.81,61.62 176.26,61.62 176.69,62.04 184.35,62.04 184.62,61.77 188.76,61.77 196.11,54.42 196.55,54.42 198.5,52.47 199.92,52.47 207.26,45.12 208.3,45.12 211,42.42 215.5,42.42 216.76,41.16 216.94,41.16 217.02,41.24 217.02,41.71 217.1,41.79 217.25,41.79 217.33,41.71 217.33,41.24 217.41,41.16 232.79,41.16 248.06,25.89 248.06,23.16 248.29,22.94 248.29,21.55 248.37,21.47 248.74,21.47 248.81,21.55 v2(248.81,21.68)
  BOTTOM w0.14: JDIMM2.246 246.93,19.06 248.16,20.3 248.16,21.03 v2(248.81,21.68) ; UH1.L8 172.06,64.62 v2(172.19,64.62)
DDR_B_DQS0: length 90.5
  IN1 w0.079: v2(138.48,65.81) 138.64,65.64 138.64,65.44 138.57,65.37 137.95,65.37 137.24,66.07 136.44,66.07 135.9,65.53 135.9,65.13 134.24,63.47 134.24,46.29 147.55,32.98 156.33,32.98 163.12,26.19 175.16,26.19 175.83,25.52 183.55,25.52 184.66,24.42 184.66,22.96 184.84,22.78 185.02,22.78 v2(185.23,22.57)
  BOTTOM w0.076: v2(138.48,65.81) 138.15,65.4 UH1.BR9
  BOTTOM w0.14: JDIMM2.13 186.68,25.45 186.58,25.36 186.58,24.93 186.14,24.49 186.14,23.02 185.82,22.7 185.36,22.7 v2(185.23,22.57)
DDR_B_DQS1: length 90.2
  IN1 w0.079: v2(141.2,65.27) 140.99,65.27 140.93,65.21 140.93,62.52 140.73,62.32 140.73,61.12 141.22,60.62 141.22,58.43 138.06,55.26 138.06,51.36 138.86,50.56 138.86,47.21 147.87,38.21 157.63,38.21 165.09,30.75 177.73,30.75 178.57,29.91 185.42,29.91 186.96,28.37 186.96,27.92 190.46,24.42 190.46,21.75 190.53,21.69 190.81,21.69 190.89,21.78 v2(190.89,21.94)
  BOTTOM w0.076: UH1.BJ9 141.47,64.83 141.17,64.83 141.08,64.92 141.08,65.16 v2(141.2,65.27)
  BOTTOM w0.14: JDIMM2.34 191.92,19.03 191.79,19.16 191.79,21.33 191.41,21.72 191.12,21.72 v2(190.89,21.94)
DDR_B_DQS2: length 92.1
  IN1 w0.079: v2(144.76,65.27) 144.4,64.91 144.4,62.85 144.9,62.34 144.9,57.88 143.38,56.36 143.38,48.01 148.78,42.61 149.35,42.61 149.43,42.69 149.43,42.99 149.6,43.16 149.97,43.16 150.14,42.99 150.14,42.69 150.22,42.61 150.45,42.61 150.53,42.69 150.53,42.99 150.7,43.16 151.06,43.16 151.23,42.99 151.23,42.69 151.31,42.61 151.55,42.61 151.63,42.69 151.63,42.99 151.82,43.19 152.14,43.19 152.33,42.99 152.33,42.69 152.41,42.61 158.54,42.61 166.64,34.5 188.04,34.5 193.81,28.74 193.81,27.42 197.31,23.92 197.31,23.04 197.11,22.84 196.88,22.84 v2(196.61,22.57)
  BOTTOM w0.089: UH1.BF9 144.66,65.27 v2(144.76,65.27)
  BOTTOM w0.14: v2(196.61,22.57) 196.83,22.79 197.07,22.79 197.39,23.11 197.39,24.89 197.07,25.21 197.07,25.39 197.18,25.49 JDIMM2.55
DDR_B_DQS3: length 91.8
  IN1 w0.079: v2(202.65,21.94) 202.43,21.72 202.26,21.72 202.17,21.8 202.17,24.67 199.81,27.03 199.81,28.25 189.78,38.28 168.29,38.28 163.07,43.5 163.07,43.61 163.42,43.96 163.42,44.22 163.19,44.46 162.92,44.46 162.58,44.11 162.46,44.11 162.3,44.28 162.3,44.39 162.64,44.73 162.64,44.98 162.38,45.23 162.14,45.23 161.8,44.89 161.69,44.89 158.63,47.94 151.02,47.94 148.46,50.51 148.46,55.14 147.84,55.76 147.84,63.09 147.15,63.78 147.15,63.94 147.16,63.95 147.16,64.9 v2(147.53,65.27)
  BOTTOM w0.089: v2(147.53,65.27) 147.4,65.27 UH1.BB9
  BOTTOM w0.14: v2(202.65,21.94) 202.82,21.77 203.13,21.77 203.38,21.51 203.38,20.29 202.32,19.23 202.32,19.13 202.43,19.03 JDIMM2.76
DDR_B_DQS4: length 99.3
  IN1 w0.079: v2(163.99,65.27) 163.99,65.43 163.86,65.55 163.63,65.55 163.5,65.43 163.5,64.94 163.61,64.83 163.61,63.73 163.86,63.48 163.86,57.23 164.84,56.25 166.97,54.12 169.33,51.77 169.33,47.05 174.33,42.04 191.33,42.04 203.37,30.01 206.99,30.01 210.05,26.95 228.11,26.95 229.81,25.25 229.81,24.91 229.89,24.84 230.17,24.84 230.37,24.63 230.37,24.34 230.17,24.13 229.89,24.13 229.81,24.05 229.81,23.11 229.89,23.02 230.37,23.02 v2(230.6,23.25)
  BOTTOM w0.089: v2(163.99,65.27) 163.86,65.27 UH1.AA9
  BOTTOM w0.14: JDIMM2.179 230.18,25.3 230.1,25.23 230.1,23.19 230.23,23.06 230.41,23.06 v2(230.6,23.25)
DDR_B_DQS5: length 101.2
  IN1 w0.079: v2(236.44,21.36) 236.44,21.52 236.35,21.61 236.09,21.61 235.86,21.85 235.86,24.59 232.79,27.66 232.79,28.25 229.29,31.75 224.17,31.75 223.43,32.49 209.64,32.49 208.42,33.71 204.76,33.71 193.25,45.23 192.83,45.65 176.52,45.65 174.69,47.47 174.69,49.72 171.38,53.03 171.38,53.28 166.27,58.39 166.27,63.6 166.2,63.67 166.2,64.88 166.13,64.95 165.99,64.95 165.83,64.8 v2(165.83,64.64)
  BOTTOM w0.076: UH1.V9 166.33,64.89 166.33,64.66 166.25,64.59 165.89,64.59 v2(165.83,64.64)
  BOTTOM w0.14: v2(236.44,21.36) 236.29,21.51 236,21.51 235.81,21.32 235.81,19.81 235.31,19.32 235.31,19.11 235.44,18.98 JDIMM2.200
DDR_B_DQS6: length 101.3
  IN1 w0.079: v2(169.48,65.27) 169.48,65.36 169.31,65.53 169.06,65.53 168.92,65.39 168.92,65.04 169.1,64.86 169.1,59.3 169.38,59.01 169.42,59.01 172.53,55.91 173.8,55.91 175.64,54.06 176.47,54.06 180.97,49.56 194.45,49.56 196.81,47.21 197.63,47.21 199.19,45.64 199.19,44.82 206.34,37.67 210.01,37.67 210.64,37.03 210.95,37.03 211.14,36.84 211.14,36.53 211.27,36.41 230.42,36.41 238.7,28.13 238.7,27.31 241.31,24.7 241.31,23.11 241.36,23.06 241.49,23.06 v2(241.7,23.27)
  BOTTOM w0.089: v2(169.48,65.27) 169.35,65.27 UH1.P9
  BOTTOM w0.14: v2(241.7,23.27) 241.59,23.15 241.34,23.15 241.27,23.23 241.27,24.66 240.6,25.33 240.6,25.44 240.67,25.52 JDIMM2.221
DDR_B_DQS7: length 103.1
  IN1 w0.079: v2(247.29,21.36) 247.29,21.5 247.17,21.62 246.46,21.62 246.28,21.8 246.28,22.46 246.91,23.09 246.91,25.28 244.28,27.91 244.28,28.04 232.31,40.01 216.28,40.01 215.02,41.27 209.49,41.27 199.44,51.32 197.91,51.32 195.96,53.27 194.69,53.27 191.45,56.51 191.45,56.73 187.56,60.62 183.27,60.62 183.05,60.84 182.5,60.84 182.49,60.86 177.45,60.86 177.12,60.52 176.57,60.52 176.3,60.79 175.15,60.79 173.99,61.96 173.71,61.96 173.12,62.54 173.12,62.66 172.24,63.54 171.98,63.54 171.62,63.9 171.62,64.73 171.47,64.88 171.29,64.88 171.16,64.74 171.16,64.67 v2(171.26,64.56)
  BOTTOM w0.076: v2(171.26,64.56) 171.64,64.95 UH1.L9
  BOTTOM w0.14: v2(247.29,21.36) 247.29,21.36 246.96,21.36 246.86,21.26 246.86,20.13 245.93,19.2 JDIMM2.242
DDR_B_DQS#0: length 90.6
  IN1 w0.079: v2(139.08,65.79) 138.94,65.79 138.8,65.65 138.8,65.38 138.63,65.21 137.88,65.21 137.18,65.91 136.5,65.91 136.05,65.46 136.05,65.06 134.4,63.41 134.4,46.36 147.62,33.14 156.4,33.14 163.19,26.35 175.23,26.35 175.89,25.68 183.62,25.68 184.81,24.48 184.81,23.02 184.9,22.93 185.07,22.93 185.23,23.1 v2(185.23,23.21)
  BOTTOM w0.076: UH1.BP9 138.75,65.19 138.85,65.1 138.98,65.1 139.08,65.19 v2(139.08,65.79)
  BOTTOM w0.14: v2(185.23,23.21) 185.43,23.01 185.69,23.01 185.83,23.15 185.83,24.61 186.28,25.06 186.28,25.45 186.18,25.55 JDIMM2.11
DDR_B_DQS#1: length 90.1
  IN1 w0.079: v2(190.89,21.3) 190.66,21.54 190.46,21.54 190.31,21.69 190.31,24.35 186.81,27.86 186.81,28.3 185.36,29.75 178.51,29.75 177.67,30.59 165.02,30.59 157.56,38.05 147.8,38.05 138.71,47.15 138.71,50.49 137.9,51.3 137.9,55.33 141.07,58.49 141.07,60.56 140.57,61.05 140.57,62.38 140.78,62.59 140.78,65.54 v2(141.16,65.92)
  BOTTOM w0.076: UH1.BL9 v2(141.16,65.92)
  BOTTOM w0.14: JDIMM2.32 191.43,18.98 191.48,19.04 191.48,21.21 191.28,21.41 191,21.41 v2(190.89,21.3)
DDR_B_DQS#2: length 92.1
  IN1 w0.079: v2(143.87,65.27) 143.87,65.43 143.96,65.52 144.24,65.52 144.32,65.43 144.32,65.05 144.24,64.97 144.24,62.79 144.75,62.28 144.75,57.95 143.23,56.42 143.23,47.94 148.71,42.46 149.42,42.46 149.59,42.63 149.59,42.93 149.67,43.01 149.9,43.01 149.98,42.93 149.98,42.63 150.15,42.46 150.52,42.46 150.69,42.63 150.69,42.93 150.76,43.01 151,43.01 151.08,42.93 151.08,42.63 151.25,42.46 151.61,42.46 151.78,42.63 151.78,42.93 151.89,43.03 152.07,43.03 152.18,42.93 152.18,42.63 152.35,42.46 158.47,42.46 166.58,34.35 187.98,34.35 193.65,28.68 193.65,27.36 197.15,23.86 197.15,23.11 197.04,23 196.82,23 v2(196.61,23.21)
  BOTTOM w0.089: v2(143.87,65.27) 143.74,65.27 UH1.BG9
  BOTTOM w0.14: JDIMM2.53 196.67,25.52 196.77,25.42 196.77,25.08 197.08,24.76 197.08,23.24 196.95,23.1 196.72,23.1 v2(196.61,23.21)
DDR_B_DQS#3: length 91.8
  IN1 w0.079: v2(146.62,65.27) 146.72,65.38 146.87,65.38 146.99,65.26 146.99,63.72 147.68,63.03 147.68,55.7 148.31,55.07 148.31,50.44 150.96,47.79 158.57,47.79 161.62,44.73 161.86,44.73 162.21,45.08 162.32,45.08 162.49,44.91 162.49,44.8 162.14,44.45 162.14,44.21 162.4,43.95 162.64,43.95 162.99,44.3 163.12,44.3 163.27,44.16 163.27,44.02 162.92,43.67 162.92,43.44 168.23,38.13 189.71,38.13 199.65,28.19 199.65,26.97 202.02,24.61 202.02,21.74 202.19,21.56 202.39,21.56 v2(202.65,21.3)
  BOTTOM w0.089: v2(146.62,65.27) 146.49,65.27 UH1.BC9
  BOTTOM w0.14: v2(202.65,21.3) 202.81,21.46 203,21.46 203.08,21.38 203.08,20.42 202.02,19.36 202.02,19.13 201.92,19.04 JDIMM2.74
DDR_B_DQS#4: length 99.3
  IN1 w0.079: v2(163.08,65.27) 163.34,65 163.34,64.88 163.46,64.77 163.46,63.67 163.71,63.42 163.71,57.17 164.73,56.14 166.86,54.01 169.17,51.7 169.17,46.98 174.27,41.89 191.27,41.89 203.3,29.85 206.92,29.85 209.98,26.79 228.04,26.79 229.65,25.18 229.65,24.85 229.82,24.68 230.1,24.68 230.22,24.57 230.22,24.4 230.1,24.29 229.82,24.29 229.65,24.12 229.65,23.05 229.83,22.87 230.35,22.87 v2(230.6,22.62)
  BOTTOM w0.089: v2(163.08,65.27) 162.94,65.27 UH1.AC9
  BOTTOM w0.14: JDIMM2.177 229.67,25.33 229.8,25.2 229.8,23.06 230.1,22.76 230.46,22.76 v2(230.6,22.62)
DDR_B_DQS#5: length 101.2
  IN1 w0.079: v2(165.83,65.28) 166,65.11 166.19,65.11 166.35,64.95 166.35,63.74 166.43,63.66 166.43,58.46 171.54,53.34 171.54,53.09 174.85,49.78 174.85,47.54 176.58,45.8 192.89,45.8 193.4,45.29 204.83,33.87 208.49,33.87 209.71,32.65 223.49,32.65 224.24,31.9 229.36,31.9 232.95,28.31 232.95,27.72 236.02,24.65 236.02,21.91 236.16,21.77 236.21,21.77 v2(236.44,22)
  BOTTOM w0.076: UH1.W9 165.5,64.95 v2(165.83,65.28)
  BOTTOM w0.14: v2(236.44,22) 236.26,21.82 235.87,21.82 235.5,21.45 235.5,19.94 235.01,19.44 235.01,19.02 234.94,18.96 JDIMM2.198
DDR_B_DQS#6: length 101.3
  IN1 w0.079: v2(241.7,22.63) 241.43,22.9 241.29,22.9 241.15,23.04 241.15,24.63 238.54,27.24 238.54,28.06 230.36,36.25 211.2,36.25 210.98,36.47 210.98,36.77 210.88,36.87 210.58,36.87 209.94,37.51 206.28,37.51 199.03,44.76 199.03,45.58 197.56,47.05 196.74,47.05 194.39,49.41 180.91,49.41 176.41,53.91 175.58,53.91 173.74,55.75 172.47,55.75 169.36,58.86 169.32,58.86 168.94,59.23 168.94,64.79 168.76,64.97 168.76,65.07 v2(168.56,65.27)
  BOTTOM w0.089: v2(168.56,65.27) 168.43,65.27 UH1.R9
  BOTTOM w0.14: JDIMM2.219 240.18,25.46 240.29,25.34 240.29,25.2 240.96,24.53 240.96,23.1 241.22,22.85 241.49,22.85 v2(241.7,22.63)
DDR_B_DQS#7: length 103.3
  IN1 w0.079: v2(171.29,65.24) 171.47,65.06 171.51,65.06 171.78,64.79 171.78,63.96 172.04,63.7 172.3,63.7 173.28,62.72 173.28,62.61 173.77,62.11 174.05,62.11 175.22,60.95 176.36,60.95 176.63,60.68 177.05,60.68 177.38,61.01 182.55,61.01 182.56,61 183.11,61 183.33,60.78 187.62,60.78 191.61,56.79 191.61,56.57 194.76,53.43 196.03,53.43 197.98,51.47 199.51,51.47 209.55,41.43 215.09,41.43 216.35,40.17 232.38,40.17 244.44,28.1 244.44,27.97 247.07,25.35 247.07,23.02 246.44,22.39 246.44,21.86 246.52,21.78 247.07,21.78 v2(247.29,22)
  BOTTOM w0.076: v2(171.29,65.24) 171,64.95 UH1.M9
  BOTTOM w0.14: JDIMM2.240 245.42,19.13 246.55,20.25 246.55,21.38 246.83,21.66 246.96,21.66 v2(247.29,22)
DDR_B_MA0: length 100.1
  IN3 w0.089: 159.82,50 159.82,50.24 158.56,51.49 158.56,53.68 158.28,53.95 158.28,59.35 157.66,59.97 157.66,60.77 158.01,61.12 158.01,62.97 157.1,63.87 157.1,65.09 157.29,65.27 v2(157.59,65.27)
  IN3 w0.122: v2(220.72,21.12) 220.51,20.9 220,20.9 219.66,21.24 219.66,22.01 219.66,22.18 219.66,30.01 210.94,38.73 196.26,38.73 194.6,40.39 168.19,40.39 166.69,41.89 159.82,48.76 159.82,50
  BOTTOM w0.076: v2(157.59,65.27) 157.46,65.27 UH1.AJ9
  BOTTOM w0.221: v2(220.72,21.12) 219.43,19.82 JDIMM2.144
DDR_B_MA1: length 95.7
  IN3 w0.089: 156.48,50 156.48,51.31 155.89,51.9 155.89,54.32 155.76,54.45 155.76,61.52 156.12,61.89 v2(156.12,62.68)
  IN3 w0.122: 156.48,50 156.48,48.25 167.06,37.67 190.56,37.67 190.68,37.55 190.68,36.77 190.81,36.65 191.05,36.65 191.17,36.77 191.17,37.55 191.29,37.67 191.54,37.67 191.66,37.55 191.66,36.77 191.78,36.65 192.03,36.65 192.15,36.77 192.15,37.55 192.27,37.67 192.51,37.67 192.64,37.55 192.64,36.77 192.76,36.65 193,36.65 193.12,36.77 193.12,37.55 193.25,37.67 193.47,37.67 195.13,36.01 209.37,36.01 215.76,29.62 215.76,27.08 216.38,26.46 v2(216.38,24.22)
  BOTTOM w0.076: v2(156.12,62.68) 156.26,62.68 UH1.AK6
  BOTTOM w0.221: v2(216.38,24.22) 216.38,24.64 216.67,24.94 JDIMM2.133
DDR_B_MA2: length 95.3
  IN3 w0.089: v2(156.9,62) 156.49,62 155.93,61.45 155.93,59.31 156.66,58.58 156.66,53.7 156.91,53.45 156.91,50
  IN3 w0.122: 156.91,50 156.91,48.43 167.24,38.1 193.65,38.1 195.31,36.44 209.55,36.44 216.84,29.14 216.84,22.92 v2(218.15,21.62)
  BOTTOM w0.076: UH1.AK5 156.85,62 v2(156.9,62)
  BOTTOM w0.221: JDIMM2.132 216.43,19 217.11,19.69 217.11,20.61 218.12,21.62 v2(218.15,21.62)
DDR_B_MA3: length 95.5
  IN3 w0.089: v2(155.34,62.01) 155.58,61.77 155.58,54.38 155.71,54.24 155.71,51.39 156.06,51.05 156.06,50
  IN3 w0.122: v2(216.38,22.95) 215.95,23.38 215.95,26.28 215.33,26.9 215.33,29.45 209.19,35.59 194.21,35.59 194.09,35.71 194.09,36.1 193.97,36.22 193.72,36.22 193.6,36.1 193.6,35.71 193.48,35.59 193.23,35.59 193.11,35.71 193.11,36.1 192.99,36.22 192.75,36.22 192.62,36.1 192.62,35.71 192.5,35.59 192.26,35.59 192.14,35.71 192.14,36.1 192.01,36.22 191.77,36.22 191.65,36.1 191.65,35.71 191.53,35.59 187.91,35.59 186.24,37.25 166.88,37.25 156.06,48.08 156.06,50
  BOTTOM w0.076: v2(155.34,62.01) 155.67,62.34 UH1.AL5
  BOTTOM w0.221: JDIMM2.131 216.18,25.18 215.85,24.86 215.85,23.45 216.36,22.95 v2(216.38,22.95)
DDR_B_MA4: length 96.6
  IN3 w0.089: 154.86,50 154.7,50.17 154.7,58.7 154.09,59.3 154.09,62.78 154.34,63.03 154.97,63.03 v2(155.34,62.66)
  IN3 w0.122: 154.86,50 155.2,49.66 155.2,47.72 166.53,36.39 185.89,36.39 187.56,34.73 208.64,34.73 214.48,28.89 214.48,26.55 215.1,25.93 215.1,21.69 v2(216.38,20.41)
  BOTTOM w0.076: UH1.AL6 155.67,62.99 v2(155.34,62.66)
  BOTTOM w0.221: v2(216.38,20.41) 216.38,19.81 215.99,19.42 215.91,19.42 215.43,18.93 JDIMM2.128
DDR_B_MA5: length 96.4
  IN3 w0.089: v2(154.5,62.66) 154.91,62.25 154.91,61.93 155.4,61.44 155.4,58.87 154.87,58.35 154.87,50.59 155.47,50
  IN3 w0.122: 155.47,50 155.63,49.84 155.63,47.9 166.71,36.82 186.07,36.82 187.73,35.16 208.87,35.16 214.9,29.12 214.9,26.72 215.53,26.1 215.53,23 215.65,22.88 215.85,22.88 215.98,22.75 215.98,22.42 215.85,22.29 215.65,22.29 215.53,22.17 215.53,21.92 215.65,21.79 216.27,21.79 v2(216.38,21.68)
  BOTTOM w0.076: UH1.AM6 154.83,62.99 v2(154.5,62.66)
  BOTTOM w0.221: JDIMM2.126 214.92,19.22 215.26,19.55 215.26,20.61 216.32,21.68 v2(216.38,21.68)
DDR_B_MA6: length 96.2
  IN3 w0.089: 154.25,50 154.25,58.61 153.86,59 153.86,62.98 154.36,63.47 v2(154.85,63.47)
  IN3 w0.122: v2(214.14,22.87) 214.59,22.87 214.67,22.95 214.67,25.75 213.57,26.85 213.57,29.18 208.45,34.3 187.38,34.3 185.71,35.97 166.35,35.97 154.48,47.84 154.48,48.05 154.74,48.31 154.74,48.5 154.61,48.62 154.34,48.62 154.25,48.72 154.25,48.99 154.37,49.11 154.63,49.11 154.75,49.23 154.75,49.47 154.63,49.6 154.37,49.6 154.25,49.72 154.25,50
  BOTTOM w0.076: UH1.AN7 154.67,63.65 v2(154.85,63.47)
  BOTTOM w0.221: v2(214.14,22.87) 215.18,23.9 JDIMM2.127
DDR_B_MA7: length 98
  IN3 w0.089: v2(154.85,65.92) 154.48,65.56 154.48,64.37 154.19,64.09 154.19,63.82 153.48,63.11 153.48,58.48 153.4,58.4 153.4,50
  IN3 w0.122: 153.4,50 153.4,47.72 166,35.11 185.36,35.11 187.03,33.45 207.56,33.45 211.5,29.51 211.5,27.72 213.7,25.51 213.7,21.97 v2(214.14,21.52)
  BOTTOM w0.076: UH1.AN10 154.71,65.92 v2(154.85,65.92)
  BOTTOM w0.221: v2(214.14,21.52) 214.23,21.52 214.63,21.13 214.63,19.76 213.92,19.06 JDIMM2.122
DDR_B_MA8: length 96.1
  IN3 w0.089: v2(154.82,64.02) 154.46,64.02 154.37,63.93 154.37,63.75 153.66,63.03 153.66,58.58 153.82,58.42 153.82,50
  IN3 w0.122: v2(214.16,24.23) 214.25,24.32 214.25,25.57 213.15,26.67 213.15,27 212.65,27.5 212.31,27.5 212.19,27.63 212.19,27.84 212.31,27.96 212.58,27.96 212.71,28.09 212.71,28.32 212.58,28.45 212.05,28.45 211.92,28.58 211.92,28.81 212.05,28.94 212.72,28.94 212.85,29.07 212.85,29.3 212.72,29.43 212.19,29.43 211.81,29.8 211.81,30.34 211.64,30.5 211.11,30.5 210.94,30.68 210.94,30.85 211.03,30.94 211.03,31.11 210.86,31.29 210.69,31.29 210.59,31.19 210.42,31.19 210.25,31.37 210.25,31.54 210.34,31.63 210.34,31.8 210.17,31.98 210,31.98 209.9,31.88 209.73,31.88 209.56,32.06 209.56,32.23 209.65,32.32 209.65,32.49 208.27,33.87 187.2,33.87 185.54,35.54 166.18,35.54 153.82,47.9 153.82,50
  BOTTOM w0.076: UH1.AN8 154.55,64.3 v2(154.82,64.02)
  BOTTOM w0.221: JDIMM2.125 214.67,24.75 v2(214.16,24.23)
DDR_B_MA9: length 96.9
  IN3 w0.089: v2(153.01,65.87) 153.56,65.32 153.56,63.69 153.03,63.16 153.03,58.75 152.79,58.52 152.79,50.65 152.54,50.4 152.54,50
  IN3 w0.122: 152.54,50 152.54,47.37 165.65,34.26 185.01,34.26 186.67,32.59 207.04,32.59 209.95,29.69 209.95,27.07 212.51,24.51 212.51,23.17 v2(212.08,22.74)
  BOTTOM w0.076: v2(153.01,65.87) 152.63,66.25 UH1.AR11
  BOTTOM w0.221: v2(212.08,22.74) 213.14,23.8 213.14,24.28 213.67,24.82 JDIMM2.121
DDR_B_MA10: length 98.4
  IN3 w0.089: 161.45,50 159.34,52.11 159.34,53.91 158.98,54.28 158.98,59.41 158.41,59.98 158.41,60.77 158.54,60.9 158.54,63.93 v2(158.5,63.97)
  IN3 w0.122: 161.45,50 161.45,48.94 164.67,45.72 166.09,45.72 168.1,43.71 168.1,43.54 167.88,43.32 167.88,43.14 168.05,42.97 168.23,42.97 168.45,43.19 168.62,43.19 170.14,41.67 195.13,41.67 196.79,40.01 211.47,40.01 220.94,30.54 220.94,26.34 221.2,26.07 221.2,20.26 v2(220.71,19.76)
  BOTTOM w0.076: v2(158.5,63.97) 158.37,63.97 UH1.AH7
  BOTTOM w0.221: JDIMM2.146 221.93,19.07 221.24,19.76 v2(220.71,19.76)
DDR_B_MA11: length 100.3
  IN3 w0.089: 152.97,50 152.97,50.21 153.13,50.37 153.13,58.5 153.25,58.62 153.25,63.13 153.98,63.86 153.98,64.12 154.3,64.45 154.3,66.03 v2(154.85,66.57)
  IN3 w0.122: 152.97,50 152.97,47.54 165.82,34.69 185.18,34.69 186.85,33.02 207.38,33.02 211.07,29.33 211.07,27.54 213.28,25.33 213.28,23.35 213.15,23.22 213.06,23.22 212.93,23.1 212.93,22.86 213.06,22.74 213.15,22.74 213.28,22.61 213.28,22.38 213.15,22.25 212.78,22.25 212.65,22.12 212.65,21.97 212.78,21.84 213.15,21.84 213.28,21.71 213.28,21.14 v2(214.16,20.25)
  BOTTOM w0.076: UH1.AN11 154.71,66.57 v2(154.85,66.57)
  BOTTOM w0.221: JDIMM2.120 213.43,19.8 213.88,20.25 v2(214.16,20.25)
DDR_B_MA12: length 94.9
  IN3 w0.089: 152.09,50 152.09,54 152.03,54.06 152.03,59.66 152.8,60.43 152.8,63.18 153.38,63.76 153.38,64.9 v2(153.02,65.26)
  IN3 w0.122: 152.09,50 152.09,47.21 165.47,33.83 184.83,33.83 186.5,32.17 205.88,32.17 206.2,31.85 206.37,31.85 206.68,32.16 206.85,32.16 207.02,31.99 207.02,31.82 206.71,31.51 206.71,31.34 206.89,31.16 207.06,31.16 207.37,31.47 207.54,31.47 207.71,31.3 207.71,31.13 207.4,30.82 207.4,30.65 209.52,28.53 209.52,26.9 212.08,24.33 v2(212.08,24.09)
  BOTTOM w0.076: v2(153.02,65.26) 152.68,65.6 UH1.AR10
  BOTTOM w0.221: v2(212.08,24.09) 213.18,25.19 JDIMM2.119
DDR_B_MA13: length 100.3
  IN3 w0.089: v2(160.33,65.27) 159.75,64.69 159.75,63.78 160.15,63.38 160.15,60.66
  IN3 w0.122: v2(225.02,19.99) 223.56,19.99 223.43,20.11 223.43,20.33 223.56,20.45 224.06,20.45 224.18,20.57 224.18,20.82 224.06,20.94 223.58,20.94 223.46,21.07 223.46,21.3 223.58,21.43 224.06,21.43 224.15,21.52 224.15,28.68 223.82,29.02 223.82,31.61 212.63,42.8 197.95,42.8 196.28,44.47 173.03,44.47 164.74,52.75 164.44,52.75 161.21,55.98 161.21,59.6 160.15,60.66
  BOTTOM w0.076: UH1.AF9 160.01,64.95 v2(160.33,65.27)
  BOTTOM w0.221: JDIMM2.158 224.93,19.22 225.02,19.31 v2(225.02,19.99)
DDR_B_PAR: length 97.9
  IN3 w0.089: 160.41,50 160.41,50.11 158.83,51.69 158.83,53.72 158.58,53.97 158.58,59.3 157.84,60.04 157.84,60.7 158.19,61.05 158.19,63.04 157.59,63.64 v2(157.59,63.97)
  IN3 w0.122: v2(220.75,22.64) 220.57,22.46 220.21,22.46 220.09,22.58 220.09,30.19 211.12,39.16 196.43,39.16 194.77,40.82 168.37,40.82 160.4,48.78 160.4,49.99 160.41,50
  BOTTOM w0.076: v2(157.59,63.97) 157.46,63.97 UH1.AJ7
  BOTTOM w0.221: JDIMM2.143 219.19,23.37 219.92,22.64 v2(220.75,22.64)
DDR_B_RAS#: length 98.3
  IN3 w0.089: v2(158.5,65.92) 158.87,65.55 158.87,65 159.04,64.83 159.04,63.65 158.9,63.5 158.9,60.57 159.43,60.04 159.43,54.61 159.75,54.29 160.36,54.29
  IN3 w0.122: v2(222.65,21.51) 222.05,22.1 222.05,26.43 221.79,26.69 221.79,30.89 211.82,40.86 197.14,40.86 195.48,42.53 171.91,42.53 164.47,49.97 164.47,50.49 160.66,54.29 160.36,54.29
  BOTTOM w0.076: UH1.AH10 158.37,65.92 v2(158.5,65.92)
  BOTTOM w0.221: JDIMM2.152 223.43,20.73 v2(222.65,21.51)
DDR_B_WE#: length 94.3
  IN3 w0.089: v2(158.5,66.57) 159.05,66.03 159.05,65.23 159.31,64.97 159.31,63.65 159.08,63.43 159.08,60.77 159.24,60.61
  IN3 w0.122: 159.24,60.61 160.49,59.36 160.49,55.19 165.49,50.19 165.49,49.86 172.4,42.95 195.66,42.95 197.32,41.29 212,41.29 222.3,30.99 222.3,26.89 222.64,26.56 222.64,24.23 v2(222.65,24.22)
  BOTTOM w0.076: v2(158.5,66.57) 158.37,66.57 UH1.AH11
  BOTTOM w0.221: v2(222.65,24.22) 222.64,24.22 223.18,24.75 JDIMM2.151
DDR_CKE0_DIMMA: length 50
  IN6 w0.117: v2(133.91,24.37) 133.83,24.45 133.83,29.14 133.96,29.27 134.16,29.27 134.28,29.4 134.28,29.59 134.16,29.71 133.96,29.71 133.83,29.84 133.83,30.06 133.96,30.19 134.64,30.19 134.77,30.32 134.77,30.53 134.64,30.66 133.96,30.66 133.83,30.79 133.83,31 133.96,31.13 134.64,31.13 134.77,31.25 134.77,31.57 134.64,31.69 134.01,31.69 133.89,31.82 133.89,32.03 134.01,32.16 134.59,32.16 134.71,32.28 134.71,32.86 143.16,41.32 143.16,41.96 147.32,46.12 147.32,47.81 147.76,48.25 147.76,48.42 147.43,48.76 147.43,48.92 147.59,49.09 147.76,49.09 148.09,48.75 148.26,48.75 148.57,49.06 148.57,52.69 148.93,53.06 148.93,54.35 v2(149.54,54.95)
  BOTTOM w0.076: v2(149.54,54.95) 150.02,55.44 150.02,56.75 151.49,58.21 UH1.AT1
  BOTTOM w0.221: JDIMM1.109 134.37,25.44 133.91,24.98 v2(133.91,24.37)
DDR_CKE1_DIMMA: length 51.2
  IN6 w0.117: v2(133.92,23.04) 133.41,23.56 133.41,31.18 133.47,31.24 133.47,32.21 142.74,41.49 142.74,42.14 146.9,46.3 146.9,49.03 147.63,49.76 147.63,52.87 148.15,53.39 148.15,54.7 v2(149.51,56.06)
  BOTTOM w0.076: UH1.AT2 151.2,60.09 151.2,58.16 149.51,56.47 v2(149.51,56.06)
  BOTTOM w0.221: JDIMM1.110 134.62,18.97 134.22,19.37 133.76,19.37 133.16,19.97 133.16,22.38 133.83,23.04 v2(133.92,23.04)
DDR_CKE2_DIMMB: length 101.1
  IN3 w0.089: v2(152.11,64.01) 151.88,64.01 150.32,62.44 150.32,60.14 149.13,58.95 ; 149.12,50 149.12,55.32
  IN3 w0.122: v2(210.23,21.45) 210.21,21.47 208.92,21.47 208.66,21.73 208.66,22.23 208.54,22.35 208.15,22.35 208.03,22.47 208.03,22.71 208.15,22.84 208.54,22.84 208.66,22.96 208.66,23.18 208.48,23.36 208.14,23.36 208.02,23.48 208.02,23.73 208.14,23.85 208.59,23.85 208.72,23.97 208.72,24.21 208.59,24.34 207.95,24.34 207.83,24.46 207.83,25.1 205.11,27.82 205.11,28.86 204.27,29.7 185.48,29.7 183.81,31.37 164.45,31.37 149.12,46.69 149.12,50 ; 149.12,55.32 149.13,55.32 149.13,58.95
  BOTTOM w0.089: v2(152.11,64.01) 151.94,64.01 UH1.AT8
  BOTTOM w0.221: v2(210.23,21.45) 209.44,22.24 209.44,24.12 210.67,25.35 JDIMM2.109
DDR_CKE3_DIMMB: length 100
  IN3 w0.089: 148.82,58.95 150.04,60.17 150.04,62.56 151.74,64.26 151.74,65.56 v2(152.1,65.92) ; 148.64,50 148.64,55.13
  IN3 w0.122: 148.82,58.95 148.82,55.32 148.64,55.13 ; 148.64,50 148.64,46.58 164.27,30.94 183.63,30.94 185.3,29.28 204.1,29.28 204.69,28.69 204.69,27.64 206.72,25.61 206.72,25.44 206.57,25.29 206.57,25.12 206.74,24.94 206.91,24.94 207.06,25.09 207.23,25.09 207.41,24.92 207.41,20.44 207.84,20.01 v2(210.23,20.01)
  BOTTOM w0.089: UH1.AT10 151.97,65.92 v2(152.1,65.92)
  BOTTOM w0.221: JDIMM2.110 210.92,19.32 v2(210.23,20.01)
DDR_CS0_DIMMA#: length 55.2
  IN6 w0.089: v2(161.19,62.01) 160.91,62.29 158.91,62.29 158.79,62.16 158.79,51.13 159.92,50
  IN6 w0.117: 159.92,50 159.92,45.24 158.66,43.99 158.66,41.95 150.12,33.41 150.12,31.49 148.15,29.52 148.15,24.94 147.25,24.05 147.25,21.78 147.18,21.7 146.96,21.7 146.88,21.78 146.88,23.11 146.74,23.25 v2(146.47,23.25)
  BOTTOM w0.076: v2(161.19,62.01) 161.51,62.34 UH1.AD5
  BOTTOM w0.221: v2(146.47,23.25) 146.05,23.25 145.87,23.43 145.87,24.97 146.37,25.47 JDIMM1.149
DDR_CS1_DIMMA#: length 57.6
  IN6 w0.117: v2(159.94,53.16) 160.24,53.16 163.07,50.33 163.07,49.64 163.18,49.52 163.29,49.52 163.41,49.39 163.41,49.18 163.29,49.05 163.18,49.05 163.07,48.94 163.07,48.7 163.18,48.59 163.29,48.59 163.41,48.46 163.41,48.25 163.29,48.12 163.18,48.12 163.07,48 163.07,47.77 163.18,47.65 163.3,47.65 163.41,47.54 163.41,47.3 163.3,47.18 163.18,47.18 163.07,47.07 163.07,46.83 163.18,46.72 163.3,46.72 163.41,46.6 163.41,46.37 163.3,46.25 163.18,46.25 163.07,46.13 163.07,45.9 163.18,45.78 163.29,45.78 163.41,45.66 163.41,45.44 163.29,45.32 163.12,45.32 162.99,45.19 162.99,44.97 163.12,44.84 163.29,44.84 163.41,44.71 163.41,44.51 163.29,44.38 162.94,44.38 162.81,44.26 162.81,44.06 163.17,43.71 163.17,43.53 163.01,43.37 162.84,43.37 162.48,43.73 162.32,43.73 162.15,43.56 162.15,43.4 162.59,42.95 162.59,42.77 162.46,42.64 162.28,42.64 161.85,43.08 161.67,43.08 161.47,42.88 161.47,42.7 161.67,42.5 161.86,42.31 161.86,42.04 161.43,41.61 161.43,40.8 154.38,33.75 154.38,31.55 153.48,30.66 153.32,30.66 153.22,30.75 153.04,30.75 152.89,30.6 152.89,30.42 152.99,30.32 152.99,30.16 151.76,28.93 151.76,27 151.88,26.89 151.98,26.89 152.1,26.76 152.1,26.55 151.98,26.42 151.88,26.42 151.76,26.3 151.76,26.07 151.88,25.95 152.16,25.95 152.29,25.83 152.29,25.61 152.16,25.49 151.88,25.49 151.76,25.37 151.76,25.08 151.24,24.56 151.24,23.13 151.09,22.98 150.87,22.98 150.74,23.1 v2(150.74,23.22)
  BOTTOM w0.076: v2(159.94,53.16) 159.84,53.06 159.73,53.06 159.55,53.24 159.55,56.78 160.52,57.75 160.52,58.38 160.65,58.51 160.65,59.49 160.53,59.6 160.53,60.32 160.64,60.44 160.76,60.44 UH1.AE2
  BOTTOM w0.221: v2(150.74,23.22) 150.51,22.99 150.36,22.99 148.37,24.98 JDIMM1.157
DDR_CS2_DIMMB#: length 97.1
  IN3 w0.089: v2(160.31,65.89) 159.92,65.5 159.92,65.28 159.53,64.9 159.53,63.73 159.86,63.4 159.86,62.79 159.86,60.5
  IN3 w0.122: v2(222.65,22.95) 223.39,23.69 223.39,28.37 223.06,28.7 223.06,31.3 212.31,42.05 197.63,42.05 195.97,43.71 172.71,43.71 160.87,55.55 160.87,59.49 159.86,60.5
  BOTTOM w0.076: UH1.AF11 159.96,66.25 v2(160.31,65.89)
  BOTTOM w0.221: v2(222.65,22.95) 222.42,22.95 221.77,23.59 221.77,24.58 222.67,25.49 JDIMM2.149
DDR_CS3_DIMMB#: length 99.7
  IN3 w0.122: v2(161.18,63.3) 161.18,63.18 161.58,62.78 161.58,61.06 162.94,59.7 162.94,57.7 169.57,51.06 171.19,51.06 174.31,47.94 183.51,47.94 183.63,47.82 183.63,47.48 183.75,47.35 184,47.35 184.12,47.48 184.12,47.82 184.24,47.94 184.48,47.94 184.6,47.82 184.6,47.48 184.73,47.35 184.97,47.35 185.09,47.48 185.09,47.82 185.21,47.94 185.51,47.94 185.64,47.81 185.64,47.45 185.76,47.33 186,47.33 186.13,47.45 186.13,47.82 186.25,47.94 186.49,47.94 186.61,47.82 186.61,47.45 186.74,47.33 186.98,47.33 187.1,47.45 187.1,47.82 187.22,47.94 187.47,47.94 187.59,47.82 187.59,47.45 187.71,47.33 187.95,47.33 188.08,47.45 188.08,47.82 188.2,47.94 188.44,47.94 188.56,47.82 188.56,47.45 188.69,47.33 199.75,47.33 202.04,45.03 212.68,45.03 226.13,31.58 226.13,27.59 225.82,27.28 225.82,27.14 225.93,27.02 226.28,27.02 226.4,26.89 226.4,26.59 226.28,26.46 225.94,26.46 225.82,26.34 225.82,26.1 225.94,25.98 226.28,25.98 226.4,25.85 226.4,25.62 226.28,25.49 225.94,25.49 225.82,25.37 225.82,23.75 v2(226.26,23.32)
  BOTTOM w0.076: UH1.AE7 161.14,63.3 v2(161.18,63.3)
  BOTTOM w0.221: v2(226.26,23.32) 224.67,24.9 JDIMM2.157
DDR_VTT_PG_CTRL: length 27.1
  TOP w0.089: 134.96,65.8 134.96,66.55 v2(135.53,67.12)
  TOP w0.127: 134.96,65.8 134.67,65.51 134.67,64.13 134.02,63.48 129.69,63.48 129.33,63.84 126.16,63.84 123.75,61.43 123.75,57.39 v3(124.82,56.32)
  TOP w0.14: v3(124.82,56.32) 125.82,55.32 125.82,54.07 125.6,53.86 UC1.2
  BOTTOM w0.102: UH1.BT13 136.64,67.76 136,67.12 v2(135.53,67.12)
DGPU_HOLD_RST#: length 168
  TOP w0.14: UV19.1 226.62,42.83 226.56,42.77 RV580.2 226.56,42.6 226.07,42.12 v2(226,42.12)
  IN5 w0.089: 101.98,13.07 101.8,13.07 100.78,12.04 99.37,12.04 99.03,12.39 96.72,12.39 95.89,13.21 92.74,13.21 91.03,11.5 84.83,11.5 83.75,10.42 v2(82.23,10.42)
  IN5 w0.099: 101.98,13.07 106.03,13.07 106.34,12.76 108.12,12.76 108.76,12.13 113.59,12.13 114.12,12.66 115.8,12.66 116.68,11.78 122.19,11.78 123.07,12.66 145.73,12.66 145.91,12.48 149.07,12.48 149.42,12.83 160.88,12.83 161.16,13.1 175.4,13.1 181.33,19.04 181.33,20.5 181.5,20.67 v2(181.5,23.35)
  IN6 w0.099: v2(226,42.12) 225.5,41.63 193.9,41.63 182.84,30.57 182.84,24.69 v2(181.5,23.35)
  BOTTOM w0.089: v2(82.23,10.42) 81.89,10.76 UH2.AL36
DGPU_PEX_RST#: length 57.7
  TOP w0.508: v2(201.83,43.95) 201.83,43.32 201.41,42.9 RV1131.2 ; RV587.2 223.75,42.13 v2(223.29,42.59)
  IN6 w0.508: v2(220.56,42.59) v2(223.29,42.59)
  BOTTOM w0.508: v2(220.14,43.09) 219.05,42 209.69,42 207.73,43.95 v2(201.83,43.95) 200.67,42.8 197.56,42.8 196.23,44.13 196.23,47.47 196.9,48.14 199.25,48.14 199.75,48.64 199.75,50.19 198.81,51.13 197.51,51.13 195.45,53.18 v1(195.45,54.35) 195.45,55.25 194.08,56.63 194.08,58.25 192.77,59.56 191.44,59.56 191.04,59.96 RV577.1 191.04,61.22 RV589.1
DGPU_PEX_RST#_R: length 12.8
  BOTTOM w0.102: UV18.AJ12 199.11,66.77 199.11,64.51 198.91,64.3 196.88,64.3 196.66,64.08 196.66,62.08 196.4,61.81 194.49,61.81 194.16,61.48
  BOTTOM w0.14: 194.16,61.48 193.66,60.98 v1(193.09,60.98) 192.2,60.98 RV577.2
DGPU_PWR_EN: length 287.2
  TOP w0.14: QV3.2 249.75,46.05 250,45.79 v1(251.64,45.79) v2(253.95,45.79)
  TOP w0.254: v2(243,103.8) 242.65,103.45 242.65,103.13 242.55,103.03 QV87.2
  IN5 w0.089: v2(77.28,11.56) 78,10.84 80.21,10.84 v2(80.67,11.3) 81.32,11.95 84.9,11.95 85.54,12.58 90.56,12.58 92.27,14.29 95.58,14.29 96.81,13.06 100.69,13.06 101.1,13.47 101.98,13.47
  IN5 w0.099: 101.98,13.47 106.2,13.47 106.43,13.24 114.5,13.24 114.68,13.06 115.97,13.06 116.85,12.18 122.02,12.18 122.91,13.06 128.95,13.06 129.12,13.23 145.72,13.23 146.08,12.88 148.9,12.88 149.26,13.23 160.72,13.23 161.07,13.59 175.31,13.59 180.52,18.8 180.52,22.09 v2(180.72,22.3)
  IN6 w0.099: v2(180.72,22.3) 180.5,22.52 180.5,23.9 182.04,25.45 182.04,30.9 194.51,43.37 208.05,43.37 209.68,45 217.19,45 217.57,44.62 222.56,44.62 222.97,45.03 226.22,45.03 226.66,45.46 231.47,45.46 232.2,44.73 233.19,44.73 234.82,43.1 239.14,43.1 240.15,44.1 243.24,44.1 246.12,41.23 253.79,41.23 254.28,41.72 254.28,45.46 v2(253.95,45.79) 254.27,46.11 254.27,49.99 253.09,51.18 253.09,53.57 251.91,54.75 251.91,59.38 251.4,59.89 251.4,95.46 250.25,96.61 250.25,97.63 248.65,99.23 246.98,99.23 245.11,101.1 245.11,102.12 243.43,103.8 v2(243,103.8)
  BOTTOM w0.089: UH2.AJ39 80.67,11.65 v2(80.67,11.3) ; 75.72,11.72 76.11,11.33 77.04,11.33 v2(77.28,11.56)
  BOTTOM w0.127: RH537.1 RH538.1 72.34,12.35 73.66,12.35 73.84,12.18 74.82,12.18 75.22,11.77 75.67,11.77 75.72,11.72
  BOTTOM w0.254: PR1403.1 243.71,103.7 243.62,103.8 v2(243,103.8)
DGPU_PWR_EN#: length 74.6
  TOP w0.14: RV399.2 247.74,48.46 RV657.2 247.83,48.39 QV3.6 v1(249.1,49.75) 249.1,50.26 v2(250.9,52.07)
  TOP w0.254: QV87.1 241.43,100.04 RV181.2 242.33,99.07 243.37,98.03 QV86.2 244.45,98.03 v2(245.38,98.95)
  IN6 w0.099: v2(245.38,98.95) 248.57,98.95 249.89,97.63 249.89,96.48 250.95,95.41 250.95,86.79 ; v2(250.9,52.07) 251.02,52.18 251.02,59.31 250.66,59.67 250.66,69.33 250.37,69.62 246.3,69.62 244.14,71.78 244.14,75.49 246.03,77.38 250.03,77.38 250.95,78.3 250.95,80.97
  IN6 w0.102: 250.95,86.79 250.95,80.97
DGPU_PWR_EN#_R: length 6.5
  TOP w0.14: v2(255.02,44.2) 254.7,44.52 QZ7.5
  IN1 w0.099: v2(255.02,44.2) 254.69,43.87 250.57,43.87 v2(249.77,44.67)
  vias: v1(249.42,45.28)
DGPU_PWROK: length 283.7
  TOP w0.089: v2(81.46,11.28) v1(81.1,11.64) 80.92,11.82 79.34,11.82 79.24,11.92 78.38,11.92 77.4,10.93 76.15,10.93 RH516.2
  TOP w0.14: v2(198.21,45.13) 197.49,44.41 UV20.2
  TOP w0.254: v2(196.34,115.71) 196.47,115.71 197.11,116.34 197.11,117.8 PR707.2
  IN2 w0.099: v2(194.25,62.68) 194.25,63.38 188.48,69.15 188.48,69.96 187.49,70.94 184.27,70.94 183.06,72.16 183.06,79.24 180.06,82.24 180.06,84.42 178.81,85.68 177.05,85.68 176.53,85.16 175.91,85.16 175.02,86.05 171.58,86.05 170.44,87.19 170.44,89.35 170.41,89.38 169.86,89.92 167,89.92 164.65,92.28 164.65,98.74 166.42,100.51 166.42,103.22 165.79,103.84 165.79,105.96 166.7,106.88 166.7,110.26 167.95,111.5 167.95,112.71 169.53,114.3 169.53,115.4 170.26,116.13 170.26,117.28 170.97,117.99 172.8,117.99 173.78,118.97 174.98,118.97 175.03,118.92 175.71,118.92 176.33,119.54 186.6,119.54 187.03,119.11 195.03,119.11 196.75,117.4 196.75,116.11 v2(196.34,115.71)
  IN5 w0.089: v2(81.46,11.28) 81.9,11.72 90.58,11.72 90.87,12.01 90.87,12.64 91.62,13.39 95.97,13.39 96.8,12.56 99.21,12.56 99.53,12.24 100.71,12.24 101.74,13.27 101.98,13.27
  IN5 w0.099: v2(180.92,19.73) 180.92,18.92 175.35,13.34 161.11,13.34 160.8,13.03 149.34,13.03 148.99,12.68 146,12.68 145.65,13.03 129.2,13.03 129.04,12.86 122.99,12.86 122.11,11.98 116.77,11.98 115.88,12.86 114.04,12.86 113.5,12.33 108.84,12.33 108.19,12.98 106.41,12.98 106.12,13.27 101.98,13.27
  IN6 w0.099: v2(194.25,62.68) 193.79,62.23 193.79,59.79 195.48,58.11 195.48,57.18 195.05,56.75 195.05,46.72 196.55,45.22 198.12,45.22 v2(198.21,45.13) 198.21,45.03 197.05,43.87 193.82,43.87 181.05,31.1 181.05,26.02 179.17,24.14 179.17,21.48 v2(180.92,19.73)
  BOTTOM w0.089: UH2.AJ38 v2(81.46,11.28)
  BOTTOM w0.254: PU700.3 195.81,115.43 196.09,115.71 v2(196.34,115.71)
DH1_NVVDD: length 11.6
  TOP w0.14: v1(164.81,112.81) 164.81,112.99 165.15,113.33 v2(165.39,113.33)
  IN4 w0.762: 166.69,102.82 165.51,104 165.51,108.54 164.75,109.3 164.75,111.6 165.55,112.4
  vias: v2(165.82,113.74) v2(167.15,101.93) v2(167.15,101.29)
DH1_NVVDDS: length 9.2
  TOP w0.14: v2(182.03,112.58) 182.03,112.15 v1(181.74,111.86)
  IN4 w0.762: 188.91,109.93 188.35,109.93 187.34,108.91 185.28,108.91 182.92,111.27 182.92,111.86 182.65,112.12
  vias: v2(181.62,113.01) v2(189.73,110.31) v2(190.21,110.64)
DH2_NVVDD: length 6.5
  TOP w0.14: v2(167.92,107.96) v1(168.61,107.96)
  IN1 w0.762: 168.91,107.83 169.37,108.29 169.37,108.9 170.1,109.64 170.1,109.98 171.71,111.58 171.71,112.53
  vias: v2(167.92,107.32) v2(170.8,113.66) v2(171.36,113.38)
DH_1.2V: length 15.2
  IN6 w1.016: 284.67,29.35 282.32,29.35 280.61,31.06 271.91,31.06 270.7,32.27
  vias: v2(270.75,34.07) v2(270.75,33.47) v2(285.31,28.58) v2(285.75,29.03)
DIMM_CHA_SA0: length 3.5
  TOP w0.14: v2(173.29,16.86) 172.76,17.39 RD28.1 RD1.2
  BOTTOM w0.127: JDIMM1.256 173.12,17.03 173.29,16.86 v2(173.29,16.86)
DIMM_CHA_SA1: length 8.9
  TOP w0.127: v2(173.93,19.82) 174.35,20.24 174.42,20.24 174.75,20.57 174.75,21.43 174.18,22 174.18,23.02 v1(174.33,23.17) 174.52,23.36 RD2.2
  TOP w0.14: RD2.2 175.17,24.17 RD29.1
  BOTTOM w0.127: JDIMM1.260 174.12,19.12 173.93,19.31 v2(173.93,19.82)
DIMM_CHA_SA2: length 3.8
  TOP w0.102: RD30.1 RD3.2
  TOP w0.14: v1(151.26,16.44) 150.88,16.82 v2(150.88,16.86) 150.88,17.33 RD30.1
  BOTTOM w0.127: JDIMM1.166 150.63,17.11 v2(150.88,16.86)
DIMM_CHB_SA0: length 4.2
  TOP w0.127: v2(248.95,16.84) 248.95,17.09 RD4.2 RD38.1
  TOP w0.14: v3(249.15,16.02) 248.95,16.23 v2(248.95,16.84)
  BOTTOM w0.102: JDIMM2.256 249.42,17.32 v2(248.95,16.84)
DIMM_CHB_SA1: length 6.4
  TOP w0.127: 250.09,22.32 v2(250.09,19.8)
  TOP w0.14: 250.09,22.32 250.66,22.89 RD39.1 RD5.2
  BOTTOM w0.127: JDIMM2.260 250.42,19.4 250.09,19.73 v2(250.09,19.8)
DIMM_CHB_SA2: length 4
  TOP w0.127: v2(227.16,16.86) 227.16,17.32 RD40.1
  TOP w0.14: v2(227.16,16.86) v3(227.16,16.09) ; RD40.1 RD6.2
  BOTTOM w0.102: JDIMM2.166 226.93,17.1 v2(227.16,16.86)
DISPOFF#: length 13.9
  TOP w0.127: DV1.1 53.65,27.19 RV107.1 55.42,28.33 57.02,28.33 57.89,27.47 v3(58.93,27.47) 60.11,27.47 v2(60.97,28.33)
  BOTTOM w0.127: JEDP1.24 60.05,32.23 60.01,32.19 60.01,30.46 60.97,29.5 v2(60.97,28.33)
DL1_NVVDD: length 15
  TOP w0.14: v2(166.94,111.45) 166.94,111.44 v1(166.46,110.96)
  IN1 w0.762: 172.91,102.94 172.91,103.88 172.49,104.3 169.76,104.3 167.88,106.18 167.39,106.18 167.07,106.5 165.86,106.5 165.36,107.01 165.36,107.58 165.8,108.02 166.46,108.02 167.01,108.57 167.01,110.5
  vias: v2(167.35,111.88) v2(174.18,102.88) v2(174.82,102.88)
