# Allegro board Dell XPS 9560 LA-E331P R10.brd (continued)
## Nets (continued)
GND: BAT100.8 BAT100.9 BAT100.10 BAT100.11 BAT100.12 C2973.2 C2974.2 CA1.2 CA2.2 CA3.2 CA4.2 CA8.2 CA9.2 CA10.2 CA11.2 CA19.2 CA23.2 CA32.2 CA33.2 CA34.2 CA35.2 CA36.2 CA37.2 CA38.2 CA39.2 CA40.2 CA77.2 CA78.2 CA120.1 CA121.2 CA122.2 CA124.2 CA125.2 CA126.2 CA127.2 CA128.2 CA129.2 CA130.2 CA137.1 CD1.2 CD2.2 CD3.2 CD4.2 CD5.2 CD6.2 CD7.2 CD8.2 CD9.2 CD10.2 CD11.2 CD12.2 CD13.2 CD14.2 CD15.2 CD16.2 CD17.2 CD18.2 CD19.2 CD20.2 CD21.2 CD22.2 CD23.2 CD24.2 CD25.2 CD26.2 CD27.2 CD28.2 CD29.2 CD30.2 CD31.2 CD32.2 CD33.2 CD34.2 CD35.2 CD36.2 CD38.2 CD39.2 CD40.2 CD41.2 CD47.2 CD69.2 CD70.2 CD71.2 CD72.2 CD73.2 CD74.2 CD75.2 CD76.2 CD77.2 CD78.2 CD79.2 CD80.2 CD81.2 CD82.2 CD83.2 CD84.2 CD85.2 CD86.2 CD87.2 CD88.2 CD89.2 CD90.2 CE2.2 CE8.2 CE11.2 CE12.2 CE13.2 CE14.2 CE15.2 CE16.2 CE17.2 CE18.2 CE19.2 CE20.2 CE21.2 CE22.2 CE23.2 CE24.2 CE25.2 CE26.2 CE27.2 CE28.2 CE29.2 CE30.2 CE31.2 CE34.2 CE37.2 CE38.2 CE39.2 CE40.2 CE41.2 CE42.2 CE43.2 CE44.2 CE48.2 CE51.2 CE52.2 CE53.2 CE54.2 CE55.2 CE65.2 CE66.2 CE67.2 CE70.2 CE71.2 CE73.2 CE74.2 CE75.2 CE76.2 CE77.2 CE78.2 CE79.2 CE80.2 CE81.2 CE82.2 CE83.2 CF1.2 CF2.2 CH3.2 CH44.2 CH45.2 CH46.2 CH47.2 CH48.2 CH50.1 CH51.1 CH52.2 CH53.2 CH70.2 CH80.2 CH82.2 CH102.2 CH103.2 CH104.2 CH105.2 CH106.2 CH107.2 CH108.2 CH109.2 CH110.2 CH111.2 CH112.2 CH113.2 CH114.2 CH115.2 CH116.2 CH117.2 CH118.2 CH119.2 CH120.2 CH121.2 CH122.2 CH123.2 CH124.2 CH125.2 CH126.2 CH127.2 CH128.2 CH129.2 CH130.2 CH131.2 CH132.2 CH133.2 CH134.2 CH135.2 CH136.2 CH138.2 CH173.2 CH174.2 CH175.2 CH176.2 CH177.2 CH178.2 CH179.2 CH180.2 CH181.2 CH182.2 CH183.2 CH184.2 CH186.2 CH187.2 CH188.2 CH189.2 CH190.2 CH191.2 CH192.2 CH196.2 CH197.2 CH198.2 CH199.2 CH200.2 CH201.2 CH202.2 CH203.2 CH204.2 CI1.2 CI2.2 CI3.2 CI4.2 CI11.2 CI12.2 CI13.2 CI17.2 CI18.2 CI19.2 CI21.2 CI22.2 CLRP1.2 CN1.2 CN2.2 CN6.2 CN7.2 CN8.2 CN9.2 CN22.2 CR1.2 CR2.2 CR3.2 CR4.2 CR5.2 CR6.2 CR8.2 CR11.2 CR12.2 CR14.2 CR15.2 CR16.2 CR17.2 CR18.2 CS12.2 CS13.2 CS14.2 CS15.2 CT43.2 CT44.2 CT47.2 CT50.2 CT52.2 CT53.2 CT54.2 CT55.2 CT56.2 CT62.2 CT63.2 CT64.2 CT65.2 CT66.2 CT67.2 CT68.2 CT71.2 CT72.2 CT74.2 CT80.2 CT81.2 CT82.2 CT83.2 CT84.2 CT85.2 CT86.2 CT88.2 CT89.2 CT90.2 CT93.2 CT94.2 CT95.2 CT96.2 CT97.2 CT98.2 CT99.2 CT100.2 CT101.2 CT102.2 CT103.2 CT105.2 CT106.2 CT120.1 CT121.1 CT122.2 CT123.2 CT141.2 CT142.2 CT143.2 CT144.2 CT145.2 CT146.2 CT147.2 CT148.2 CT149.2 CT150.2 CT151.2 CT152.2 CT153.2 CT155.2 CT157.2 CT158.2 CT159.2 CT160.2 CT161.2 CT162.2 CT163.2 CT164.2 CT165.2 CT170.2 CT171.2 CT172.2 CT173.2 CV121.2 CV122.2 CV123.2 CV156.2 CV157.2 CV169.2 CV178.2 CV179.2 CV180.1 CV181.1 CV182.1 CV183.2 CV184.2 CV363.2 CV499.2 CV794.2 CV796.2 CV798.2 CV817.2 CV850.2 CV851.2 CV852.2 CV853.2 CV854.2 CV855.2 CV856.2 CV857.1 CV858.1 CV859.2 CV860.2 CV861.2 CV862.2 CV863.2 CV864.1 CV865.2 CV866.2 CV867.2 CV868.1 CV869.2 CV870.2 CV871.2 CV872.2 CV873.1 CV874.2 CV875.2 CV876.2 CV877.2 CV878.2 CV879.2 CV880.1 CV881.1 CV882.2 CV883.1 CV884.1 CV885.2 CV886.2 CV887.2 CV888.2 CV889.2 CV890.2 CV891.2 CV892.2 CV893.2 CV894.2 CV895.2 CV896.1 CV897.1 CV898.2 CV899.2 CV900.2 CV901.2 CV902.2 CV903.2 CV904.2 CV905.2 CV906.2 CV907.2 CV917.2 CV918.2 CV919.2 CV921.2 CV922.2 CV923.2 CV924.2 CV925.2 CV926.2 CV927.2 CV928.2 CV929.2 CV930.2 CV931.2 CV932.2 CV933.2 CV934.2 CV935.2 CV936.2 CV937.2 CV938.2 CV939.2 CV940.2 CV941.2 CV942.2 CV943.2 CV944.2 CV945.2 CV946.2 CV947.2 CV948.2 CV949.2 CV950.2 CV951.2 CV952.2 CV953.2 CV954.2 CV955.2 CV956.2 CV957.2 CV958.2 CV959.2 CV960.2 CV961.2 CV962.2 CV963.2 CV964.2 CV965.2 CV966.2 CV967.2 CV968.2 CV969.2 CV970.2 CV971.2 CV972.2 CV973.2 CV974.2 CV975.2 CV976.2 CV977.2 CV978.2 CV979.2 CV980.2 CV981.2 CV982.2 CV983.2 CV984.2 CV985.2 CV986.2 CV987.2 CV988.2 CV989.2 CV990.2 CV991.2 CV992.2 CV993.2 CV994.2 CV995.2 CV996.2 CV997.2 CV998.2 CV999.2 CV1000.2 CV1001.2 CV1002.2 CV1003.2 CV1004.2 CV1005.2 CV1006.2 CV1007.2 CV1008.2 CV1009.2 CV1010.2 CV1011.2 CV1012.2 CV1013.2 CV1014.2 CV1015.2 CV1016.2 CV1017.2 CV1018.2 CV1019.2 CV1020.2 CV1021.2 CV1022.2 CV1023.2 CV1024.2 CV1025.2 CV1026.2 CV1027.2 CV1028.2 CV1029.2 CV1030.2 CV1031.2 CV1032.2 CV1033.2 CV1034.2 CV1035.2 CV1036.2 CV1037.2 CV1038.2 CV1039.2 CV1040.2 CV1041.2 CV1042.2 CV1043.2 CV1044.2 CV1045.2 CV1046.2 CV1047.2 CV1048.2 CV1049.2 CV1050.2 CV1051.2 CV1500.2 CZ4.2 CZ6.2 CZ8.2 CZ9.2 CZ11.2 CZ12.2 CZ18.2 CZ19.2 CZ20.2 CZ26.2 CZ28.2 CZ29.2 CZ31.2 CZ37.2 CZ39.2 CZ41.2 CZ43.2 CZ44.2 CZ45.2 CZ46.2 CZ47.2 CZ49.2 CZ57.2 CZ82.2 CZ86.2 CZ88.2 CZ96.2 CZ97.2 CZ98.2 CZ99.2 D2.2 D123.2 D124.2 D125.2 D126.2 DA2.2 DA3.2 DA4.2 DA5.2 DA9.2 DE2.1 DE4.1 DE5.1 DE9.1 DI3.1 DI7.3 DI9.3 DI13.1 DL1.1 DT10.1 DT12.2 DT13.2 DT14.2 DT15.2 DT16.2 DT17.2 DT18.2 DT19.2 DT20.2 DT21.2 DT22.2 DT23.2 DT24.2 DT25.2 DT26.2 DT27.2 DT28.2 DT174.2 DV4.3 DV5.3 DV12.2 H1.1(TP-1) H2.1(TP-1) H5.1(TP-1) H9.1(TP-1) H10.1(TP-1) H13.1(TP-1) H16.1(TP-1) H18.1 H19.1 H20.1 H21.1 H22.1 H23.1 H24.1 H25.1 H26.1 H28.1 H30.1 H31.1 H32.1 H33.1 H34.1 H35.1 H37.1(TP-1) H38.1(TP-1) H39.1(TP-1) H40.1(TP-1) H41.1(TP-1) H42.1(TP-1) H43.1(TP-1) H45.1(TP-1) H46.1(TP-1) H48.1(TP-1) H49.1(TP-1) H50.1(TP-1) H51.1(TP-1) H52.1 H53.1 H54.1(TP-1) H55.1(TP-1) H56.1 H57.1 H58.1 JAPS.8 JAPS.10 JAPS.12 JAPS.14 JAPS.19 JAPS.20 JAUDIO.1 JAUDIO.7 JAUDIO.10 JAUDIO.12 JAUDIO.14 JAUDIO.16 JAUDIO.18 JAUDIO.19 JAUDIO.20 JAUDIO.21 JAUDIO.23 JAUDIO.31 JAUDIO.32 JAUDIO.33 JAUDIO.34 JCR.4 JCR.7 JCR.12 JCR.15 JCR.19 JCR.20 JCR.21 JCR.22 JCR.23 JDEG1.10 JDEG1.11 JDEG1.12 JDIMM1.1 JDIMM1.2 JDIMM1.5 JDIMM1.6 JDIMM1.9 JDIMM1.10 JDIMM1.14 JDIMM1.15 JDIMM1.18 JDIMM1.19 JDIMM1.22 JDIMM1.23 JDIMM1.26 JDIMM1.27 JDIMM1.30 JDIMM1.31 JDIMM1.35 JDIMM1.36 JDIMM1.39 JDIMM1.40 JDIMM1.43 JDIMM1.44 JDIMM1.47 JDIMM1.48 JDIMM1.51 JDIMM1.52 JDIMM1.56 JDIMM1.57 JDIMM1.60 JDIMM1.61 JDIMM1.64 JDIMM1.65 JDIMM1.68 JDIMM1.69 JDIMM1.72 JDIMM1.73 JDIMM1.77 JDIMM1.78 JDIMM1.81 JDIMM1.82 JDIMM1.85 JDIMM1.86 JDIMM1.89 JDIMM1.90 JDIMM1.93 JDIMM1.94 JDIMM1.98 JDIMM1.99 JDIMM1.102 JDIMM1.103 JDIMM1.106 JDIMM1.107 JDIMM1.167 JDIMM1.168 JDIMM1.171 JDIMM1.172 JDIMM1.175 JDIMM1.176 JDIMM1.180 JDIMM1.181 JDIMM1.184 JDIMM1.185 JDIMM1.188 JDIMM1.189 JDIMM1.192 JDIMM1.193 JDIMM1.196 JDIMM1.197 JDIMM1.201 JDIMM1.202 JDIMM1.205 JDIMM1.206 JDIMM1.209 JDIMM1.210 JDIMM1.213 JDIMM1.214 JDIMM1.217 JDIMM1.218 JDIMM1.222 JDIMM1.223 JDIMM1.226 JDIMM1.227 JDIMM1.230 JDIMM1.231 JDIMM1.234 JDIMM1.235 JDIMM1.238 JDIMM1.239 JDIMM1.243 JDIMM1.244 JDIMM1.247 JDIMM1.248 JDIMM1.251 JDIMM1.252 JDIMM1.261 JDIMM1.262 JDIMM2.1 JDIMM2.2 JDIMM2.5 JDIMM2.6 JDIMM2.9 JDIMM2.10 JDIMM2.14 JDIMM2.15 JDIMM2.18 JDIMM2.19 JDIMM2.22 JDIMM2.23 JDIMM2.26 JDIMM2.27 JDIMM2.30 JDIMM2.31 JDIMM2.35 JDIMM2.36 JDIMM2.39 JDIMM2.40 JDIMM2.43 JDIMM2.44 JDIMM2.47 JDIMM2.48 JDIMM2.51 JDIMM2.52 JDIMM2.56 JDIMM2.57 JDIMM2.60 JDIMM2.61 JDIMM2.64 JDIMM2.65 JDIMM2.68 JDIMM2.69 JDIMM2.72 JDIMM2.73 JDIMM2.77 JDIMM2.78 JDIMM2.81 JDIMM2.82 JDIMM2.85 JDIMM2.86 JDIMM2.89 JDIMM2.90 JDIMM2.93 JDIMM2.94 JDIMM2.98 JDIMM2.99 JDIMM2.102 JDIMM2.103 JDIMM2.106 JDIMM2.107 JDIMM2.167 JDIMM2.168 JDIMM2.171 JDIMM2.172 JDIMM2.175 JDIMM2.176 JDIMM2.180 JDIMM2.181 JDIMM2.184 JDIMM2.185 JDIMM2.188 JDIMM2.189 JDIMM2.192 JDIMM2.193 JDIMM2.196 JDIMM2.197 JDIMM2.201 JDIMM2.202 JDIMM2.205 JDIMM2.206 JDIMM2.209 JDIMM2.210 JDIMM2.213 JDIMM2.214 JDIMM2.217 JDIMM2.218 JDIMM2.222 JDIMM2.223 JDIMM2.226 JDIMM2.227 JDIMM2.230 JDIMM2.231 JDIMM2.234 JDIMM2.235 JDIMM2.238 JDIMM2.239 JDIMM2.243 JDIMM2.244 JDIMM2.247 JDIMM2.248 JDIMM2.251 JDIMM2.252 JDIMM2.261 JDIMM2.262 JEDP1.1 JEDP1.2 JEDP1.5 JEDP1.8 JEDP1.11 JEDP1.14 JEDP1.17 JEDP1.27 JEDP1.28 JEDP1.30 JEDP1.33 JEDP1.34 JEDP1.35 JEDP1.41 JEDP1.42 JEDP1.43 JEDP1.44 JFAN1.4 JFAN1.5 JFAN1.6 JFAN2.4 JFAN2.5 JFAN2.6 JFP.2 JFP.7 JFP.8 JHDD.4 JHDD.7 JHDD.10 JHDD.17 JHDD.18 JHDD.19 JHDD.20 JHDD.21 JHDD.22 JHDD.23 JHDD.24 JHDMI1.2 JHDMI1.5 JHDMI1.8 JHDMI1.11 JHDMI1.17 JHDMI1.20 JHDMI1.21 JHDMI1.22 JHDMI1.23 JKB.13 JKB.14 JKB.15 JKB.16 JKB.17 JLPDE1.9 JLPDE1.11 JLPDE1.12 JNGFF1.1 JNGFF1.7 JNGFF1.10 JNGFF1.15 JNGFF1.16 JNGFF1.21 JNGFF1.22 JNGFF1.25 JNGFF1.28 JNGFF1.31 JNGFF1.37 JNGFF1.43 JNGFF1.49 JNGFF1.55 JNGFF1.61 JNGFF1.67 JNGFF1.68 JNGFF1.69 JNGFF2.1 JNGFF2.3 JNGFF2.9 JNGFF2.15 JNGFF2.21 JNGFF2.27 JNGFF2.33 JNGFF2.39 JNGFF2.45 JNGFF2.51 JNGFF2.57 JNGFF2.63 JNGFF2.65 JNGFF2.67 JNGFF2.68 JNGFF2.69 JRTC.2 JRTC.3 JRTC.4 JSPI1.1 JSPI1.2 JSPI1.3 JSPI1.22 JTAG1.2 JTP.5 JTP.9 JTP.10 JTS.3 JTS.6 JTS.7 JTS.8 JUART.4 JUART.5 JUART.6 JUSB1.4 JUSB1.7 JUSB1.11 JUSB1.12 JUSB1.13 JUSB1.14 JUSB2.4 JUSB2.7 JUSB2.11 JUSB2.12 JUSB2.13 JUSB2.14 JUSBC1.1 JUSBC1.2 JUSBC1.3 JUSBC1.4 JUSBC1.A1 JUSBC1.A12 JUSBC1.B1 JUSBC1.B12 JXDP.2 JXDP.7 JXDP.8 JXDP.13 JXDP.14 JXDP.19 JXDP.20 JXDP.25 JXDP.26 JXDP.31 JXDP.32 JXDP.37 JXDP.38 JXDP.49 JXDP.50 JXDP.59 PC106.2 PC107.2 PC108.2 PC109.2 PC110.2 PC114.2 PC115.2 PC201.2 PC205.2 PC206.2 PC214.1 PC215.1 PC216.2 PC217.2 PC218.2 PC219.2 PC225.2 PC299.2 PC306.2 PC307.2 PC308.2 PC309.2 PC310.2 PC312.2 PC315.2 PC316.2 PC317.2 PC318.2 PC319.2 PC320.2 PC323.2 PC324.2 PC325.2 PC326.2 PC329.2 PC334.2 PC335.2 PC336.2 PC337.2 PC400.2 PC403.2 PC404.2 PC405.2 PC406.2 PC407.2 PC408.2 PC409.2 PC412.2 PC413.2 PC414.2 PC415.2 PC416.2 PC417.2 PC418.2 PC419.2 PC420.2 PC456.2 PC500.2 PC501.2 PC502.2 PC503.2 PC504.2 PC506.2 PC508.2 PC509.2 PC510.2 PC511.2 PC512.2 PC513.2 PC601.2 PC602.2 PC603.2 PC604.2 PC605.2 PC606.2 PC607.1 PC608.2 PC609.2 PC610.2 PC611.2 PC613.2 PC614.2 PC700.2 PC701.1 PC703.2 PC704.2 PC705.2 PC706.2 PC707.2 PC708.2 PC709.1 PC710.2 PC712.2 PC713.2 PC736.2 PC737.2 PC764.2 PC765.2 PC766.2 PC780.2 PC781.2 PC800.2 PC801.2 PC802.2 PC803.2 PC804.2 PC806.2 PC808.2 PC809.2 PC810.2 PC811.2 PC812.2 PC813.2 PC900.2 PC901.2 PC902.2 PC903.2 PC904.2 PC906.2 PC908.2 PC909.2 PC910.2 PC911.2 PC912.2 PC913.2 PC1000.2 PC1001.2 PC1003.2 PC1004.2 PC1005.2 PC1006.2 PC1007.2 PC1008.2 PC1009.2 PC1010.2 PC1011.2 PC1012.2 PC1013.2 PC1014.2 PC1015.2 PC1016.2 PC1017.2 PC1018.2 PC1019.2 PC1020.2 PC1021.2 PC1023.2 PC1024.2 PC1025.2 PC1026.2 PC1027.2 PC1028.2 PC1029.2 PC1030.2 PC1031.2 PC1032.2 PC1033.2 PC1034.2 PC1035.2 PC1036.2 PC1037.2 PC1038.2 PC1039.2 PC1040.2 PC1041.2 PC1042.2 PC1043.2 PC1045.2 PC1046.2 PC1048.2 PC1049.2 PC1050.2 PC1051.2 PC1052.2 PC1053.2 PC1055.2 PC1056.2 PC1057.2 PC1058.2 PC1059.2 PC1060.2 PC1061.2 PC1062.2 PC1063.2 PC1064.2 PC1065.2 PC1066.2 PC1067.2 PC1068.2 PC1069.2 PC1070.2 PC1100.1 PC1101.2 PC1102.2 PC1103.1 PC1104.1 PC1105.1 PC1107.2 PC1109.2 PC1110.2 PC1114.2 PC1115.2 PC1116.2 PC1117.2 PC1119.2 PC1121.2 PC1126.2 PC1129.2 PC1131.2 PC1132.2 PC1134.1 PC1137.2 PC1138.1 PC1139.1 PC1200.1 PC1207.2 PC1208.2 PC1209.2 PC1210.2 PC1211.2 PC1212.2 PC1213.2 PC1214.2 PC1220.2 PC1221.2 PC1222.2 PC1223.2 PC1224.2 PC1225.2 PC1226.2 PC1227.1 PC1229.2 PC1230.2 PC1231.2 PC1232.2 PC1233.2 PC1234.2 PC1235.2 PC1236.2 PC1237.2 PC1238.2 PC1239.2 PC1240.2 PC1241.2 PC1242.2 PC1243.2 PC1244.2 PC1245.2 PC1246.2 PC1247.2 PC1248.2 PC1249.1 PC1251.2 PC1252.2 PC1253.2 PC1254.2 PC1255.2 PC1256.2 PC1261.2 PC1262.2 PC1263.2 PC1264.2 PC1265.2 PC1269.2 PC1271.2 PC1274.2 PC1276.2 PC1277.2 PC1300.2 PC1301.2 PC1302.1 PC1303.2 PC1304.2 PC1305.2 PC1306.2 PC1307.2 PC1309.2 PC1310.2 PC1311.2 PC1312.2 PC1314.2 PC1315.2 PC1316.2 PC1317.2 PC1318.2 PC1319.2 PC1320.2 PC1321.2 PC1322.2 PC1323.2 PC1324.2 PC1325.2 PC1326.2 PC1327.2 PC1328.2 PC1329.2 PC1330.2 PC1331.2 PC1332.2 PC1333.2 PC1334.2 PC1335.2 PC1336.1 PC1338.2 PC1339.2 PC1340.2 PC1341.2 PC1342.2 PC1343.2 PC1344.2 PC1345.2 PC1346.2 PC1347.2 PC1348.2 PC1349.2 PC1350.2 PC1351.2 PC1352.2 PC1353.2 PC1354.2 PC1355.2 PC1356.2 PC1357.2 PC1358.2 PC1359.2 PC1360.2 PC1361.2 PC1362.2 PC1363.2 PC1364.1 PC1365.2 PC1366.2 PC1367.2 PC1368.2 PC1369.2 PC1370.2 PC1372.2 PC1373.2 PC1374.2 PC1375.2 PC1376.2 PC1377.2 PC1378.2 PC1379.2 PC1380.2 PC1382.2 PC1383.2 PC1384.2 PC1385.2 PC1386.2 PC1388.2 PC1389.2 PC1390.2 PC1391.2 PC1393.2 PC1394.2 PC1395.2 PC1396.2 PC1397.2 PC1400.1 PC1402.2 PC1403.2 PC1404.2 PC1405.2 PC1406.2 PC1407.2 PC1501.2 PC1502.2 PC1503.2 PC1504.2 PC1505.2 PC1507.2 PC1508.2 PC1509.2 PC1510.2 PC1511.2 PC1512.2 PC1513.2 PC1514.2 PC1515.2 PC1516.2 PC1517.2 PC1518.2 PC1520.2 PC1521.2 PC1522.2 PC1523.2 PC1524.2 PC1525.2 PC1526.2 PC1527.2 PC1528.2 PC1529.2 PC1530.2 PC1532.2 PC1534.2 PC1800.2 PC1801.2 PC1803.2 PC1804.2 PD100.2 PD101.1 PD102.1 PH1100.1 PH1104.1 PJP300.2 PL105.2 PL106.2 PL202.2 PL203.2 PQ101.3 PQ205.3 PQ206.3 PQ208.3 PQ211.3 PQ218.3 PQ220.3 PQ222.3 PQ223.3 PQ225.3 PQ228.3 PQ229.3 PQ230.3 PQ231.3 PQ232.3 PQ233.3 PQ302.1 PQ302.2 PQ302.3 PQ402.1 PQ402.2 PQ402.3 PQ403.1 PQ403.2 PQ403.3 PQ601.1 PQ601.2 PQ601.3 PQ700.3 PQ1300.5 PQ1300.6 PQ1300.7 PR105.2 PR217.2 PR240.2 PR263.2 PR264.1 PR265.1 PR270.2 PR271.2 PR273.2 PR327.2 PR403.1 PR404.2 PR405.1 PR406.2 PR410.2 PR501.2 PR508.2 PR512.2 PR607.2 PR701.1 PR702.1 PR703.1 PR704.1 PR801.2 PR810.1 PR812.2 PR902.2 PR907.2 PR910.2 PR1002.2 PR1011.2 PR1016.1 PR1022.2 PR1100.1 PR1104.1 PR1106.1 PR1107.2 PR1108.2 PR1109.2 PR1110.2 PR1116.2 PR1129.2 PR1137.2 PR1138.1 PR1404.2 PR1405.2 PR1502.2 PR1511.2 PR1516.1 PR1519.2 PR1804.2 PU202.4 PU203.2 PU204.3 PU300.22 PU400.21 PU500.9 PU600.1 PU600.3 PU600.14 PU600.21 PU700.23 PU800.9 PU900.9 PU1000.8 PU1001.21 PU1002.8 PU1100.49 PU1200.7 PU1200.11 PU1201.7 PU1201.11 PU1202.7 PU1202.11 PU1300.7 PU1300.11 PU1301.7 PU1301.11 PU1302.4 PU1302.9 PU1400.4 PU1400.8 PU1400.9 PU1501.21 PU1502.8 PU1800.11 QE4.1 QE4.4 QF1.1 QF1.4 QI10.3 QR104.3 QV3.1 QV12.3 QV13.3 QV87.3 QV95.3 QV96.3 QV101.3 QV102.3 QV104.1 QV104.4 QZ6.1 QZ6.4 QZ7.4 QZ14.1 QZ14.4 QZ15.4 QZ16.4 QZ17.1 QZ17.4 QZ18.3 R1054.2 RA16.1 RA57.2 RA68.2 RA73.1 RA74.2 RA80.2 RA94.1 RA95.1 RD28.2 RD29.2 RD30.2 RD38.2 RD39.2 RD40.2 RE13.2 RE27.2 RE30.2 RE31.1 RE32.1 RE33.1 RE44.2 RE57.2 RE58.2 RE61.2 RE70.1 RE74.1 RE75.1 RE85.1 RE143.1 RH57.1 RH58.1 RH59.2 RH77.2 RH88.1 RH95.1 RH109.2 RH148.1 RH149.1 RH150.1 RH166.1 RH183.2 RH184.2 RH185.2 RH186.2 RH187.2 RH188.2 RH209.2 RH210.2 RH211.2 RH212.2 RH401.1 RH423.2 RH455.1 RH466.2 RH469.2 RH472.2 RH475.2 RH497.1 RH498.1 RH528.2 RH529.2 RH538.2 RH544.2 RH556.1 RH565.2 RH567.2 RH568.2 RH580.2 RH581.2 RH589.2 RI6.2 RI7.2 RI8.1 RI11.2 RI12.2 RI13.1 RI23.2 RI25.2 RI26.2 RI27.2 RN33.1 RR6.1 RT1.2 RT2.2 RT3.1 RT4.1 RT5.2 RT12.2 RT37.1 RT38.1 RT39.1 RT40.1 RT41.1 RT42.1 RT43.1 RT44.1 RT45.1 RT164.1 RT183.2 RT186.2 RT187.1 RT188.1 RT190.2 RT191.2 RT199.2 RT207.1 RT208.1 RT209.1 RT429.2 RT431.1 RT437.2 RT1092.1 RV107.2 RV109.2 RV114.2 RV123.2 RV135.2 RV550.2 RV566.2 RV567.2 RV578.1 RV579.2 RV580.1 RV581.2 RV589.2 RV592.2 RV593.2 RV601.1 RV602.1 RV613.2 RV614.2 RV615.2 RV616.2 RV617.2 RV619.2 RV620.2 RV625.2 RV631.2 RV632.2 RV633.2 RV636.2 RV642.1 RV643.1 RV644.1 RV651.1 RV652.1 RV653.1 RV654.1 RV655.1 RV656.1 RV1073.2 RV1077.2 RV1128.2 RZ32.1 RZ39.2 RZ40.2 RZ41.2 RZ43.1 RZ46.1 RZ50.2 RZ71.2 RZ74.2 RZ80.2 RZ85.2 RZ86.2 RZ87.2 RZ88.2 SW1.4 SW2.1 SW2.2 SW4.4 SW4.5 UA1.57 UA3.2 UA4.11 UA4.15 UC1.3 UD2.3 UE1.9 UE1.16 UE1.23 UE1.32 UE1.33 UE2.1 UE3.B11 UE3.B18 UE3.B54 UE3.B60 UE3.B66 UE3.C1 UE4.6 UE6.5 UE6.9 UF1.5 UF1.10 UF1.12 UF1.13 UF1.15 UF1.16 UH1.A3 UH1.A4 UH1.A6 UH1.A9 UH1.A10 UH1.A12 UH1.A14 UH1.A16 UH1.A18 UH1.A20 UH1.A22 UH1.A24 UH1.A26 UH1.A28 UH1.A30 UH1.A34 UH1.A36 UH1.A37 UH1.AA12 UH1.AA29 UH1.AA30 UH1.AB6 UH1.AB33 UH1.AB34 UH1.AC1 UH1.AC2 UH1.AC3 UH1.AC4 UH1.AC5 UH1.AC6 UH1.AC12 UH1.AC37 UH1.AC38 UH1.AD6 UH1.AD7 UH1.AD8 UH1.AD9 UH1.AD10 UH1.AD11 UH1.AD12 UH1.AD29 UH1.AD30 UH1.AE6 UH1.AE33 UH1.AE34 UH1.AF1 UH1.AF2 UH1.AF3 UH1.AF4 UH1.AF12 UH1.AF13 UH1.AF14 UH1.AG6 UH1.AG7 UH1.AG8 UH1.AG10 UH1.AG11 UH1.AG29 UH1.AG30 UH1.AH6 UH1.AH12 UH1.AH33 UH1.AH34 UH1.AJ1 UH1.AJ2 UH1.AJ3 UH1.AJ4 UH1.AJ5 UH1.AJ6 UH1.AJ37 UH1.AJ38 UH1.AK4 UH1.AK29 UH1.AK30 UH1.AL4 UH1.AL7 UH1.AL8 UH1.AL9 UH1.AL10 UH1.AL12 UH1.AL14 UH1.AL33 UH1.AL34 UH1.AM1 UH1.AM2 UH1.AM3 UH1.AM4 UH1.AM5 UH1.AM12 UH1.AM37 UH1.AM38 UH1.AN5 UH1.AN6 UH1.AN12 UH1.AN29 UH1.AN30 UH1.AP8 UH1.AP9 UH1.AP10 UH1.AP11 UH1.AP12 UH1.AP33 UH1.AP34 UH1.AR1 UH1.AR2 UH1.AR3 UH1.AR4 UH1.AR5 UH1.AR13 UH1.AR14 UH1.AR37 UH1.AR38 UH1.AT6 UH1.AT29 UH1.AT30 UH1.AU6 UH1.AU7 UH1.AU8 UH1.AU9 UH1.AU10 UH1.AU11 UH1.AU12 UH1.AU33 UH1.AU34 UH1.AV37 UH1.AV38 UH1.AW1 UH1.AW2 UH1.AW3 UH1.AW4 UH1.AW5 UH1.AW12 UH1.AW29 UH1.AW30 UH1.AY12 UH1.AY14 UH1.AY33 UH1.AY34 UH1.B3 UH1.B9 UH1.B37 UH1.BA6 UH1.BA7 UH1.BA8 UH1.BA9 UH1.BA10 UH1.BA11 UH1.BA12 UH1.BA37 UH1.BA38 UH1.BB1 UH1.BB2 UH1.BB3 UH1.BB4 UH1.BB5 UH1.BB6 UH1.BB12 UH1.BB29 UH1.BB30 UH1.BC6 UH1.BC12 UH1.BC13 UH1.BC14 UH1.BC33 UH1.BC34 UH1.BD6 UH1.BD7 UH1.BD8 UH1.BD9 UH1.BD10 UH1.BD11 UH1.BD12 UH1.BD37 UH1.BD38 UH1.BE1 UH1.BE2 UH1.BE3 UH1.BE4 UH1.BE5 UH1.BE6 UH1.BE29 UH1.BE30 UH1.BF6 UH1.BF12 UH1.BF33 UH1.BF34 UH1.BG6 UH1.BG12 UH1.BG13 UH1.BG14 UH1.BG37 UH1.BG38 UH1.BH1 UH1.BH2 UH1.BH3 UH1.BH4 UH1.BH5 UH1.BH6 UH1.BH7 UH1.BH8 UH1.BH9 UH1.BH10 UH1.BH11 UH1.BH12 UH1.BH14 UH1.BJ12 UH1.BJ15 UH1.BJ18 UH1.BJ22 UH1.BJ25 UH1.BJ29 UH1.BJ30 UH1.BJ31 UH1.BJ32 UH1.BK6 UH1.BK13 UH1.BK14 UH1.BK15 UH1.BK18 UH1.BK22 UH1.BK25 UH1.BK29 UH1.BL6 UH1.BL13 UH1.BL29 UH1.BL35 UH1.BL38 UH1.BM2 UH1.BM3 UH1.BM5 UH1.BM6 UH1.BM7 UH1.BM8 UH1.BM9 UH1.BM11 UH1.BM12 UH1.BM13 UH1.BM18 UH1.BM21 UH1.BM23 UH1.BM25 UH1.BM26 UH1.BM27 UH1.BM28 UH1.BM29 UH1.BM35 UH1.BM38 UH1.BN2 UH1.BN4 UH1.BN7 UH1.BN9 UH1.BN12 UH1.BN14 UH1.BN18 UH1.BN19 UH1.BN20 UH1.BN21 UH1.BN24 UH1.BN29 UH1.BN30 UH1.BN31 UH1.BN34 UH1.BP7 UH1.BP12 UH1.BP14 UH1.BP18 UH1.BP21 UH1.BP24 UH1.BP26 UH1.BP29 UH1.BP33 UH1.BP34 UH1.BR7 UH1.BR12 UH1.BR14 UH1.BR18 UH1.BR21 UH1.BR24 UH1.BR26 UH1.BR29 UH1.BR34 UH1.BR36 UH1.BR38 UH1.BT3 UH1.BT4 UH1.BT5 UH1.BT9 UH1.BT12 UH1.BT14 UH1.BT18 UH1.BT21 UH1.BT24 UH1.BT26 UH1.BT32 UH1.BT35 UH1.BT36 UH1.C2 UH1.C5 UH1.C8 UH1.C9 UH1.C11 UH1.C13 UH1.C15 UH1.C17 UH1.C19 UH1.C21 UH1.C23 UH1.C25 UH1.C27 UH1.C29 UH1.C31 UH1.C37 UH1.D3 UH1.D6 UH1.D9 UH1.D10 UH1.D12 UH1.D14 UH1.D16 UH1.D18 UH1.D20 UH1.D22 UH1.D24 UH1.D26 UH1.D28 UH1.D30 UH1.D33 UH1.D38 UH1.E4 UH1.E9 UH1.E34 UH1.E35 UH1.E38 UH1.F2 UH1.F3 UH1.F4 UH1.F5 UH1.F8 UH1.F9 UH1.F11 UH1.F13 UH1.F15 UH1.F17 UH1.F19 UH1.F21 UH1.F23 UH1.F25 UH1.F27 UH1.F29 UH1.F31 UH1.F36 UH1.G4 UH1.G5 UH1.G6 UH1.G8 UH1.G9 UH1.G10 UH1.G12 UH1.G14 UH1.G16 UH1.G18 UH1.G20 UH1.G22 UH1.G23 UH1.G24 UH1.G26 UH1.G28 UH1.H11 UH1.H12 UH1.H18 UH1.H22 UH1.H25 UH1.H32 UH1.H35 UH1.J4 UH1.J7 UH1.J10 UH1.J18 UH1.J22 UH1.J25 UH1.J32 UH1.J33 UH1.J36 UH1.K1 UH1.K2 UH1.K3 UH1.K4 UH1.K5 UH1.K7 UH1.K8 UH1.K9 UH1.K10 UH1.K11 UH1.K38 UH1.L29 UH1.L30 UH1.L33 UH1.L34 UH1.M6 UH1.M12 UH1.M13 UH1.M14 UH1.N1 UH1.N2 UH1.N3 UH1.N4 UH1.N5 UH1.N6 UH1.N7 UH1.N8 UH1.N9 UH1.N10 UH1.N11 UH1.N12 UH1.N33 UH1.N34 UH1.P6 UH1.P12 UH1.P37 UH1.P38 UH1.R12 UH1.R29 UH1.R30 UH1.T1 UH1.T2 UH1.T3 UH1.T4 UH1.T5 UH1.T7 UH1.T8 UH1.T9 UH1.T10 UH1.T11 UH1.T12 UH1.T13 UH1.T14 UH1.T33 UH1.T34 UH1.U6 UH1.U37 UH1.U38 UH1.V6 UH1.V12 UH1.V29 UH1.V30 UH1.W1 UH1.W2 UH1.W3 UH1.W4 UH1.W5 UH1.W12 UH1.W33 UH1.W34 UH1.Y7 UH1.Y8 UH1.Y9 UH1.Y10 UH1.Y11 UH1.Y13 UH1.Y14 UH1.Y37 UH1.Y38 UH2.A2 UH2.A3 UH2.A4 UH2.A18 UH2.A25 UH2.A32 UH2.A37 UH2.A42 UH2.A44 UH2.AA4 UH2.AA17 UH2.AA18 UH2.AA20 UH2.AA21 UH2.AA25 UH2.AA29 UH2.AA42 UH2.AB4 UH2.AB5 UH2.AB7 UH2.AB8 UH2.AB10 UH2.AB11 UH2.AB14 UH2.AB15 UH2.AB31 UH2.AB32 UH2.AB38 UH2.AC1 UH2.AC18 UH2.AC20 UH2.AC21 UH2.AC25 UH2.AC29 UH2.AC45 UH2.AD4 UH2.AD8 UH2.AD11 UH2.AD14 UH2.AD32 UH2.AD33 UH2.AD36 UH2.AE4 UH2.AE18 UH2.AE20 UH2.AE21 UH2.AE25 UH2.AE28 UH2.AE29 UH2.AE42 UH2.AF18 UH2.AF20 UH2.AF21 UH2.AF23 UH2.AF25 UH2.AF26 UH2.AF28 UH2.AF29 UH2.AG4 UH2.AG11 UH2.AG13 UH2.AG31 UH2.AG32 UH2.AG33 UH2.AG38 UH2.AH1 UH2.AH17 UH2.AH18 UH2.AH20 UH2.AH21 UH2.AH23 UH2.AH25 UH2.AH26 UH2.AH28 UH2.AH29 UH2.AH45 UH2.AJ10 UH2.AJ14 UH2.AJ15 UH2.AJ17 UH2.AJ18 UH2.AJ26 UH2.AJ28 UH2.AJ29 UH2.AJ31 UH2.AJ32 UH2.AJ36 UH2.AK4 UH2.AK42 UH2.AL4 UH2.AL10 UH2.AL11 UH2.AL13 UH2.AL17 UH2.AL19 UH2.AL24 UH2.AL29 UH2.AL32 UH2.AL33 UH2.AL38 UH2.AM15 UH2.AM17 UH2.AM19 UH2.AM22 UH2.AM24 UH2.AM27 UH2.AM29 UH2.AM45 UH2.AN4 UH2.AN7 UH2.AN8 UH2.AN10 UH2.AN11 UH2.AN22 UH2.AN27 UH2.AN31 UH2.AN39 UH2.AP4 UH2.AP11 UH2.AR5 UH2.AR7 UH2.AR9 UH2.AR33 UH2.AR34 UH2.AR42 UH2.AT9 UH2.AT10 UH2.AT15 UH2.AT36 UH2.AU1 UH2.AU7 UH2.AU35 UH2.AU36 UH2.AU39 UH2.AU45 UH2.AV6 UH2.AV17 UH2.AV24 UH2.AV27 UH2.AV31 UH2.AV33 UH2.AW9 UH2.AW13 UH2.AW19 UH2.AW29 UH2.AW37 UH2.AY38 UH2.AY45 UH2.B1 UH2.B2 UH2.B3 UH2.B6 UH2.B25 UH2.B37 UH2.B40 UH2.B44 UH2.B45 UH2.BA1 UH2.BB1 UH2.BB11 UH2.BB16 UH2.BB21 UH2.BB25 UH2.BB30 UH2.BB34 UH2.BC1 UH2.BC2 UH2.BD2 UH2.BD43 UH2.BD44 UH2.BD45 UH2.BE9 UH2.BE14 UH2.BE18 UH2.BE23 UH2.BE28 UH2.BE32 UH2.BE37 UH2.BE40 UH2.BE44 UH2.C1 UH2.C2 UH2.C4 UH2.C10 UH2.C28 UH2.C37 UH2.C42 UH2.D1 UH2.D10 UH2.D12 UH2.D15 UH2.D16 UH2.D17 UH2.D19 UH2.D21 UH2.D24 UH2.D25 UH2.D27 UH2.D29 UH2.D30 UH2.D31 UH2.D33 UH2.D35 UH2.D36 UH2.D45 UH2.E13 UH2.E15 UH2.E31 UH2.E33 UH2.F8 UH2.F44 UH2.G9 UH2.G42 UH2.H3 UH2.H17 UH2.H19 UH2.H22 UH2.H24 UH2.H27 UH2.H29 UH2.H35 UH2.J3 UH2.J5 UH2.J7 UH2.J10 UH2.J11 UH2.J39 UH2.K4 UH2.K10 UH2.K27 UH2.K33 UH2.K36 UH2.K42 UH2.K43 UH2.L4 UH2.L8 UH2.L12 UH2.L13 UH2.L15 UH2.L41 UH2.M35 UH2.M42 UH2.N4 UH2.N5 UH2.N10 UH2.N15 UH2.N19 UH2.N22 UH2.N24 UH2.N35 UH2.N36 UH2.N41 UH2.P17 UH2.P19 UH2.P22 UH2.P45 UH2.R5 UH2.R10 UH2.R14 UH2.R22 UH2.R29 UH2.R33 UH2.R38 UH2.T1 UH2.T2 UH2.T4 UH2.T42 UH2.U4 UH2.U8 UH2.U10 UH2.U11 UH2.U14 UH2.U15 UH2.U17 UH2.U18 UH2.U28 UH2.U29 UH2.U31 UH2.U32 UH2.U33 UH2.U38 UH2.V3 UH2.V18 UH2.V20 UH2.V21 UH2.V23 UH2.V25 UH2.V29 UH2.V45 UH2.W4 UH2.W8 UH2.W14 UH2.W31 UH2.W32 UH2.W33 UH2.W38 UH2.Y17 UH2.Y18 UH2.Y20 UH2.Y21 UH2.Y26 UH2.Y28 UH2.Y29 UH7.3 UH8.4 UH14.3 UI1.14 UI1.17 UI2.14 UI2.17 UI3.10 UI3.21 UI3.25 UI4.3 UI5.3 UN3.5 UN3.9 UR1.33 UT1.A1 UT1.A6 UT1.A8 UT1.A10 UT1.A12 UT1.A14 UT1.A16 UT1.A18 UT1.A20 UT1.A22 UT1.AA22 UT1.AA23 UT1.AB1 UT1.AB2 UT1.AB6 UT1.AB8 UT1.AB10 UT1.AB12 UT1.AB14 UT1.AB16 UT1.AB18 UT1.AB20 UT1.AB22 UT1.AC1 UT1.AC2 UT1.AC6 UT1.AC8 UT1.AC10 UT1.AC12 UT1.AC14 UT1.AC16 UT1.AC18 UT1.AC20 UT1.AC22 UT1.B1 UT1.B2 UT1.B6 UT1.B8 UT1.B10 UT1.B12 UT1.B14 UT1.B16 UT1.B18 UT1.B20 UT1.B22 UT1.C22 UT1.C23 UT1.D5 UT1.D6 UT1.D8 UT1.D9 UT1.D11 UT1.D12 UT1.D13 UT1.D15 UT1.D16 UT1.D18 UT1.E4 UT1.E5 UT1.E6 UT1.E8 UT1.E9 UT1.E11 UT1.E15 UT1.E16 UT1.E22 UT1.E23 UT1.F5 UT1.F6 UT1.F9 UT1.F16 UT1.F20 UT1.G22 UT1.G23 UT1.H1 UT1.H2 UT1.H5 UT1.H8 UT1.H12 UT1.H13 UT1.H15 UT1.H16 UT1.H20 UT1.J5 UT1.J8 UT1.J12 UT1.J13 UT1.J15 UT1.J18 UT1.J19 UT1.J20 UT1.J22 UT1.J23 UT1.K1 UT1.K2 UT1.L5 UT1.L13 UT1.L15 UT1.L20 UT1.L22 UT1.L23 UT1.M1 UT1.M2 UT1.M5 UT1.M11 UT1.M12 UT1.M19 UT1.M20 UT1.N5 UT1.N8 UT1.N9 UT1.N11 UT1.N12 UT1.N13 UT1.N15 UT1.N20 UT1.N22 UT1.N23 UT1.P1 UT1.P2 UT1.R5 UT1.R18 UT1.R19 UT1.R20 UT1.R22 UT1.R23 UT1.T1 UT1.T2 UT1.T5 UT1.T6 UT1.T8 UT1.T9 UT1.T13 UT1.T15 UT1.T16 UT1.T18 UT1.T20 UT1.U22 UT1.U23 UT1.V5 UT1.V6 UT1.V8 UT1.V9 UT1.V15 UT1.V16 UT1.V20 UT1.W5 UT1.W6 UT1.W8 UT1.W9 UT1.W13 UT1.W18 UT1.W20 UT1.W22 UT1.W23 UT1.Y9 UT1.Y13 UT1.Y20 UT2.4 UT3.5 UT3.9 UT4.A1 UT4.B8 UT4.D8 UT4.E5 UT4.E6 UT4.E7 UT4.E8 UT4.F5 UT4.F6 UT4.F7 UT4.F8 UT4.G5 UT4.G6 UT4.G7 UT4.G8 UT4.H4 UT4.H5 UT4.H8 UT4.L1 UT4.L11 UT5.4 UV16.2 UV17.4 UV18.A2 UV18.A33 UV18.AA13 UV18.AA15 UV18.AA17 UV18.AA18 UV18.AA20 UV18.AA22 UV18.AB2 UV18.AB5 UV18.AB7 UV18.AB12 UV18.AB14 UV18.AB16 UV18.AB19 UV18.AB21 UV18.AB23 UV18.AB28 UV18.AB30 UV18.AB32 UV18.AC13 UV18.AC15 UV18.AC17 UV18.AC18 UV18.AC20 UV18.AC22 UV18.AE2 UV18.AE5 UV18.AE7 UV18.AE28 UV18.AE30 UV18.AE32 UV18.AE33 UV18.AG11 UV18.AH2 UV18.AH5 UV18.AH7 UV18.AH10 UV18.AH11 UV18.AH13 UV18.AH16 UV18.AH19 UV18.AH22 UV18.AH24 UV18.AH28 UV18.AH29 UV18.AH30 UV18.AH32 UV18.AH33 UV18.AJ7 UV18.AK7 UV18.AK10 UV18.AL2 UV18.AL5 UV18.AL12 UV18.AL14 UV18.AL15 UV18.AL17 UV18.AL18 UV18.AL20 UV18.AL21 UV18.AL23 UV18.AL24 UV18.AL26 UV18.AL28 UV18.AL30 UV18.AL32 UV18.AL33 UV18.AM13 UV18.AM16 UV18.AM19 UV18.AM22 UV18.AM25 UV18.AN1 UV18.AN4 UV18.AN7 UV18.AN10 UV18.AN13 UV18.AN16 UV18.AN19 UV18.AN22 UV18.AN25 UV18.AN30 UV18.AN34 UV18.AP2 UV18.AP33 UV18.B1 UV18.B4 UV18.B7 UV18.B10 UV18.B22 UV18.B25 UV18.B28 UV18.B31 UV18.B34 UV18.C7 UV18.C10 UV18.C13 UV18.C16 UV18.C19 UV18.C22 UV18.C25 UV18.C28 UV18.D2 UV18.D31 UV18.D33 UV18.E5 UV18.E7 UV18.E10 UV18.E22 UV18.E25 UV18.F7 UV18.F28 UV18.G2 UV18.G3 UV18.G5 UV18.G7 UV18.G10 UV18.G13 UV18.G16 UV18.G19 UV18.G22 UV18.G25 UV18.G28 UV18.G30 UV18.G32 UV18.G33 UV18.K2 UV18.K5 UV18.K7 UV18.K28 UV18.K30 UV18.K32 UV18.K33 UV18.M13 UV18.M15 UV18.M17 UV18.M18 UV18.M20 UV18.M22 UV18.N2 UV18.N5 UV18.N7 UV18.N12 UV18.N14 UV18.N16 UV18.N19 UV18.N21 UV18.N23 UV18.N28 UV18.N30 UV18.N32 UV18.N33 UV18.P13 UV18.P15 UV18.P17 UV18.P18 UV18.P20 UV18.P22 UV18.R12 UV18.R14 UV18.R16 UV18.R19 UV18.R21 UV18.R23 UV18.T2 UV18.T5 UV18.T7 UV18.T13 UV18.T15 UV18.T17 UV18.T18 UV18.T20 UV18.T22 UV18.T28 UV18.T32 UV18.U12 UV18.U14 UV18.U16 UV18.U19 UV18.U21 UV18.U23 UV18.V12 UV18.V14 UV18.V16 UV18.V19 UV18.V21 UV18.V23 UV18.W13 UV18.W15 UV18.W17 UV18.W18 UV18.W20 UV18.W22 UV18.W28 UV18.W32 UV18.Y12 UV18.Y14 UV18.Y16 UV18.Y19 UV18.Y21 UV18.Y23 UV19.3 UV20.3 UV21.3 UV23.A1 UV23.A3 UV23.A12 UV23.A14 UV23.B5 UV23.B10 UV23.C1 UV23.C3 UV23.C4 UV23.C11 UV23.C12 UV23.C14 UV23.D10 UV23.E1 UV23.E3 UV23.E12 UV23.E14 UV23.F5 UV23.F10 UV23.G5 UV23.G10 UV23.H1 UV23.H2 UV23.H13 UV23.H14 UV23.J10 UV23.K1 UV23.K2 UV23.K13 UV23.K14 UV23.L5 UV23.L10 UV23.M5 UV23.M10 UV23.N1 UV23.N3 UV23.N12 UV23.N14 UV23.P10 UV23.R1 UV23.R3 UV23.R4 UV23.R11 UV23.R12 UV23.R14 UV23.T5 UV23.T10 UV23.U1 UV23.U3 UV23.U12 UV23.U14 UV24.A1 UV24.A3 UV24.A12 UV24.A14 UV24.B5 UV24.B10 UV24.C1 UV24.C3 UV24.C4 UV24.C11 UV24.C12 UV24.C14 UV24.D10 UV24.E1 UV24.E3 UV24.E12 UV24.E14 UV24.F5 UV24.F10 UV24.G5 UV24.G10 UV24.H1 UV24.H2 UV24.H13 UV24.H14 UV24.J10 UV24.K1 UV24.K2 UV24.K13 UV24.K14 UV24.L5 UV24.L10 UV24.M5 UV24.M10 UV24.N1 UV24.N3 UV24.N12 UV24.N14 UV24.P10 UV24.R1 UV24.R3 UV24.R4 UV24.R11 UV24.R12 UV24.R14 UV24.T5 UV24.T10 UV24.U1 UV24.U3 UV24.U12 UV24.U14 UV25.A1 UV25.A3 UV25.A12 UV25.A14 UV25.B5 UV25.B10 UV25.C1 UV25.C3 UV25.C4 UV25.C11 UV25.C12 UV25.C14 UV25.D10 UV25.E1 UV25.E3 UV25.E12 UV25.E14 UV25.F5 UV25.F10 UV25.G5 UV25.G10 UV25.H1 UV25.H2 UV25.H13 UV25.H14 UV25.J10 UV25.K1 UV25.K2 UV25.K13 UV25.K14 UV25.L5 UV25.L10 UV25.M5 UV25.M10 UV25.N1 UV25.N3 UV25.N12 UV25.N14 UV25.P10 UV25.R1 UV25.R3 UV25.R4 UV25.R11 UV25.R12 UV25.R14 UV25.T5 UV25.T10 UV25.U1 UV25.U3 UV25.U12 UV25.U14 UV26.A1 UV26.A3 UV26.A12 UV26.A14 UV26.B5 UV26.B10 UV26.C1 UV26.C3 UV26.C4 UV26.C11 UV26.C12 UV26.C14 UV26.D10 UV26.E1 UV26.E3 UV26.E12 UV26.E14 UV26.F5 UV26.F10 UV26.G5 UV26.G10 UV26.H1 UV26.H2 UV26.H13 UV26.H14 UV26.J10 UV26.K1 UV26.K2 UV26.K13 UV26.K14 UV26.L5 UV26.L10 UV26.M5 UV26.M10 UV26.N1 UV26.N3 UV26.N12 UV26.N14 UV26.P10 UV26.R1 UV26.R3 UV26.R4 UV26.R11 UV26.R12 UV26.R14 UV26.T5 UV26.T10 UV26.U1 UV26.U3 UV26.U12 UV26.U14 UV28.3 UZ1.11 UZ1.15 UZ4.5 UZ4.9 UZ5.5 UZ5.9 UZ7.11 UZ7.15 UZ8.2 UZ9.5 UZ11.3 UZ12.3 UZ15.5 UZ16.5 UZ16.9 UZ18.3 UZ19.3 UZ20.3 UZ21.3 UZ22.3 UZ23.3 UZ24.5 UZ24.9 YH2.2 YH2.4 YT1.2 YT1.4 YV1.2 YV1.4
GNDA_CHG: PC311.1 PC314.2 PC322.1 PC327.2 PC328.2 PC330.1 PC332.2 PC333.1 PJP300.1 PQ304.3 PR308.2 PR316.2 PR323.2 PR325.2 PU300.29
GNDS_SENSE_VGA: PR1517.1 UV18.U2
V1N: PR1203.2 PR1212.1 PR1213.1 PR1219.2
V2N: PR1207.2 PR1214.1 PR1215.1 PR1221.2
V3N: PR1211.2 PR1216.1 PR1217.1 PR1223.2
VBATT: PC107.1 PC108.1 PD301.2 PD302.2 PL107.1 PL108.1 PQ303.5 PR320.2
VBUS_ACOK: PC217.1 PQ229.1 PR255.1 PR258.2 PR267.1 PU202.1
VBUS_HV_DIS#: PD211.1 PR290.1 UE3.B2
VCC0V9_LVR_OUT: CT95.1 CT96.1 CT97.1 CT98.1 UT1.F18 UT1.H11 UT1.H18 UT1.J11
VCC0V9_SVR: CT74.1 CT83.1 CT84.1 CT85.1 CT86.1 CT88.1 CT89.1 CT90.1 CT141.1 CT142.1 LT1.2 UT1.E12 UT1.E13 UT1.F11 UT1.F12 UT1.F13 UT1.F15 UT1.J9 UT1.L9 UT1.M9
VCC1V8A_TBTA_LDO: CT151.1 RT246.2 UT4.K1
VCC1V8D_TBTA_LDO: CT152.1 UT4.A2
VCC3V3_FLASH: CT146.1 RT168.1 RT169.1 RT170.1 RT171.1 RT189.2 RT226.1 RT227.1 RT243.1 RT432.1 RT1093.1 UT4.G1 UT5.8
VCC3V3_TBT_SX: CT145.1 UT4.H2
VCC5V0_SYS: CT147.1 CT148.1 CT149.1 CT150.1 RT165.2 UT4.A11 UT4.B11 UT4.C11 UT4.D11 UT4.H10
VCC_3V3_PCIE: CT99.1 UT1.L16
VCC_3V3_USB2: CT100.1 UT1.J16
VCC_SENSE: PC1130.2 PR1142.1 RH198.2
VCCGT_B+: PC1315.1 PC1316.1 PC1317.1 PC1319.1 PC1343.1 PC1344.1 PC1345.1 PC1346.1 PJP1300.1 PL1303.2 PL1304.2 PU1300.6 PU1300.12 PU1301.6 PU1301.12
VCCGT_SENSE: PC1106.1 PR1113.1 RH204.2
VCCIO_SENSE: PR808.2 UH1.H14
VCCSA_SENSE: PC1118.2 PR1128.2 RH202.2
VCCSENSE_VGA: PR1021.1 UV18.L4
VCCST_PWRGD_CPU: RH154.2 UH1.H13
VDD33STB: RA100.2 RA101.2 UA1.10
VDD_1.2V: PC610.1 PR601.1 PR603.2 PU600.11
VDDS_SENSE_VGA: PR1520.1 UV18.U1
VSS_SENSE: PC1107.1 PU1100.18 RH465.2
VSSGT_SENSE: PC1109.1 PU1100.6 RH471.2
VSSIO_SENSE: PR809.2 UH1.J14
VSSSA_SENSE: PC1121.1 PU1100.31 RH470.2
VSSSENSE_VGA: PR1018.1 UV18.L5
+AC_IN: PC208.1 PC221.1 PQ212.1 PQ212.2 PQ212.3 PQ214.1 PQ214.2 PQ214.3 PQ216.3 PR219.1 PR220.1 PR222.1
+DC_IN: ADP100.1 ADP100.2 ADP100.3 PC114.1 PC115.1 PC200.1 PD202.2 PQ200.1 PQ200.2 PQ200.3 PR201.1 PR213.1
+DC_IN_SS: PD304.2 PQ200.5 PQ201.5 PR261.1
+DCPRTC: CH70.1 UH2.BA26
+EDPVDD: CV156.1 CV157.1 CZ41.1 JEDP1.19 JEDP1.20 JEDP1.21 RV545.1 RV546.1 RV547.1 RZ35.2
+FB_PLLAVDD: CV921.1 CV922.1 CV923.1 CV924.1 LV24.1 UV18.H17 UV18.K27 UV18.U27
+FBA_VREFC0: CV926.1 CV927.1 RV623.2 RV624.2 RV625.1 UV23.J14 UV24.J14
+FBA_VREFC0_R: QV95.1 QV101.1 RV624.1
+FBC_VREFC1: CV988.1 CV989.1 RV634.2 RV635.2 RV636.1 UV25.J14 UV26.J14
+FBC_VREFC1_R: QV96.1 QV102.1 RV635.1
+GPCPLL_AVDD: CV850.1 CV1050.1 CV1051.1 RV574.1 UV18.H26
+GPU_CORE: PC1006.1 PC1007.1 PC1008.1 PC1009.1 PC1010.1 PC1011.1 PC1012.1 PC1013.1 PC1014.1 PC1016.1 PC1019.1 PC1020.1 PC1021.1 PC1023.1 PC1025.1 PC1026.1 PC1027.1 PC1028.1 PC1029.1 PC1031.1 PC1032.1 PC1033.1 PC1034.1 PC1035.1 PC1036.1 PC1037.1 PC1038.1 PC1039.1 PC1040.1 PC1048.1 PC1049.1 PC1050.1 PC1051.1 PC1052.1 PC1053.1 PC1057.1 PC1058.1 PC1059.1 PC1060.1 PC1061.1 PC1062.1 PC1063.1 PC1064.1 PC1065.1 PC1066.1 PC1067.1 PC1068.1 PC1069.1 PC1070.1 PL1002.2 PL1003.2 PR1023.1 RV1075.1 RV1076.1 RV1810.1 UV18.AA1 UV18.AA2 UV18.AA3 UV18.AA4 UV18.AA5 UV18.AA6 UV18.AA7 UV18.AA8 UV18.AA14 UV18.AA21 UV18.AB13 UV18.AB15 UV18.AB17 UV18.AB18 UV18.AB20 UV18.AB22 UV18.AC12 UV18.AC16 UV18.AC19 UV18.AC23 UV18.M12 UV18.M16 UV18.M19 UV18.M23 UV18.N13 UV18.N15 UV18.N17 UV18.N18 UV18.N20 UV18.N22 UV18.P14 UV18.P21 UV18.R13 UV18.R15 UV18.R17 UV18.R18 UV18.R20 UV18.R22 UV18.T12 UV18.T16 UV18.T19 UV18.T23 UV18.U4 UV18.U5 UV18.U6 UV18.U7 UV18.U8 UV18.U13 UV18.U15 UV18.U18 UV18.U20 UV18.U22 UV18.V1 UV18.V2 UV18.V3 UV18.V4 UV18.V5 UV18.V6 UV18.V7 UV18.V8 UV18.V13 UV18.V15 UV18.V17 UV18.V20 UV18.V22 UV18.W2 UV18.W3 UV18.W4 UV18.W5 UV18.W7 UV18.W8 UV18.W12 UV18.W16 UV18.W19 UV18.W23 UV18.Y1 UV18.Y2 UV18.Y3 UV18.Y4 UV18.Y5 UV18.Y6 UV18.Y7 UV18.Y8 UV18.Y13 UV18.Y15 UV18.Y17 UV18.Y18 UV18.Y20 UV18.Y22
+GPU_CORE_VDDS: PC1502.1 PC1503.1 PC1504.1 PC1507.1 PC1508.1 PC1512.1 PC1513.1 PC1514.1 PC1515.1 PC1516.1 PC1523.1 PC1524.1 PC1525.1 PC1526.1 PC1527.1 PC1528.1 PC1529.1 PC1530.1 PL1500.2 PR1521.1 RV1075.2 RV1076.2 RV1808.1 UV18.AA12 UV18.AA16 UV18.AA19 UV18.AA23 UV18.AC14 UV18.AC21 UV18.M14 UV18.M21 UV18.P12 UV18.P16 UV18.P19 UV18.P23 UV18.T14 UV18.T21 UV18.U17 UV18.V18 UV18.W14 UV18.W21
+INV_PWR_SRC: CV169.1 JEDP1.38 JEDP1.39 JEDP1.40 QV11.1 QV11.2 QV11.5 QV11.6
+NVVDDS_B+: PC1505.1 PC1509.1 PC1510.1 PC1511.1 PL1501.2 PL1502.2 PR1514.1 PU1502.1
+ODR_PWR: CR14.1 CR15.1 JCR.5 UR1.12
+PEX_PLL_HVDD: CV891.1 RV597.1 RV1056.1 UV18.AH12
+PEX_PLL_VDD: CV121.1 CV122.1 CV123.1 RV1057.1 UV18.AG26
+PEX_SVDD_3V3: CV1049.1 RV1074.1 UV18.AG12
+PWR_SRC_AC: PL300.1 PL301.1 PR300.1
+RTC_CELL_VBAT: CE17.1 RE16.2 UE3.B64
+RTCBATT: JRTC.1 RH67.2
+RTCVCC: CH44.1 CH80.1 CH173.1 CH196.1 D122.3 RA101.1 RE16.1 RE34.1 RE50.1 RE90.1 RH83.1 RH84.1 RH531.2 RP19.5 RP19.6 UH2.BA22
+SD_VDD2: CR17.1 CR18.1 JCR.16 UR1.13
+SDC_IN: PC201.1 PC205.1 PC206.1 PD302.1 PL200.2 PL201.2 PR300.4 PR304.1 PR399.2
+SP_PLLVDD: CV852.1 RV576.1 UV18.AE8
+V_DDR_REF: PC609.1 PU600.4
+V_DDR_REFA: CD18.1 JDIMM1.164 RH206.2 RH209.1 RH484.2
+V_DDR_REFA_R: CH101.1 RH484.1 UH1.BN13
+V_DDR_REFB: CD29.1 JDIMM2.164 RH207.2 RH210.1 RH485.2
+V_DDR_REFB_R: CH100.1 RH485.1 UH1.BR13
+VCHGR: PC323.1 PC324.1 PC325.1 PC326.1 PD301.1 PQ303.1 PQ303.2 PQ303.3 PR310.4
+VDISPLAY_VCC: CV178.1 CV179.1 JHDMI1.18 RV124.2 RV125.2 UV16.3
+VGA_B+: PC1000.1 PC1001.1 PC1003.1 PC1004.1 PC1042.1 PC1043.1 PC1045.1 PC1046.1 PL1000.2 PL1001.2 PR1014.1 PU1000.1 PU1002.1
+VID_PLLVDD: CV854.1 RV582.1 UV18.AD7
+VLDOIN_1.2V: PJP601.2 PU600.19
+VR_CAP: CE40.1 UE3.B12
+XS_PLLVDD: CV851.1 RV575.1 UV18.AD8
A_DE0: RI19.1 UI3.16
A_DE1: RI20.1 UI3.18
A_EQ0: RI15.1 UI3.17
A_EQ1: RI16.1 UI3.15
AC_DET: PR240.1 PR243.2
AC_DIS: PQ211.2 PQ304.2 PR327.1 UE3.A50
AC_PRESENT: RH533.1 UE3.A54 UH2.BB15
ACAV_IN: PR312.1 UE3.A64
ACAV_IN_NB: DE11.2 RE142.1 UE3.B20
ALL_GPWRGD: RV590.2 RV1132.2 UV20.4
ALW_PWRGD_3V_5V: PQ225.2 PR277.1 PR407.1
ALWON: PR326.1 UE3.A60
AUD_AZA_CPU_SCLK: RH147.1 UH1.G27
AUD_AZA_CPU_SCLK_R: RH147.2 UH2.AM2
AUD_AZA_CPU_SDI_R: RH145.2 UH2.AN2
AUD_AZA_CPU_SDO: RH146.1 UH1.G25
AUD_AZA_CPU_SDO_R: RH146.2 UH2.AM1
AUD_PWR_EN: JAUDIO.2 RH568.1 RH569.1 UA4.3 UA4.5 UH2.BE21
AUX_EN_WOWL: DN3.3 UE3.B38
B+: CV168.1 JAUDIO.24 JAUDIO.26 JAUDIO.28 JAUDIO.30 PC312.1 PC315.1 PC316.1 PC317.1 PC318.1 PJP400.1 PJP600.1 PJP700.1 PJP1200.1 PJP1300.2 PJP1301.2 PL302.2 PL402.1 PL403.1 PL500.1 PL601.1 PL700.1 PL800.1 PL900.1 PL1000.1 PL1001.1 PL1203.1 PL1204.1 PL1303.1 PL1304.1 PL1305.1 PL1501.1 PL1502.1 PR310.1 QV11.4 RV119.1
B++: PC403.1 PC404.1 PC405.1 PC406.1 PC407.1 PC408.1 PC409.1 PC420.1 PJP400.2 PL402.2 PL403.2 PQ400.5 PQ401.5 PR415.2
B+_0.95V: PC802.1 PC803.1 PC804.1 PC806.1 PL800.2 PU800.8
B+_1V: PC502.1 PC503.1 PC504.1 PC506.1 PL500.2 PU500.8
B+_1VSP: PC902.1 PC903.1 PC904.1 PC906.1 PL900.2 PU900.8
B_DE0: RI21.1 UI3.3
B_DE1: RI22.1 UI3.6
B_EQ0: RI17.1 UI3.2
B_EQ1: RI18.1 UI3.4
B_PWM_EC: RE122.2 UE3.B25
BAT1_LED#: JKB.10 RE118.1
BAT2_LED#: JKB.9 RE119.1
BAT_LED#_LV1: LED1.1 RL5.2
BAT_LED#_LV2: LED2.1 RL4.2
BAT_LED#_LV3: LED3.1 RL3.2
BAT_LED#_LV4: LED4.1 RL2.2
BAT_LED#_LV5: LED5.1 RL1.2
BATBTN#: DL1.2 RP19.4 SW2.3 SW2.4 UE3.A63
BATDRV#: PQ303.4 PR319.2
BATT++: BAT100.1 BAT100.2 BAT100.3 BAT100.4 PC109.1 PC110.1 PL107.2 PL108.2
BATT_LED#_LV1: RL5.1 RP24.9 UE4.25
BATT_LED#_LV2: RL4.1 RP24.4 UE4.26
BATT_LED#_LV3: RL3.1 RP24.3 UE4.27
BATT_LED#_LV4: RL2.1 RP24.2 UE4.28
BATT_LED#_LV5: RL1.1 RP24.1 UE4.1
BBS_BIT0: RH130.2 UH2.AT29
BC_CLK_ECE1117: CE81.1 JKB.8 UE3.A20
BC_DAT_ECE1117: CE82.1 JKB.7 RP19.1 UE3.B21
BC_INT#_ECE1117: JKB.6 UE3.A19
BEEP: RA4.1 UE3.B19
BIA_PWM_EC: DV2.3 RE122.1
BIA_PWM_PCH: DV2.2 RH456.2 UH2.W36
BID_BC: RH566.2 RH567.1 UH2.AU41
BID_DIS: RE112.2 RH564.2 RH565.1 UH2.BA41
BOARD_ID: CE51.1 RE67.2 UE3.B10
BOOT_1.2V: PR600.2 PU600.18
BQ24777_REGN: PC320.1 PR311.1 PR318.2 PR321.1 PU300.24
BST1_3V: PC410.2 PR411.1
BST1_5V: PC411.1 PR412.2
BST1_NVVDD: PR1010.1 PU1001.1
BST1_NVVDDS: PR1510.1 PU1501.1
BST2_NVVDD: PR1015.1 PU1001.15
BST_0.95V: PR803.1 PU800.6
BST_1V: PR503.1 PU500.6
BST_1VSP: PR904.1 PU900.6
BST_3V: PR411.2 PU400.9
BST_5V: PR412.1 PU400.17
BST_+1.35VRUN: PR708.1 PU700.4
BT_RADIO_DIS#: DN2.1 RE72.2 UE4.23
BT_RADIO_DIS#_R: DN2.2 JNGFF1.46
CAM_CBL_DET#: JEDP1.29 RH511.1 UH2.U43
CD_WAKE#: RR1.2 RR10.2 UR1.32
CFG0: JXDP.9 RH183.1 RH488.2 UH1.BN25
CFG1: JXDP.11 UH1.BN27
CFG2: JXDP.15 RH184.1 UH1.BN26
CFG3: JXDP.17 RH474.2 UH1.BN28
CFG4: JXDP.27 RH185.1 UH1.BR20
CFG5: JXDP.29 RH186.1 UH1.BM20
CFG6: JXDP.33 RH187.1 UH1.BT20
CFG7: JXDP.35 RH188.1 UH1.BP20
CFG8: JXDP.10 UH1.BR23
CFG9: JXDP.12 UH1.BR22
CFG10: JXDP.16 UH1.BT23
CFG11: JXDP.18 UH1.BT22
CFG12: JXDP.28 UH1.BM19
CFG13: JXDP.30 UH1.BR19
CFG14: JXDP.34 UH1.BP19
CFG15: JXDP.36 UH1.BT19
CFG16: JXDP.6 UH1.BP23
CFG17: JXDP.4 UH1.BN23
CFG18: JXDP.24 UH1.BN22
CFG19: JXDP.22 UH1.BP22
CFG_RCOMP: RH59.1 UH1.BT25
CHAGER_SRC: PC306.1 PC307.1 PC308.1 PC309.1 PC310.1 PC334.1 PC336.1 PC337.1 PL300.2 PL301.2 PQ300.5 PQ301.5
CHARGER_SCL: PR309.2 PU300.12
CHARGER_SDA: PR306.2 PU300.11
CHARGER_SMBCLK: PR309.1 RE23.1 UE3.B50
CHARGER_SMBDAT: PR306.1 RE22.1 UE3.A47
CHG_BTS: PR307.1 PU300.25
CHG_BTS_C: PC321.1 PR307.2
CHG_LGATE: PQ302.4 PU300.23
CHG_SW: PC321.2 PL302.1 PQ300.1 PQ300.2 PQ300.3 PQ301.1 PQ301.2 PQ301.3 PQ302.5 PR313.2 PU300.27
CHG_UGATE: PQ300.4 PQ301.4 PU300.26
CLINK_CLK: JNGFF1.34 UH2.AV2
CLINK_DATA: JNGFF1.32 UH2.AV3
CLINK_RST#: JNGFF1.30 UH2.AW2
CLK_PCI_MEC: CH198.1 RE62.1 RH168.2 UE3.A29
CLK_PCIE_CR: UH2.E6 UR1.5
CLK_PCIE_CR#: UH2.D5 UR1.6
CLK_PCIE_SSD: JNGFF2.55 UH2.R7
CLK_PCIE_SSD#: JNGFF2.53 UH2.R8
CLK_PCIE_TBT: UH2.D7 UT1.V19
CLK_PCIE_TBT#: UH2.D8 UT1.T19
CLK_PCIE_WLAN: JNGFF1.39 UH2.G4
CLK_PCIE_WLAN#: JNGFF1.41 UH2.E5
CLK_PEG_VGA: UH2.U7 UV18.AL13
CLK_PEG_VGA#: UH2.U5 UV18.AK13
CLK_REQ: QV103.3 RV591.2 UV18.AK12
CLK_TP_SIO: CE77.1 DE4.2 JTP.1 RE24.2 UE3.A37
CLKDET#: RH558.1 UH2.BB22
CLKOUT_LPC0: RH168.1 UH2.BC17
CLKOUT_LPC1: RH428.1 UH2.AV19
CLKREQ_PCIE#0: RH548.2 UH2.BC24
CLKRUN#: RH85.1 UE3.A32 UH2.AW22
CPU_24MHZ_N: UH1.D31 UH2.F1
CPU_24MHZ_P: UH1.E31 UH2.G1
CPU_TRIGGER: RH192.1 UH2.AK1
CPU_TRIGGER_R: RH192.2 UH1.J23
CPU_XDP_TCK: JXDP.57 RH491.2 RH498.2 UH1.BR28
CPU_XDP_TDI: RH495.2 RH541.2 UH1.BL32
CPU_XDP_TDO: RH496.2 RH540.2 UH1.BT28
CPU_XDP_TMS: RH494.2 RH542.2 UH1.BP28
CPU_XDP_TRST#: RH497.2 RH543.2 UH1.BP30 UH2.AY5
CR_CLK_REQ#: RP2.6 UH2.BB24 UR1.2
CS_1.2V: PR601.2 PU600.13
CSSN_1: PR300.2 PR302.1
CSSP_1: PR300.3 PR301.1
DAT_TP_SIO: CE78.1 DE4.3 JTP.2 RE26.2 UE3.B40
DAUL_IN: PC202.1 PC203.1 PC204.1 PC220.1 PC222.1 PL200.1 PL201.1 PQ201.1 PQ201.2 PQ201.3 PQ204.3 PQ213.1 PQ213.2 PQ213.3 PQ217.3 PR200.1 PR202.1 PR223.1 PR224.1 PR243.1
DCIN_ACOK: DE11.1 PC216.1 PQ229.2 PQ230.2 PR209.1 PR228.1 PR231.1 PR251.1 PR259.2 PU202.7
DCIN_ACOK#: PQ228.2 PQ230.1 PR235.1 PR252.1 PR268.1 PR283.1 PU204.2
DDC_CLK_HDMI: JHDMI1.15 QX1.6 RV124.1
DDC_DAT_HDMI: JHDMI1.16 QX1.3 RV125.1
DDI1_CPU_AUXN: CT26.2 UH1.E27
DDI1_CPU_AUXN_C: CT26.1 UT1.W11
DDI1_CPU_AUXP: CT25.2 UH1.D27
DDI1_CPU_AUXP_C: CT25.1 UT1.Y11
DDI1_DDPB_CTRLCLK: RP1.3 UH2.BA5 UT1.Y5
DDI1_DDPB_CTRLDAT: RP1.4 UH2.BC4 UT1.R4
DDI1_HTX_TBRX_N0: CT18.2 UH1.K37
DDI1_HTX_TBRX_N0_C: CT18.1 UT1.AC7
DDI1_HTX_TBRX_N1: CT20.2 UH1.J34
DDI1_HTX_TBRX_N1_C: CT20.1 UT1.AC9
DDI1_HTX_TBRX_N2: CT22.2 UH1.H36
DDI1_HTX_TBRX_N2_C: CT22.1 UT1.AC11
DDI1_HTX_TBRX_N3: CT24.2 UH1.J38
DDI1_HTX_TBRX_N3_C: CT24.1 UT1.AC13
DDI1_HTX_TBRX_P0: CT17.2 UH1.K36
DDI1_HTX_TBRX_P0_C: CT17.1 UT1.AB7
DDI1_HTX_TBRX_P1: CT19.2 UH1.J35
DDI1_HTX_TBRX_P1_C: CT19.1 UT1.AB9
DDI1_HTX_TBRX_P2: CT21.2 UH1.H37
DDI1_HTX_TBRX_P2_C: CT21.1 UT1.AB11
DDI1_HTX_TBRX_P3: CT23.2 UH1.J37
DDI1_HTX_TBRX_P3_C: CT23.1 UT1.AB13
DDI1_PCH_HPD: RT41.2 UH2.AW4 UT1.AA2
DDI2_CPU_AUXN: CT107.2 UH1.E26
DDI2_CPU_AUXN_C: CT107.1 UT1.W12
DDI2_CPU_AUXP: CT108.2 UH1.F26
DDI2_CPU_AUXP_C: CT108.1 UT1.Y12
DDI2_DDPC_CTRLCLK: RP1.1 UH2.BB3 UT1.Y8
DDI2_DDPC_CTRLDAT: RP1.2 UH2.BD6 UT1.N4
DDI2_HTX_TBRX_N0: CT30.2 UH1.H33
DDI2_HTX_TBRX_N0_C: CT30.1 UT1.AC15
DDI2_HTX_TBRX_N1: CT32.2 UH1.G38
DDI2_HTX_TBRX_N1_C: CT32.1 UT1.AC17
DDI2_HTX_TBRX_N2: CT34.2 UH1.F35
DDI2_HTX_TBRX_N2_C: CT34.1 UT1.AC19
DDI2_HTX_TBRX_N3: CT36.2 UH1.E36
DDI2_HTX_TBRX_N3_C: CT36.1 UT1.AC21
DDI2_HTX_TBRX_P0: CT29.2 UH1.H34
DDI2_HTX_TBRX_P0_C: CT29.1 UT1.AB15
DDI2_HTX_TBRX_P1: CT31.2 UH1.F37
DDI2_HTX_TBRX_P1_C: CT31.1 UT1.AB17
DDI2_HTX_TBRX_P2: CT33.2 UH1.F34
DDI2_HTX_TBRX_P2_C: CT33.1 UT1.AB19
DDI2_HTX_TBRX_P3: CT35.2 UH1.E37
DDI2_HTX_TBRX_P3_C: CT35.1 UT1.AB21
DDI2_PCH_HPD: RT42.2 UH2.AY2 UT1.Y6
DDR4_DRAMRST#: JDIMM1.108 JDIMM2.108 RD31.1
DDR_A_ACT#: JDIMM1.114 UH1.AU3
DDR_A_ALERT#: JDIMM1.116 UH1.AU5
DDR_A_BG0: JDIMM1.115 UH1.AU1
DDR_A_BG1: JDIMM1.113 UH1.AU2
DDR_A_BS0: JDIMM1.150 UH1.AH5
DDR_A_BS1: JDIMM1.145 UH1.AH1
DDR_A_CAS#: JDIMM1.156 UH1.AD1
DDR_A_D0: JDIMM1.8 UH1.BR6
DDR_A_D1: JDIMM1.7 UH1.BT6
DDR_A_D2: JDIMM1.20 UH1.BP3
DDR_A_D3: JDIMM1.21 UH1.BN3
DDR_A_D4: JDIMM1.4 UH1.BN5
DDR_A_D5: JDIMM1.3 UH1.BP6
DDR_A_D6: JDIMM1.16 UH1.BP2
DDR_A_D7: JDIMM1.17 UH1.BR3
DDR_A_D8: JDIMM1.28 UH1.BK5
DDR_A_D9: JDIMM1.29 UH1.BL4
DDR_A_D10: JDIMM1.41 UH1.BL2
DDR_A_D11: JDIMM1.42 UH1.BM1
DDR_A_D12: JDIMM1.24 UH1.BK4
DDR_A_D13: JDIMM1.25 UH1.BL5
DDR_A_D14: JDIMM1.38 UH1.BK1
DDR_A_D15: JDIMM1.37 UH1.BK2
DDR_A_D16: JDIMM1.50 UH1.BG5
DDR_A_D17: JDIMM1.49 UH1.BG1
DDR_A_D18: JDIMM1.62 UH1.BF2
DDR_A_D19: JDIMM1.63 UH1.BF5
DDR_A_D20: JDIMM1.46 UH1.BG4
DDR_A_D21: JDIMM1.45 UH1.BG2
DDR_A_D22: JDIMM1.58 UH1.BF1
DDR_A_D23: JDIMM1.59 UH1.BF4
DDR_A_D24: JDIMM1.70 UH1.BD2
DDR_A_D25: JDIMM1.71 UH1.BD1
DDR_A_D26: JDIMM1.83 UH1.BC4
DDR_A_D27: JDIMM1.84 UH1.BC5
DDR_A_D28: JDIMM1.66 UH1.BD5
DDR_A_D29: JDIMM1.67 UH1.BD4
DDR_A_D30: JDIMM1.79 UH1.BC1
DDR_A_D31: JDIMM1.80 UH1.BC2
DDR_A_D32: JDIMM1.174 UH1.AB1
DDR_A_D33: JDIMM1.173 UH1.AB2
DDR_A_D34: JDIMM1.187 UH1.AA4
DDR_A_D35: JDIMM1.186 UH1.AA5
DDR_A_D36: JDIMM1.170 UH1.AB5
DDR_A_D37: JDIMM1.169 UH1.AB4
DDR_A_D38: JDIMM1.183 UH1.AA2
DDR_A_D39: JDIMM1.182 UH1.AA1
DDR_A_D40: JDIMM1.195 UH1.V4
DDR_A_D41: JDIMM1.194 UH1.V1
DDR_A_D42: JDIMM1.207 UH1.U5
DDR_A_D43: JDIMM1.208 UH1.U1
DDR_A_D44: JDIMM1.191 UH1.V5
DDR_A_D45: JDIMM1.190 UH1.V2
DDR_A_D46: JDIMM1.203 UH1.U4
DDR_A_D47: JDIMM1.204 UH1.U2
DDR_A_D48: JDIMM1.216 UH1.R1
DDR_A_D49: JDIMM1.215 UH1.R4
DDR_A_D50: JDIMM1.228 UH1.P1
DDR_A_D51: JDIMM1.229 UH1.P5
DDR_A_D52: JDIMM1.211 UH1.R5
DDR_A_D53: JDIMM1.212 UH1.R2
DDR_A_D54: JDIMM1.224 UH1.P2
DDR_A_D55: JDIMM1.225 UH1.P4
DDR_A_D56: JDIMM1.237 UH1.M4
DDR_A_D57: JDIMM1.236 UH1.M1
DDR_A_D58: JDIMM1.249 UH1.L4
DDR_A_D59: JDIMM1.250 UH1.L1
DDR_A_D60: JDIMM1.232 UH1.M5
DDR_A_D61: JDIMM1.233 UH1.M2
DDR_A_D62: JDIMM1.245 UH1.L5
DDR_A_D63: JDIMM1.246 UH1.L2
DDR_A_DQS0: JDIMM1.13 UH1.BP5
DDR_A_DQS1: JDIMM1.34 UH1.BK3
DDR_A_DQS2: JDIMM1.55 UH1.BF3
DDR_A_DQS3: JDIMM1.76 UH1.BC3
DDR_A_DQS4: JDIMM1.179 UH1.AB3
DDR_A_DQS5: JDIMM1.200 UH1.V3
DDR_A_DQS6: JDIMM1.221 UH1.R3
DDR_A_DQS7: JDIMM1.242 UH1.M3
DDR_A_DQS#0: JDIMM1.11 UH1.BR5
DDR_A_DQS#1: JDIMM1.32 UH1.BL3
DDR_A_DQS#2: JDIMM1.53 UH1.BG3
DDR_A_DQS#3: JDIMM1.74 UH1.BD3
DDR_A_DQS#4: JDIMM1.177 UH1.AA3
DDR_A_DQS#5: JDIMM1.198 UH1.U3
DDR_A_DQS#6: JDIMM1.219 UH1.P3
DDR_A_DQS#7: JDIMM1.240 UH1.L3
DDR_A_MA0: JDIMM1.144 UH1.AH3
DDR_A_MA1: JDIMM1.133 UH1.AP4
DDR_A_MA2: JDIMM1.132 UH1.AN4
DDR_A_MA3: JDIMM1.131 UH1.AP5
DDR_A_MA4: JDIMM1.128 UH1.AP2
DDR_A_MA5: JDIMM1.126 UH1.AP1
DDR_A_MA6: JDIMM1.127 UH1.AP3
DDR_A_MA7: JDIMM1.122 UH1.AN1
DDR_A_MA8: JDIMM1.125 UH1.AN3
DDR_A_MA9: JDIMM1.121 UH1.AT4
DDR_A_MA10: JDIMM1.146 UH1.AH2
DDR_A_MA11: JDIMM1.120 UH1.AN2
DDR_A_MA12: JDIMM1.119 UH1.AU4
DDR_A_MA13: JDIMM1.158 UH1.AE3
DDR_A_PAR: JDIMM1.143 UH1.AG3
DDR_A_RAS#: JDIMM1.152 UH1.AH4
DDR_A_WE#: JDIMM1.151 UH1.AG4
DDR_B_ACT#: JDIMM2.114 UH1.AT9
DDR_B_ALERT#: JDIMM2.116 UH1.AR8
DDR_B_BG0: JDIMM2.115 UH1.AR9
DDR_B_BG1: JDIMM2.113 UH1.AR7
DDR_B_BS0: JDIMM2.150 UH1.AH8
DDR_B_BS1: JDIMM2.145 UH1.AH9
DDR_B_CAS#: JDIMM2.156 UH1.AF8
DDR_B_D0: JDIMM2.8 UH1.BT11
DDR_B_D1: JDIMM2.7 UH1.BR11
DDR_B_D2: JDIMM2.20 UH1.BR8
DDR_B_D3: JDIMM2.21 UH1.BP8
DDR_B_D4: JDIMM2.4 UH1.BP11
DDR_B_D5: JDIMM2.3 UH1.BN11
DDR_B_D6: JDIMM2.16 UH1.BT8
DDR_B_D7: JDIMM2.17 UH1.BN8
DDR_B_D8: JDIMM2.28 UH1.BL11
DDR_B_D9: JDIMM2.29 UH1.BL8
DDR_B_D10: JDIMM2.41 UH1.BJ8
DDR_B_D11: JDIMM2.42 UH1.BJ10
DDR_B_D12: JDIMM2.24 UH1.BL12
DDR_B_D13: JDIMM2.25 UH1.BL7
DDR_B_D14: JDIMM2.38 UH1.BJ11
DDR_B_D15: JDIMM2.37 UH1.BJ7
DDR_B_D16: JDIMM2.50 UH1.BG11
DDR_B_D17: JDIMM2.49 UH1.BG10
DDR_B_D18: JDIMM2.62 UH1.BF11
DDR_B_D19: JDIMM2.63 UH1.BF8
DDR_B_D20: JDIMM2.46 UH1.BG7
DDR_B_D21: JDIMM2.45 UH1.BG8
DDR_B_D22: JDIMM2.58 UH1.BF10
DDR_B_D23: JDIMM2.59 UH1.BF7
DDR_B_D24: JDIMM2.70 UH1.BC11
DDR_B_D25: JDIMM2.71 UH1.BC8
DDR_B_D26: JDIMM2.83 UH1.BB11
DDR_B_D27: JDIMM2.84 UH1.BB7
DDR_B_D28: JDIMM2.66 UH1.BC10
DDR_B_D29: JDIMM2.67 UH1.BC7
DDR_B_D30: JDIMM2.79 UH1.BB10
DDR_B_D31: JDIMM2.80 UH1.BB8
DDR_B_D32: JDIMM2.174 UH1.AC11
DDR_B_D33: JDIMM2.173 UH1.AC7
DDR_B_D34: JDIMM2.187 UH1.AA11
DDR_B_D35: JDIMM2.186 UH1.AA7
DDR_B_D36: JDIMM2.170 UH1.AC10
DDR_B_D37: JDIMM2.169 UH1.AC8
DDR_B_D38: JDIMM2.183 UH1.AA10
DDR_B_D39: JDIMM2.182 UH1.AA8
DDR_B_D40: JDIMM2.195 UH1.W8
DDR_B_D41: JDIMM2.194 UH1.W7
DDR_B_D42: JDIMM2.207 UH1.V10
DDR_B_D43: JDIMM2.208 UH1.V11
DDR_B_D44: JDIMM2.191 UH1.W11
DDR_B_D45: JDIMM2.190 UH1.W10
DDR_B_D46: JDIMM2.203 UH1.V8
DDR_B_D47: JDIMM2.204 UH1.V7
DDR_B_D48: JDIMM2.216 UH1.R11
DDR_B_D49: JDIMM2.215 UH1.R7
DDR_B_D50: JDIMM2.228 UH1.P7
DDR_B_D51: JDIMM2.229 UH1.P11
DDR_B_D52: JDIMM2.211 UH1.R8
DDR_B_D53: JDIMM2.212 UH1.R10
DDR_B_D54: JDIMM2.224 UH1.P8
DDR_B_D55: JDIMM2.225 UH1.P10
DDR_B_D56: JDIMM2.237 UH1.M7
DDR_B_D57: JDIMM2.236 UH1.M11
DDR_B_D58: JDIMM2.249 UH1.L11
DDR_B_D59: JDIMM2.250 UH1.L7
DDR_B_D60: JDIMM2.232 UH1.M10
DDR_B_D61: JDIMM2.233 UH1.M8
DDR_B_D62: JDIMM2.245 UH1.L10
DDR_B_D63: JDIMM2.246 UH1.L8
DDR_B_DQS0: JDIMM2.13 UH1.BR9
DDR_B_DQS1: JDIMM2.34 UH1.BJ9
DDR_B_DQS2: JDIMM2.55 UH1.BF9
DDR_B_DQS3: JDIMM2.76 UH1.BB9
DDR_B_DQS4: JDIMM2.179 UH1.AA9
DDR_B_DQS5: JDIMM2.200 UH1.V9
DDR_B_DQS6: JDIMM2.221 UH1.P9
DDR_B_DQS7: JDIMM2.242 UH1.L9
DDR_B_DQS#0: JDIMM2.11 UH1.BP9
DDR_B_DQS#1: JDIMM2.32 UH1.BL9
DDR_B_DQS#2: JDIMM2.53 UH1.BG9
DDR_B_DQS#3: JDIMM2.74 UH1.BC9
DDR_B_DQS#4: JDIMM2.177 UH1.AC9
DDR_B_DQS#5: JDIMM2.198 UH1.W9
DDR_B_DQS#6: JDIMM2.219 UH1.R9
DDR_B_DQS#7: JDIMM2.240 UH1.M9
DDR_B_MA0: JDIMM2.144 UH1.AJ9
DDR_B_MA1: JDIMM2.133 UH1.AK6
DDR_B_MA2: JDIMM2.132 UH1.AK5
DDR_B_MA3: JDIMM2.131 UH1.AL5
DDR_B_MA4: JDIMM2.128 UH1.AL6
DDR_B_MA5: JDIMM2.126 UH1.AM6
DDR_B_MA6: JDIMM2.127 UH1.AN7
DDR_B_MA7: JDIMM2.122 UH1.AN10
DDR_B_MA8: JDIMM2.125 UH1.AN8
DDR_B_MA9: JDIMM2.121 UH1.AR11
DDR_B_MA10: JDIMM2.146 UH1.AH7
DDR_B_MA11: JDIMM2.120 UH1.AN11
DDR_B_MA12: JDIMM2.119 UH1.AR10
DDR_B_MA13: JDIMM2.158 UH1.AF9
DDR_B_PAR: JDIMM2.143 UH1.AJ7
DDR_B_RAS#: JDIMM2.152 UH1.AH10
DDR_B_WE#: JDIMM2.151 UH1.AH11
DDR_CKE0_DIMMA: JDIMM1.109 UH1.AT1
DDR_CKE1_DIMMA: JDIMM1.110 UH1.AT2
DDR_CKE2_DIMMB: JDIMM2.109 UH1.AT8
DDR_CKE3_DIMMB: JDIMM2.110 UH1.AT10
DDR_CS0_DIMMA#: JDIMM1.149 UH1.AD5
DDR_CS1_DIMMA#: JDIMM1.157 UH1.AE2
DDR_CS2_DIMMB#: JDIMM2.149 UH1.AF11
DDR_CS3_DIMMB#: JDIMM2.157 UH1.AE7
DDR_VTT_PG_CTRL: UC1.2 UH1.BT13
DGPU_HOLD_RST#: RV580.2 UH2.AL36 UV19.1
DGPU_PEX_RST#: RV577.1 RV587.2 RV588.2 RV589.1 RV1084.1 RV1131.2 UV21.4
DGPU_PEX_RST#_R: RV577.2 UV18.AJ12
DGPU_PWR_EN: PR1403.1 QV3.2 QV87.2 RH537.1 RH538.1 UH2.AJ39
DGPU_PWR_EN#: QV3.6 QV86.2 QV87.1 RV181.2 RV399.2 RV657.2
DGPU_PWR_EN#_R: CV499.1 QZ7.5 RV399.1
DGPU_PWROK: PR707.2 PU700.3 RH516.2 UH2.AJ38 UV20.2
DH1_NVVDD: PU1000.2 PU1001.2
DH1_NVVDDS: PU1501.2 PU1502.2
DH2_NVVDD: PU1001.14 PU1002.2
DH_1.2V: PQ600.4 PU600.17
DIMM_CHA_SA0: JDIMM1.256 RD1.2 RD28.1
DIMM_CHA_SA1: JDIMM1.260 RD2.2 RD29.1
DIMM_CHA_SA2: JDIMM1.166 RD3.2 RD30.1
DIMM_CHB_SA0: JDIMM2.256 RD4.2 RD38.1
DIMM_CHB_SA1: JDIMM2.260 RD5.2 RD39.1
DIMM_CHB_SA2: JDIMM2.166 RD6.2 RD40.1
DISPOFF#: DV1.1 JEDP1.24 RV107.1
DL1_NVVDD: PU1000.4 PU1001.19
DL1_NVVDDS: PU1501.19 PU1502.4
DL2_NVVDD: PU1001.17 PU1002.4
DL_1.2V: PQ601.4 PU600.15
DMI_CRX_PTX_N0: UH1.E8 UH2.C27
DMI_CRX_PTX_N1: UH1.F6 UH2.B28
DMI_CRX_PTX_N2: UH1.E5 UH2.B29
DMI_CRX_PTX_N3: UH1.J9 UH2.B30
DMI_CRX_PTX_P0: UH1.D8 UH2.B27
DMI_CRX_PTX_P1: UH1.E6 UH2.A28
DMI_CRX_PTX_P2: UH1.D5 UH2.C29
DMI_CRX_PTX_P3: UH1.J8 UH2.A30
DMI_CTX_PRX_N0: UH1.A8 UH2.L27
DMI_CTX_PRX_N1: UH1.B6 UH2.E24
DMI_CTX_PRX_N2: UH1.A5 UH2.G27
DMI_CTX_PRX_N3: UH1.B4 UH2.L29
DMI_CTX_PRX_P0: UH1.B8 UH2.N27
DMI_CTX_PRX_P1: UH1.C6 UH2.G24
DMI_CTX_PRX_P2: UH1.B5 UH2.E26
DMI_CTX_PRX_P3: UH1.D4 UH2.K29
DMIC_CLK_CODEC: CA35.1 DE9.2 RE116.1 UA1.53
DMIC_CLK_CODEC_C: CE73.1 JKB.12 RE116.2
DMIC_DAT_CODEC: CA36.1 DE9.3 RE117.1 UA1.54
DMIC_DAT_CODEC_C: CE74.1 JKB.11 RE117.2
DOCK_TNY_SMB_CLK: RE109.1 RT184.1 UV17.2
DOCK_TNY_SMB_DAT: RE108.1 RT185.1 UV17.3
EC_PECI: CE39.1 RE48.1 UE3.A48
EC_SLP_S0IX#: RH535.1 UE3.A43 UH2.BD24
EC_SMB_CK2_PX: QV21.1 RV326.2 UV18.T4
EC_SMB_DA2_PX: QV21.4 RV325.2 UV18.T3
EDP_AUXN: CV166.1 UH1.B26
EDP_AUXN_C: CV166.2 RV528.1
EDP_AUXN_R: JEDP1.15 RV528.2
EDP_AUXP: CV167.1 UH1.C26
EDP_AUXP_C: CV167.2 RV529.1
EDP_AUXP_R: JEDP1.16 RV529.2
EDP_COMP: RH30.1 UH1.D37
EDP_CTRL_EN: RE107.2 UE3.B53
EDP_CTRL_EN_C: RE107.1 UV17.5
EDP_DISP_UTIL: RH456.1 UH1.A33
EDP_HPD: QV9.3 RV113.1 RV114.1 UH2.BD7
EDP_HPD_S: JEDP1.23 QV9.1 RV113.2
EDP_PANEL_CLK: JEDP1.18 RV546.2 RV549.1 UV17.7
EDP_PANEL_CLK_PCH: RV549.2 UH2.AJ44
EDP_PANEL_DAT: JEDP1.26 RV545.2 RV548.1 UV17.6
EDP_PANEL_DAT_PCH: RV548.2 UH2.AM44
EDP_TXN0: CV159.1 UH1.E29
EDP_TXN0_C: CV159.2 RV521.1
EDP_TXN0_R: JEDP1.12 RV521.2
EDP_TXN1: CV161.1 UH1.E28
EDP_TXN1_C: CV161.2 RV523.1
EDP_TXN1_R: JEDP1.9 RV523.2
EDP_TXN2: CV163.1 UH1.B29
EDP_TXN2_C: CV163.2 RV525.1
EDP_TXN2_R: JEDP1.6 RV525.2
EDP_TXN3: CV165.1 UH1.B28
EDP_TXN3_C: CV165.2 RV527.1
EDP_TXN3_R: JEDP1.3 RV527.2
EDP_TXP0: CV158.1 UH1.D29
EDP_TXP0_C: CV158.2 RV520.1
EDP_TXP0_R: JEDP1.13 RV520.2
EDP_TXP1: CV160.1 UH1.F28
EDP_TXP1_C: CV160.2 RV522.1
EDP_TXP1_R: JEDP1.10 RV522.2
EDP_TXP2: CV162.1 UH1.A29
EDP_TXP2_C: CV162.2 RV524.1
EDP_TXP2_R: JEDP1.7 RV524.2
EDP_TXP3: CV164.1 UH1.C28
EDP_TXP3_C: CV164.2 RV526.1
EDP_TXP3_R: JEDP1.4 RV526.2
EN_INVPWR: QV12.2 RV135.1 UE3.A25
EN_PD_HV: PR234.1 PR270.1 PU204.1 RT178.2
ENVDD: DV7.1 RZ40.1 UZ8.4
ENVDD_PCH: DV7.3 UE3.A7 UH2.W42
FAN1_PWM: JFAN1.1 RE100.2 UE3.A24
FAN1_TACH: CE66.1 DE7.2 RE81.2 UE3.B22
FAN2_PWM: JFAN2.1 RE101.2 UE3.A23
FAN2_TACH: CE67.1 DE8.2 RE83.2 UE3.B23
FB_1.8V: PC1401.2 PR1402.2 PR1405.1 PU1400.1
FB_3V: PC401.2 PR401.2 PR403.2 PU400.4
FB_5V: PC402.1 PR402.1 PR404.1 PU400.2
FBA_ABI#_H: UV18.Y29 UV24.J4
FBA_ABI#_L: UV18.V28 UV23.J4
FBA_CAS#_H: UV18.V31 UV24.G3
FBA_CAS#_L: UV18.Y32 UV23.L3
FBA_CKE_H: RV607.2 UV18.Y33 UV24.J3
FBA_CKE_L: RV605.2 UV18.V33 UV23.J3
FBA_CLK0: RV622.1 UV18.R30 UV23.J12
FBA_CLK0#: RV621.1 UV18.R31 UV23.J11
FBA_CLK1: RV627.1 UV18.AB31 UV24.J12
FBA_CLK1#: RV626.1 UV18.AC31 UV24.J11
FBA_CS#_H: UV18.AA31 UV24.L12
FBA_CS#_L: UV18.U30 UV23.G12
FBA_D0: UV18.L28 UV23.A4
FBA_D1: UV18.M29 UV23.A2
FBA_D2: UV18.L29 UV23.B4
FBA_D3: UV18.M28 UV23.B2
FBA_D4: UV18.N31 UV23.E4
FBA_D5: UV18.P29 UV23.E2
FBA_D6: UV18.R29 UV23.F4
FBA_D7: UV18.P28 UV23.F2
FBA_D8: UV18.J28 UV23.A11
FBA_D9: UV18.H29 UV23.A13
FBA_D10: UV18.J29 UV23.B11
FBA_D11: UV18.H28 UV23.B13
FBA_D12: UV18.G29 UV23.E11
FBA_D13: UV18.E31 UV23.E13
FBA_D14: UV18.E32 UV23.F11
FBA_D15: UV18.F30 UV23.F13
FBA_D16: UV18.C34 UV23.U11
FBA_D17: UV18.D32 UV23.U13
FBA_D18: UV18.B33 UV23.T11
FBA_D19: UV18.C33 UV23.T13
FBA_D20: UV18.F33 UV23.N11
FBA_D21: UV18.F32 UV23.N13
FBA_D22: UV18.H33 UV23.M11
FBA_D23: UV18.H32 UV23.M13
FBA_D24: UV18.P34 UV23.U4
FBA_D25: UV18.P32 UV23.U2
FBA_D26: UV18.P31 UV23.T4
FBA_D27: UV18.P33 UV23.T2
FBA_D28: UV18.L31 UV23.N4
FBA_D29: UV18.L34 UV23.N2
FBA_D30: UV18.L32 UV23.M4
FBA_D31: UV18.L33 UV23.M2
FBA_D32: UV18.AG28 UV24.U4
