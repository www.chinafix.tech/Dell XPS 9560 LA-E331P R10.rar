# Allegro board Dell XPS 9560 LA-E331P R10.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG_GTX_C_HRX_P2: length 17.8
  TOP w0.152: CV822.2 190.68,67 190.11,67 189.14,66.04 188.86,66.04 v2(188.74,65.91)
  IN1 w0.089: 179.22,65.96 177.69,65.96 177.26,66.39 176.25,66.39 175.57,67.06 175.41,67.06 v2(175.16,66.81)
  IN1 w0.107: 179.22,65.96 179.31,65.96 179.67,65.6 187.13,65.6 187.67,66.14 188.5,66.14 v2(188.74,65.91)
  BOTTOM w0.076: v2(175.16,66.81) 174.83,67.14 UH1.F12
PEG_GTX_C_HRX_P3: length 18.9
  TOP w0.152: v2(185.2,66.81) 185.2,66.71 185.74,66.18 187.3,66.18 189.32,68.19 192.16,68.19 192.47,68.5 CV824.2
  IN1 w0.089: 179.84,66.73 178.08,66.73 177.65,67.16 176.34,67.16 176.16,67.34 176.16,67.52 176.24,67.6 v2(176.46,67.6)
  IN1 w0.107: 179.84,66.73 183.31,66.73 183.4,66.82 184.74,66.82 184.76,66.81 v2(185.2,66.81)
  BOTTOM w0.076: v2(176.46,67.6) 176.13,67.92 UH1.D13
PEG_GTX_C_HRX_P4: length 19.1
  TOP w0.152: v2(186.22,67.22) 186.22,67.22 186.62,66.82 187.3,66.82 189.36,68.88 190.65,68.88 190.65,68.88 CV826.2
  IN1 w0.089: 179.57,67.41 179.56,67.41 179.55,67.42 179.49,67.42 179.48,67.43 179.43,67.43 179.29,67.57 177.65,67.57 177.2,68.02 175.01,68.02 174.76,68.27 174.66,68.37 v2(174.45,68.37)
  IN1 w0.107: 179.57,67.41 181.88,67.41 182.43,67.95 185.83,67.95 186.22,67.57 v2(186.22,67.22)
  BOTTOM w0.076: v2(174.45,68.37) 174.83,68.75 UH1.F14
PEG_GTX_C_HRX_P5: length 19.2
  TOP w0.152: CV828.2 192.26,70.3 189.03,70.3 188.02,69.29 187.87,69.29 187.78,69.38 187.78,69.66 v2(187.84,69.72)
  IN1 w0.089: v2(176.46,69.17) 176.26,69.17 176.15,69.06 176.15,68.92 176.27,68.79 177.54,68.79 177.92,68.42 179.87,68.42 179.88,68.43 179.9,68.43
  IN1 w0.107: 179.9,68.43 181.74,68.43 183.2,69.88 187.31,69.88 187.47,69.72 v2(187.84,69.72)
  BOTTOM w0.076: UH1.D15 176.13,69.5 v2(176.46,69.17)
PEG_GTX_C_HRX_P6: length 20
  TOP w0.152: CV830.2 189.13,70.91 v2(187.2,72.84)
  IN1 w0.089: v2(175.16,69.96) 175.16,70.18 175.28,70.3 175.39,70.3 176.16,69.54 177.51,69.54 177.88,69.16 179.87,69.16 179.88,69.15 179.9,69.15
  IN1 w0.107: 179.9,69.15 181.85,69.15 186.11,73.4 187.02,73.4 187.26,73.16 187.26,72.91 v2(187.2,72.84)
  BOTTOM w0.076: v2(175.16,69.96) 175.16,70.03 UH1.F16
PEG_GTX_C_HRX_P7: length 21
  TOP w0.152: v2(185.04,73.61) 184.98,73.54 184.98,73.18 185.13,73.03 185.61,73.03 186.63,74.05 188.02,74.05 189.74,72.33 192.26,72.33 CV832.2
  IN1 w0.089: v2(176.46,70.75) 176.29,70.75 176.13,70.58 176.13,70.44 176.29,70.28 178.26,70.28 178.55,69.99 179.81,69.99 179.82,70 179.88,70 179.89,70.01 179.9,70.01
  IN1 w0.107: v2(185.04,73.61) 184.71,73.61 184.57,73.74 184.25,73.74 180.52,70.01 179.9,70.01
  BOTTOM w0.076: v2(176.46,70.75) 176.13,71.07 UH1.D17
PEG_GTX_C_HRX_P8: length 20.2
  TOP w0.152: CV834.2 190.57,73.31 189.88,73.31 188.25,74.94 186.4,74.94 186.06,75.28 v2(186.06,75.7)
  IN1 w0.089: 179.9,70.93 179.87,70.93 179.86,70.93 177.7,70.93 177.32,71.31 175.64,71.31 175.58,71.38 175.58,71.64 175.45,71.76 175.32,71.76 175.16,71.59 v2(175.16,71.54)
  IN1 w0.107: 179.9,70.93 180.34,70.93 185.07,75.67 186.02,75.67 v2(186.06,75.7)
  BOTTOM w0.076: UH1.E18 175.16,71.6 v2(175.16,71.54)
PEG_GTX_C_HRX_P9: length 22.4
  TOP w0.152: v2(186.37,76.93) 186.46,76.84 186.46,76.53 187.35,75.64 188.19,75.64 189.84,73.99 191.77,73.99 191.8,73.96 CV836.2
  IN1 w0.089: 179.94,71.51 179.92,71.51 179.91,71.52 179.2,71.52 179.06,71.38 178.01,71.38 177.73,71.65 175.93,71.65 175.27,72.32 v2(175.16,72.32)
  IN1 w0.107: v2(186.37,76.93) 186.37,77.21 186.29,77.28 186.11,77.28 180.34,71.51 179.94,71.51
  BOTTOM w0.076: v2(175.16,72.32) 175.48,72.65 UH1.E19
PEG_GTX_C_HRX_P10: length 22.2
  TOP w0.152: CV838.2 190.82,75.61 190.51,75.3 190.11,75.3 188.67,76.74 188.67,77.67 188.35,77.99 186.72,77.99 186.56,78.15 186.56,78.37 v2(186.66,78.48)
  IN1 w0.089: v2(175.16,73.9) 175.35,73.7 175.48,73.7 176.31,72.87 177.47,72.87 177.78,72.56 179.87,72.56 179.88,72.57 179.9,72.57
  IN1 w0.107: 179.9,72.57 180.24,72.57 185.04,77.37 185.04,78.08 185.75,78.8 186.07,78.8 186.39,78.48 v2(186.66,78.48)
  BOTTOM w0.076: v2(175.16,73.9) 175.16,73.83 UH1.E20
PEG_GTX_C_HRX_P11: length 24.8
  TOP w0.152: v2(186.51,79.67) 186.62,79.57 186.62,79.39 187.01,78.99 188.44,78.99 191.29,76.15 192.14,76.15 192.32,75.97 193.4,75.97 CV840.2
  IN1 w0.089: v2(175.81,73.9) 175.99,73.72 175.99,73.54 176.25,73.28 178.27,73.28 178.55,73 179.68,73 179.69,72.99 179.85,72.99 179.89,73.03 179.9,73.03
  IN1 w0.107: 179.9,73.03 180.12,73.03 184.59,77.5 184.59,78.46 186.34,80.21 186.64,80.21 186.85,80.01 186.85,79.85 186.66,79.67 v2(186.51,79.67)
  BOTTOM w0.076: v2(175.81,73.9) 175.81,73.96 UH1.E21
PEG_GTX_C_HRX_P12: length 27.2
  TOP w0.152: v2(187.01,83.4) 187.26,83.15 187.49,83.15 187.83,82.8 187.83,81.18 191.52,77.49 191.76,77.49 CV842.2
  IN1 w0.089: 179.9,74.17 179.89,74.17 179.88,74.16 179.82,74.16 179.81,74.15 177.63,74.15 177.33,74.45 176.27,74.45 175.53,75.19 175.39,75.19 175.16,75.43 v2(175.16,75.47)
  IN1 w0.107: v2(187.01,83.4) 186.82,83.22 186.64,83.22 186.5,83.36 185.99,83.36 185.21,82.58 185.21,80.29 183.77,78.85 183.77,77.89 180.05,74.17 179.9,74.17
  BOTTOM w0.076: v2(175.16,75.47) 175.16,75.4 UH1.E22
PEG_GTX_C_HRX_P13: length 27.9
  TOP w0.152: CV844.2 193.35,78.11 191.55,78.11 188.52,81.14 188.52,82.93 188.34,83.11 v2(188.19,83.11)
  IN1 w0.089: v2(175.81,75.47) 176,75.28 176,75.1 176.24,74.86 178,74.86 178.35,74.5 178.88,74.5 178.89,74.49 178.92,74.49
  IN1 w0.107: v2(188.19,83.11) 187.49,83.82 185.86,83.82 184.77,82.73 184.77,80.45 183.36,79.04 183.36,78.06 179.79,74.49 178.92,74.49
  BOTTOM w0.076: UH1.E23 175.81,75.54 v2(175.81,75.47)
PEG_GTX_C_HRX_P14: length 27
  TOP w0.152: v2(188.23,84.27) 188.94,84.27 189.81,83.4 189.81,80.96 190.61,80.16 190.63,80.15 191.53,79.24 191.65,79.24 CV846.2
  IN1 w0.089: 177.74,76.01 177.72,76.01 177.71,76.01 177.66,76.01 177.65,76.02 177.06,76.02 176.84,76.25 176.34,76.25 175.98,75.89 175.71,75.89 175.63,75.96 175.63,76.09 v2(175.81,76.26)
  IN1 w0.107: 177.74,76.01 180.43,76.01 182.75,78.32 182.75,79.41 184.16,80.82 184.16,82.98 186.05,84.87 187.71,84.87 187.88,84.7 187.99,84.7 188.23,84.46 v2(188.23,84.27)
  BOTTOM w0.076: UH1.E24 175.48,76.59 v2(175.81,76.26)
PEG_GTX_C_HRX_P15: length 27.2
  TOP w0.152: v2(188.91,85.16) 189.17,85.16 190.6,83.73 190.6,81.6 192.05,80.15 193.28,80.15 CV848.2
  IN1 w0.107: v2(175.77,77.05) 176.14,77.42 177.45,77.42 177.6,77.26 180.82,77.26 182.13,78.57 182.13,79.68 183.54,81.09 183.54,83.24 185.79,85.49 188.33,85.49 188.44,85.38 188.69,85.38 v2(188.91,85.16)
  BOTTOM w0.076: v2(175.77,77.05) 175.77,77.16 UH1.E25
PEG_GTX_HRX_N0: length 9.9
  TOP w0.089: 198.42,67.45 198.44,67.47 198.44,67.57 198.82,67.96 198.82,68.21 v2(199.01,68.4)
  TOP w0.152: 198.42,67.45 197.71,66.73 196.01,66.73 194.09,64.81 CV819.1
  BOTTOM w0.102: UV18.AJ14 198.69,68.72 v2(199.01,68.4)
PEG_GTX_HRX_N1: length 8.9
  TOP w0.089: 196.04,67.95 196.04,68.1 196.79,68.84 197.99,68.84 198.04,68.79 199.59,68.79 v2(199.89,68.49)
  TOP w0.152: CV821.1 193.15,65.91 194,65.91 v5(194.35,66.26) 196.04,67.95
  BOTTOM w0.102: UV18.AG14 200.3,68.9 v2(199.89,68.49)
PEG_GTX_HRX_N2: length 8.6
  TOP w0.102: 195.24,68.75 195.38,68.75 196.29,69.67 197.99,69.67 198.26,69.93 v2(198.26,70.06)
  TOP w0.152: CV823.1 191.52,67.38 193.86,67.38 195.24,68.75
  BOTTOM w0.102: v2(198.26,70.06) 198.62,69.7 UV18.AJ15
PEG_GTX_HRX_N3: length 6.2
  TOP w0.089: v2(197.45,70.14) 197.45,70.36 197.37,70.43 197.19,70.43 197.17,70.42 196.43,70.42 v5(195.75,69.74) 195.38,69.36 195.2,69.36 194.91,69.08
  TOP w0.152: CV825.1 193.21,68 193.84,68 194.91,69.08
  BOTTOM w0.102: v2(197.45,70.14) 197.45,70.17 UV18.AK16
PEG_GTX_HRX_N4: length 9.5
  TOP w0.089: 194.64,70.11 194.76,70.11 v5(195.67,71.03) 196.19,71.55 197.32,71.55 197.4,71.62 198.56,71.62 198.82,71.36 198.82,71.26 v2(199.09,71)
  TOP w0.152: CV827.1 191.57,69.36 193.58,69.36 194.34,70.11 194.64,70.11
  BOTTOM w0.102: v2(199.09,71) UV18.AJ17
PEG_GTX_HRX_N5: length 8.7
  TOP w0.089: 194.87,70.83 194.97,70.93 194.97,71.1 195.67,71.8 196.47,71.8 196.49,71.78 197.03,71.78 197.05,71.8 198.91,71.8 199.46,71.26 199.7,71.26 v2(199.95,71.01)
  TOP w0.152: CV829.1 193.22,70.05 193.62,70.05 193.84,70.26 194.15,70.57 194.61,70.57 194.87,70.83
  BOTTOM w0.102: v2(199.95,71.01) 199.95,71.01 UV18.AG17
PEG_GTX_HRX_N6: length 8.2
  TOP w0.102: 194.64,72.24 194.76,72.24 194.98,72.46 196.81,72.46 197.28,72.94 197.64,72.94 198.01,72.57 v2(198.29,72.57)
  TOP w0.152: 194.64,72.24 194.56,72.24 194.08,71.76 193.81,71.76 193.73,71.67 193.63,71.67 193.42,71.47 191.5,71.47 CV831.1
  BOTTOM w0.102: v2(198.29,72.57) 198.29,72.57 198.29,72.57 198.66,72.2 UV18.AJ18
PEG_GTX_HRX_N7: length 5.7
  TOP w0.089: 194.64,72.77 194.65,72.77 194.66,72.78 194.66,72.82 194.75,72.92 194.93,72.92 195.7,72.92 195.84,72.78 196.79,72.78 197.18,73.18 197.18,73.18 v2(197.41,73.41)
  TOP w0.152: CV833.1 193.28,72.13 193.54,72.13 193.77,72.36 193.99,72.36 194.4,72.77 194.64,72.77
  BOTTOM w0.102: UV18.AK19 197.47,73.41 v2(197.41,73.41)
PEG_GTX_HRX_N8: length 9.3
  TOP w0.089: v2(199.16,73.5) 199.03,73.5 198.67,73.14 198.15,73.14 197.87,73.41 197.87,73.67 197.74,73.8 196.22,73.8 196.03,73.61 v5(195.26,73.61) 194.69,73.61 194.64,73.55
  TOP w0.152: 194.64,73.55 194.07,73.55 193.67,73.15 191.63,73.15 CV835.1
  BOTTOM w0.102: UV18.AJ20 198.76,73.9 v2(199.16,73.5)
PEG_GTX_HRX_N9: length 9
  TOP w0.089: 194.64,74.67 194.65,74.67 194.71,74.61 195.66,74.61 195.9,74.37 198.95,74.37 199.2,74.11 199.32,74.11 199.34,74.13 199.88,74.13 199.89,74.11 200.28,74.11 200.56,73.84 200.56,73.68 v2(200.74,73.5)
  TOP w0.152: 194.64,74.67 v5(194.08,74.67) 193.61,74.67 193.38,74.44 193.22,74.44 CV837.1
  BOTTOM w0.102: UV18.AG20 v2(200.74,73.5)
PEG_GTX_HRX_N10: length 8.3
  TOP w0.089: 194.64,75.18 194.66,75.18 194.65,75.19 194.71,75.26 195.53,75.26 v5(195.9,74.89) 196.23,74.56 197.81,74.56 198.05,74.8 198.05,74.97 v2(198.28,75.2)
  TOP w0.152: CV839.1 191.63,75.18 194.64,75.18
  BOTTOM w0.102: UV18.AJ21 198.69,74.79 v2(198.28,75.2)
PEG_GTX_HRX_N11: length 4.3
  TOP w0.102: v2(197.39,75.99) 197.01,76.37 196.11,76.37 196.07,76.34 v5(195.37,76.34) 194.72,76.34 194.65,76.41 194.64,76.41
  TOP w0.152: 194.64,76.41 194.19,76.41 194.17,76.43 194.16,76.43 CV841.1
  BOTTOM w0.102: UV18.AK22 197.84,75.55 v2(197.39,75.99)
PEG_GTX_HRX_N12: length 7
  TOP w0.076: v2(198.26,75.97) 198.26,76.07 198.02,76.3 197.72,76.3 197.34,76.68 195.63,76.68 195.3,77.01 195.28,77.01 195.26,77.02
  TOP w0.102: 195.26,77.02 195.12,77.16 194.64,77.16
  TOP w0.152: 194.64,77.16 192.66,77.16 CV843.1
  BOTTOM w0.102: UV18.AJ23 v2(198.26,75.97)
PEG_GTX_HRX_N13: length 8.6
  TOP w0.076: v2(200.73,76) 200.56,76.18 200.56,76.28 200.27,76.56 198.97,76.56 198.82,76.72 198.82,77 198.57,77.26 v5(197.01,77.26) 196.31,77.26 195.24,78.33 194.92,78.33 194.76,78.49
  TOP w0.152: 194.76,78.49 194.19,78.49 CV845.1
  BOTTOM w0.102: UV18.AG23 v2(200.73,76)
PEG_GTX_HRX_N14: length 7.4
  TOP w0.076: v2(198.25,77.63) 198.25,77.63 198.08,77.81 198.08,77.97 197.86,78.18 196.43,78.18 196.29,78.32 196.29,78.34 196.29,78.35
  TOP w0.102: 195.53,79.22 195.53,79.11 196.29,78.35
  TOP w0.152: 195.53,79.22 195.21,79.54 192.57,79.54 CV847.1
  BOTTOM w0.102: UV18.AJ24 v2(198.25,77.63)
PEG_GTX_HRX_N15: length 5.9
  TOP w0.089: 197.56,79.26 197.56,79.01 197.42,78.88 v2(197.42,78.53)
  TOP w0.152: 197.56,79.26 197.56,79.8 196.88,80.48 v5(196.22,80.48) 194.17,80.48 CV849.1
  BOTTOM w0.102: v2(197.42,78.53) 197.84,78.12 UV18.AK25
PEG_GTX_HRX_P0: length 9.9
  TOP w0.089: 198.19,67.69 198.2,67.7 198.31,67.7 198.64,68.03 198.64,68.26 198.48,68.42 v2(198.21,68.42)
  TOP w0.152: 198.19,67.69 197.57,67.06 v5(196.32,67.06) 195.88,67.06 193.95,65.14 191.75,65.14 191.44,65.45 CV818.1
  BOTTOM w0.102: v2(198.21,68.42) 197.84,68.8 UV18.AK14
PEG_GTX_HRX_P1: length 8.9
  TOP w0.089: v2(199.92,69.31) 199.92,69.24 199.64,68.97 198.12,68.97 198.07,69.02 196.71,69.02 195.89,68.2 195.82,68.2 195.81,68.18
  TOP w0.152: 195.81,68.18 193.86,66.24 193.3,66.24 CV820.1
  BOTTOM w0.102: UV18.AH14 199.64,68.9 199.92,69.18 v2(199.92,69.31)
PEG_GTX_HRX_P2: length 8.6
  TOP w0.102: 195.47,68.52 195.49,68.54 195.49,68.6 196.37,69.48 198.12,69.48 v2(198.27,69.33)
  TOP w0.152: 195.47,68.52 v5(194.84,67.89) 194,67.05 191.63,67.05 CV822.1
  BOTTOM w0.102: UV18.AK15 197.9,69.7 v2(198.27,69.33)
PEG_GTX_HRX_P3: length 6.2
  TOP w0.089: v2(197.42,70.94) 197.43,70.71 197.35,70.61 v5(196.9,70.61) 196.38,70.61 195.83,70.06 195.8,70.06 195.43,69.69 195.43,69.67 195.3,69.54 195.13,69.54 194.9,69.31 194.68,69.31 194.68,69.31
  TOP w0.152: CV824.1 193.24,68.33 193.7,68.33 194.68,69.31
  BOTTOM w0.102: UV18.AL16 197.04,70.56 v2(197.42,70.94)
PEG_GTX_HRX_P4: length 9.6
  TOP w0.089: v2(198.24,71) 198.5,71 198.65,71.15 198.65,71.29 198.48,71.45 197.47,71.45 197.4,71.37 196.26,71.37 196.03,71.14 196.03,71.08 195.62,70.66 195.56,70.66 194.83,69.94 194.83,69.87 194.74,69.78 194.64,69.78
  TOP w0.152: 194.64,69.78 194.49,69.78 v5(194.17,69.47) 193.74,69.03 191.57,69.03 CV826.1
  BOTTOM w0.102: UV18.AK17 v2(198.24,71)
PEG_GTX_HRX_P5: length 8.7
  TOP w0.089: v2(199.94,71.8) 199.94,71.52 199.85,71.43 199.53,71.43 198.98,71.98 v5(196.76,71.98) 195.74,71.98 195.74,71.98 195.59,71.98 194.76,71.15 194.72,71.15 194.64,71.07
  TOP w0.152: 194.64,71.07 194.47,70.9 194.28,70.9 194.01,70.9 193.96,70.85 193.48,70.38 193.22,70.38 CV828.1
  BOTTOM w0.102: UV18.AH17 v2(199.94,71.8)
PEG_GTX_HRX_P6: length 8.2
  TOP w0.102: 194.79,72 195.06,72.27 197.2,72.27 197.28,72.19 197.74,72.19 197.84,72.29 197.84,72.47 197.74,72.57 v2(197.44,72.57)
  TOP w0.152: CV830.1 191.65,71.14 193.56,71.14 193.77,71.34 193.86,71.34 193.95,71.43 194.22,71.43 v5(194.56,71.77) 194.79,72
  BOTTOM w0.102: UV18.AK18 197.46,72.57 v2(197.44,72.57)
PEG_GTX_HRX_P7: length 5.6
  TOP w0.089: v2(196.63,73.41) 196.74,73.52 196.92,73.52 197.01,73.44 197.01,73.26 196.71,72.96 195.91,72.96 195.77,73.1 195,73.1 195,73.1 194.68,73.1 194.68,73.1 194.64,73.1
  TOP w0.152: 194.64,73.1 194.26,73.1 193.86,72.69 193.63,72.69 193.4,72.46 193.17,72.46 CV832.1
  BOTTOM w0.102: UV18.AL19 196.67,73.41 v2(196.63,73.41)
PEG_GTX_HRX_P8: length 9.3
  TOP w0.089: 194.64,73.88 194.65,73.88 194.66,73.87 194.75,73.78 194.98,73.78 194.99,73.8 195.53,73.8 195.55,73.78 195.95,73.78 196.14,73.97 v5(198.26,73.97) 198.57,73.97 198.78,73.77 198.78,73.5 198.59,73.31 198.5,73.31 v2(198.31,73.5)
  TOP w0.152: 194.64,73.88 193.94,73.88 193.53,73.48 191.52,73.48 CV834.1
  BOTTOM w0.102: UV18.AK20 197.91,73.9 v2(198.31,73.5)
PEG_GTX_HRX_P9: length 9
  TOP w0.089: 194.64,74.34 194.72,74.43 195.58,74.43 195.82,74.19 198.87,74.19 199.13,73.94 v5(199.61,73.94) 200.13,73.94 200.21,73.94 200.38,73.76 200.38,73.64 200.24,73.5 v2(199.94,73.5)
  TOP w0.152: CV836.1 193.23,74.11 193.52,74.11 193.75,74.34 194.64,74.34
  BOTTOM w0.102: UV18.AH20 v2(199.94,73.5)
PEG_GTX_HRX_P10: length 8.3
  TOP w0.089: 194.64,75.51 194.66,75.51 194.73,75.43 195.6,75.43 195.82,75.22 195.85,75.22 196.33,74.74 197.73,74.74 197.88,74.88 197.88,75.16 197.79,75.25 197.48,75.25 v2(197.43,75.2)
  TOP w0.152: CV838.1 191.52,75.51 v5(192.41,75.51) 194.64,75.51
  BOTTOM w0.102: UV18.AK21 197.84,74.79 v2(197.43,75.2)
PEG_GTX_HRX_P11: length 4.3
  TOP w0.102: 194.64,76.08 194.7,76.15 195.04,76.15 195.07,76.11 195.66,76.11 195.69,76.15 195.99,76.15 196.15,75.98 196.15,75.76 196.37,75.54 196.57,75.54 196.76,75.73 196.76,75.83 v2(196.59,75.99)
  TOP w0.152: CV840.1 194.18,76.08 194.64,76.08
  BOTTOM w0.102: UV18.AL22 197.04,75.55 v2(196.59,75.99)
PEG_GTX_HRX_P12: length 7
  TOP w0.076: v2(198.28,76.72) 198.02,76.47 197.78,76.47 197.4,76.85 195.69,76.85 195.42,77.12 195.42,77.15 195.41,77.16
  TOP w0.102: 195.2,77.36 195.21,77.36 195.41,77.16
  TOP w0.152: 195.2,77.36 195.07,77.49 v5(194.82,77.49) 192.65,77.49 CV842.1
  BOTTOM w0.102: v2(198.28,76.72) 197.95,76.4 UV18.AK23
PEG_GTX_HRX_P13: length 8.6
  TOP w0.076: v2(199.93,76) 200.29,76 200.39,76.1 200.39,76.21 200.2,76.4 198.9,76.4 198.65,76.65 198.65,76.93 198.5,77.09 197.43,77.09 197.4,77.07 196.73,77.07 196.71,77.09 196.24,77.09 195.17,78.16 194.77,78.16
  TOP w0.102: 194.76,78.16 194.77,78.16
  TOP w0.152: CV844.1 194.17,78.16 194.76,78.16
  BOTTOM w0.102: UV18.AH23 v2(199.93,76)
PEG_GTX_HRX_P14: length 7.3
  TOP w0.076: v2(197.47,77.63) 197.77,77.63 197.91,77.77 197.91,77.9 197.8,78.01 196.36,78.01 196.18,78.19 196.16,78.19 196.14,78.21
  TOP w0.102: 196.14,78.21 195.33,79.02
  TOP w0.152: 195.33,79.02 195.14,79.21 v5(194.84,79.21) 192.73,79.21 192.66,79.13 CV846.1
  BOTTOM w0.102: v2(197.47,77.63) 197.52,77.63 197.84,77.32 UV18.AK24
PEG_GTX_HRX_P15: length 5.8
  TOP w0.089: 197.23,79.26 197.23,79.25 197.24,79.24 197.29,79.24 197.35,79.17 197.35,79.06 197.24,78.95 197.24,78.86 196.94,78.58 196.92,78.56 v2(196.64,78.56)
  TOP w0.152: CV848.1 194.18,80.15 196.75,80.15 197.23,79.66 197.23,79.26
  BOTTOM w0.102: UV18.AL25 197.04,78.16 v2(196.64,78.56)
PEG_HTX_C_GRX_N0: length 7.5
  BOTTOM w0.102: 194.25,67.81 194.33,67.81 195.02,67.81 195.29,67.54 195.89,67.54 UV18.AM12
  BOTTOM w0.152: CH36.2 189.95,65.67 191.07,65.67 193.21,67.81 194.25,67.81
PEG_HTX_C_GRX_N1: length 6.6
  BOTTOM w0.102: 194.25,68.27 194.27,68.27 194.28,68.28 194.28,68.28 194.29,68.29 194.53,68.29 194.61,68.21 195.08,68.21 195.33,68.46 195.52,68.46 195.95,68.9 UV18.AM14
  BOTTOM w0.152: CH34.2 190.7,66.65 191.41,66.65 193.02,68.27 194.25,68.27
PEG_HTX_C_GRX_N2: length 6
  BOTTOM w0.152: CH32.2 189.38,68.28 v5(190.17,68.28) 191.38,68.28 192.52,69.43 194.37,69.43 UV18.AP15
PEG_HTX_C_GRX_N3: length 6.6
  BOTTOM w0.102: 195.07,69.81 195.1,69.79 195.1,69.57 195.3,69.37 195.79,69.37 196.12,69.7 UV18.AM15
  BOTTOM w0.152: 195.07,69.81 194.72,70.16 194.38,70.16 194.19,69.97 192.01,69.97 191.38,69.34 190.65,69.34 CH30.2
PEG_HTX_C_GRX_N4: length 7.8
  BOTTOM w0.089: UV18.AM17 196.11,71.4 195.85,71.66 195.71,71.66 195.64,71.72 195.3,71.72 195.11,71.53 195.11,71.17 195,71.05 193.9,71.05 193.83,71.13 193.8,71.13
  BOTTOM w0.152: CH28.2 189.24,70.9 191.29,70.9 191.52,71.13 193.8,71.13
PEG_HTX_C_GRX_N5: length 5.8
  BOTTOM w0.089: 193.8,71.77 193.93,71.89 193.93,72.06 194.06,72.2 194.21,72.2 194.29,72.11 194.29,71.94 194.19,71.83 194.19,71.71 194.28,71.62 194.4,71.62 194.5,71.72 194.71,71.72 194.83,71.84 194.83,72 UV18.AP18
  BOTTOM w0.152: 193.8,71.77 193.72,71.69 v5(191.49,71.69) 191,71.69 190.69,71.38 CH26.2
PEG_HTX_C_GRX_N6: length 7.6
  BOTTOM w0.089: 193.8,73.02 193.85,73.02 193.9,72.97 195.01,72.97 195.26,72.72 195.82,72.72 196.04,72.5 196.04,72.4 UV18.AM18
  BOTTOM w0.152: CH24.2 189.4,72.91 190.74,72.91 190.86,73.02 v5(191.47,73.02) 193.8,73.02
PEG_HTX_C_GRX_N7: length 6.1
  BOTTOM w0.089: 193.72,73.48 193.73,73.48 193.76,73.51 193.84,73.51 193.89,73.55 194.11,73.55 194.3,73.36 195.29,73.36 195.3,73.37 195.82,73.37 196.05,73.61 196.05,73.71 UV18.AM20
  BOTTOM w0.152: 193.72,73.48 191.41,73.48 191.32,73.57 190.76,73.57 CH22.2
PEG_HTX_C_GRX_N8: length 5.9
  BOTTOM w0.152: CH20.2 189.29,74.91 189.86,74.91 189.88,74.94 192.15,74.94 192.49,74.6 194.08,74.6 194.2,74.48 194.42,74.48 UV18.AP21
PEG_HTX_C_GRX_N9: length 6.2
  BOTTOM w0.102: UV18.AM21 195.87,75.07 195.29,75.07 194.97,75.39 193.91,75.39 193.91,75.38 193.87,75.38
  BOTTOM w0.152: CH18.2 190.76,75.93 192.3,75.93 v5(192.55,75.69) 192.85,75.38 193.87,75.38
PEG_HTX_C_GRX_N10: length 8.1
  BOTTOM w0.102: UV18.AM23 195.42,75.99 195.14,75.72 194.18,75.72 193.89,76.01 193.87,76.01
  BOTTOM w0.152: CH16.2 189,76.51 v5(191.39,76.51) 192.4,76.51 192.9,76.01 193.87,76.01
PEG_HTX_C_GRX_N11: length 5.1
  BOTTOM w0.152: CH14.2 190.21,77.81 v5(191.02,77.81) 192.7,77.81 193.35,77.16 193.99,77.16 194.19,76.96 194.4,76.96 UV18.AP24
PEG_HTX_C_GRX_N12: length 8.9
  BOTTOM w0.102: 193.87,77.7 193.99,77.7 194.02,77.67 194.69,77.67 194.81,77.67 195.11,77.37 195.11,77.06 195.3,76.87 195.8,76.87 196.13,77.2 UV18.AM24
  BOTTOM w0.152: CH12.2 188.72,78.74 189.63,78.74 189.76,78.88 v5(190.09,78.88) 192.28,78.88 193.46,77.7 193.87,77.7
PEG_HTX_C_GRX_N13: length 7.5
  BOTTOM w0.102: 193.87,78.87 193.98,78.87 194.29,78.56 194.93,78.56 195.11,78.73 195.11,79.04 195.3,79.23 195.92,79.23 195.94,79.21 196.13,79.01 UV18.AM26
  BOTTOM w0.152: 193.87,78.87 193.78,78.97 192.56,80.18 190.18,80.18 CH10.2
PEG_HTX_C_GRX_N14: length 7.1
  BOTTOM w0.102: UV18.AP27 194.64,79.58 194.54,79.48 194.35,79.48 194.12,79.71 194.12,79.74 194.11,79.76
  BOTTOM w0.152: 194.11,79.76 192.82,81.05 191.06,81.05 v5(190.85,81.26) 190.65,81.45 188.72,81.45 CH8.2
PEG_HTX_C_GRX_N15: length 7.4
  BOTTOM w0.102: UV18.AM27 195.75,79.98 195.63,80.03 195.33,80.15 195.21,80.28 195.21,80.28 194.62,80.87 194.17,80.87 194.11,80.94
  BOTTOM w0.152: CH6.2 190.18,82.53 v5(191,82.53) 192.48,82.53 192.5,82.51 193.95,81.06 193.98,81.06 194.11,80.94
PEG_HTX_C_GRX_P0: length 7.5
  BOTTOM w0.102: 194.25,67.48 194.39,67.48 194.44,67.53 194.91,67.53 195.03,67.4 195.03,66.91 195.14,66.81 195.37,66.81 195.44,66.88 UV18.AN12
  BOTTOM w0.152: CH35.2 190.17,65.34 v5(190.73,65.34) 191.2,65.34 193.34,67.48 194.25,67.48
PEG_HTX_C_GRX_P1: length 6.6
  BOTTOM w0.102: UV18.AN14 195.44,69.06 195.34,69.16 195.22,69.16 195.16,69.22 195.06,69.22 194.97,69.13 194.97,68.82 195.07,68.72 195.07,68.6 194.96,68.49 194.72,68.49 194.65,68.57 194.4,68.57 194.37,68.6 194.25,68.6
  BOTTOM w0.152: CH33.2 190.94,66.99 191.27,66.99 v5(191.88,67.59) 192.88,68.6 194.25,68.6
PEG_HTX_C_GRX_P2: length 6
  BOTTOM w0.152: CH31.2 189.46,67.95 191.52,67.95 192.47,68.91 v5(192.47,68.91) 192.66,69.1 194.44,69.1 UV18.AP14
PEG_HTX_C_GRX_P3: length 6.6
  BOTTOM w0.102: 195.24,70.11 195.77,70.11 195.87,70.01 195.87,69.85 195.72,69.7 UV18.AN15
  BOTTOM w0.152: 195.24,70.11 194.86,70.49 194.25,70.49 194.06,70.3 191.88,70.3 v5(191.44,69.86) 191.24,69.67 190.86,69.67 CH29.2
PEG_HTX_C_GRX_P4: length 7.8
  BOTTOM w0.089: UV18.AN17 195.52,71.48 195.77,71.48 195.88,71.37 195.88,71.11 195.74,70.97 195.17,70.97 195.07,70.87 193.9,70.87 193.83,70.8 193.8,70.8
  BOTTOM w0.152: CH27.2 189.48,70.57 191.43,70.57 191.65,70.8 v5(192.42,70.8) 193.8,70.8
PEG_HTX_C_GRX_P5: length 5.8
  BOTTOM w0.089: 193.8,72.23 193.94,72.38 194.35,72.38 194.5,72.53 194.88,72.53 195.01,72.4 195.01,71.77 UV18.AP17
  BOTTOM w0.152: CH25.2 v5(192.83,72.02) 193.59,72.02 193.8,72.23
PEG_HTX_C_GRX_P6: length 7.5
  BOTTOM w0.089: UV18.AN18 195.77,72.2 195.86,72.29 195.86,72.43 195.75,72.54 195.19,72.54 194.94,72.79 193.92,72.79 193.81,72.69 193.8,72.69
  BOTTOM w0.152: CH23.2 189.32,72.58 190.88,72.58 190.99,72.69 193.8,72.69
PEG_HTX_C_GRX_P7: length 6.1
  BOTTOM w0.089: 193.86,73.8 193.85,73.81 193.72,73.81 ; UV18.AN20 195.79,73.9 195.88,73.81 195.88,73.68 195.74,73.55 195.23,73.55 195.22,73.54 194.37,73.54 194.18,73.73 193.93,73.73 193.87,73.8
  BOTTOM w0.097: 193.87,73.8 193.86,73.8
  BOTTOM w0.152: 193.72,73.81 v5(192.6,73.81) 191.55,73.81 191.46,73.9 190.76,73.9 CH21.2
PEG_HTX_C_GRX_P8: length 5.9
  BOTTOM w0.152: UV18.AP20 194.39,74.15 194.06,74.15 193.94,74.27 192.36,74.27 192.02,74.61 v5(191.45,74.61) 190.02,74.61 190,74.58 189.29,74.58 CH19.2
PEG_HTX_C_GRX_P9: length 6.2
  BOTTOM w0.102: UV18.AN21 195.52,74.62 195.52,74.41 195.42,74.3 195.2,74.3 195.01,74.49 195.01,74.95 194.86,75.11 194.03,75.11 194,75.08 193.91,75.08 193.89,75.05 193.87,75.05
  BOTTOM w0.152: CH17.2 190.76,75.6 192.17,75.6 192.31,75.45 192.71,75.05 193.87,75.05
PEG_HTX_C_GRX_P10: length 8.1
  BOTTOM w0.102: 193.87,76.34 193.89,76.34 193.91,76.31 194,76.31 194.31,76 195.02,76 195.09,76.06 195.09,76.2 194.97,76.32 194.97,76.63 195.06,76.72 195.16,76.72 195.22,76.66 195.34,76.66 195.44,76.56 UV18.AN23
  BOTTOM w0.152: 193.87,76.34 193.04,76.34 192.53,76.84 188.82,76.84 CH15.2
PEG_HTX_C_GRX_P11: length 5.1
  BOTTOM w0.152: CH13.2 190.16,77.48 v5(192.33,77.48) 192.57,77.48 193.22,76.83 193.85,76.83 194.05,76.63 194.4,76.63 UV18.AP23
PEG_HTX_C_GRX_P12: length 8.9
  BOTTOM w0.102: UV18.AN24 195.54,77.1 195.74,77.1 195.89,77.25 195.89,77.49 195.74,77.64 195.23,77.64 194.92,77.95 194.58,77.95 194.58,77.95 194.13,77.95 194.11,77.97 194.07,77.97 194.02,78.03 193.98,78.03
  BOTTOM w0.152: 193.98,78.03 193.6,78.03 192.42,79.21 v5(192.22,79.21) 189.62,79.21 189.49,79.07 188.72,79.07 CH11.2
PEG_HTX_C_GRX_P13: length 7.5
  BOTTOM w0.102: 193.64,78.63 193.65,78.63 193.68,78.63 193.75,78.56 193.89,78.56 194.18,78.28 195.05,78.28 195.23,78.46 195.74,78.46 195.87,78.59 195.87,78.9 195.76,79 195.54,79 UV18.AN26
  BOTTOM w0.152: 193.64,78.63 192.42,79.85 v5(191.06,79.85) 190.18,79.85 CH9.2
PEG_HTX_C_GRX_P14: length 7.1
  BOTTOM w0.102: 193.87,79.53 193.89,79.51 193.93,79.51 194.24,79.2 194.5,79.2 194.64,79.06 UV18.AP26
  BOTTOM w0.152: 193.87,79.53 192.68,80.72 v5(192.15,80.72) 190.92,80.72 190.62,81.02 190.52,81.12 188.72,81.12 CH7.2
PEG_HTX_C_GRX_P15: length 7.4
  BOTTOM w0.102: 193.87,80.7 193.99,80.59 194.5,80.59 195.1,80 195.1,79.85 194.97,79.72 194.97,79.47 195.07,79.37 195.15,79.37 195.22,79.43 195.31,79.43 195.44,79.56 UV18.AN27
  BOTTOM w0.152: CH5.2 190.18,82.2 192.34,82.2 v5(192.62,81.92) 193.81,80.73 193.84,80.73 193.87,80.7
PEG_HTX_GRX_N0: length 13.9
  BOTTOM w0.076: 181.1,64.83 180.95,64.83 180.77,65.01 178.95,65.01 178.89,65.07 178.54,65.07 178.31,65.3 177.21,65.3 177.06,65.44 177.06,65.59 177.14,65.67 177.39,65.67 UH1.B10
  BOTTOM w0.152: CH36.1 189.31,65.71 189.02,65.43 188.4,65.43 188.14,65.17 187.21,65.17 186.32,64.28 v5(184.11,64.28) 181.68,64.28 181.13,64.83 181.1,64.83
PEG_HTX_GRX_N1: length 14.6
  BOTTOM w0.076: UH1.B11 177.59,66.26 177.59,66.12 177.77,65.93 178.24,65.93 178.34,66.04 178.85,66.04 179.29,65.59 180.63,65.59
  BOTTOM w0.152: 180.63,65.59 181.03,65.59 181.88,64.74 v5(182.83,64.74) 186.04,64.74 187.41,66.11 187.74,66.11 188.57,66.94 189.68,66.94 189.87,66.75 189.95,66.75 CH34.1
PEG_HTX_GRX_N2: length 13.6
  BOTTOM w0.076: UH1.B12 177.14,67.2 177.07,67.13 177.07,67.01 177.17,66.91 178.3,66.91 178.43,66.78 179.46,66.78
  BOTTOM w0.152: 179.46,66.78 179.5,66.75 181.46,66.75 182.33,65.87 185.59,65.87 v5(186.12,66.4) 186.95,67.23 187.28,67.23 188.19,68.14 188.43,68.14 CH32.1
PEG_HTX_GRX_N3: length 14.5
  BOTTOM w0.076: 179.95,67.26 179.93,67.26 179.81,67.38 179.25,67.38 178.97,67.66 178.46,67.66 178.34,67.53 177.81,67.53 177.6,67.75 177.6,67.82 UH1.B13
  BOTTOM w0.152: CH30.1 189.84,69.47 188.87,69.47 187.74,68.33 187.14,68.33 187.01,68.21 186.5,68.21 185.98,67.69 185.41,67.69 184.45,66.73 v5(183.97,66.73) 182.11,66.73 181.59,67.26 179.95,67.26
PEG_HTX_GRX_N4: length 13.2
  BOTTOM w0.076: UH1.B14 177.39,68.82 177.15,68.82 177.08,68.74 177.08,68.6 177.19,68.49 178.31,68.49 178.41,68.39 179.9,68.39
  BOTTOM w0.152: 179.9,68.39 v5(183.72,68.39) 184.43,68.39 184.85,68.8 185.42,68.8 186.52,69.91 186.95,69.91 187.52,70.48 187.88,70.48 188.16,70.75 188.42,70.75 188.44,70.78 188.46,70.78 CH28.1
PEG_HTX_GRX_N5: length 14.2
  BOTTOM w0.076: 179.89,68.87 179.76,69 179.35,69 179.1,69.24 178.48,69.24 178.32,69.08 177.85,69.08 177.57,69.36 177.57,69.42 UH1.B15
  BOTTOM w0.152: 179.89,68.87 v5(182.41,68.87) 184.26,68.87 184.68,69.29 185.25,69.29 186.33,70.36 186.76,70.36 187.33,70.93 187.64,70.93 188.27,71.56 189.84,71.56 CH26.1
PEG_HTX_GRX_N6: length 13.6
  BOTTOM w0.076: 179.95,70.02 179.9,69.97 178.98,69.97 178.84,69.83 178.51,69.83 178.3,70.04 177.2,70.04 177.06,70.18 177.06,70.29 177.17,70.39 177.39,70.39 UH1.B16
  BOTTOM w0.152: 179.95,70.02 v5(181.79,70.02) 183.81,70.02 184.23,70.44 184.8,70.44 185.84,71.48 186.3,71.48 186.87,72.05 187.15,72.05 188.08,72.98 188.51,72.98 CH24.1
PEG_HTX_GRX_N7: length 14.5
  BOTTOM w0.076: 179.91,70.48 179.9,70.48 179.84,70.54 179.11,70.54 178.89,70.77 178.55,70.77 178.44,70.66 177.86,70.66 177.61,70.91 177.61,70.96 UH1.B17
  BOTTOM w0.152: CH22.1 189.83,73.61 188.07,73.61 187.89,73.78 187.44,73.78 v5(186.95,73.29) 184.6,70.94 184.02,70.94 183.57,70.48 179.91,70.48
PEG_HTX_GRX_N8: length 13.8
  BOTTOM w0.076: UH1.C18 177.06,72.21 177.55,72.21 177.76,71.99 177.76,71.75 177.88,71.63 178.47,71.63 178.56,71.55 180.82,71.55 180.9,71.62
  BOTTOM w0.152: CH20.1 188.41,74.91 186.99,74.91 184.17,72.09 183.57,72.09 183.1,71.62 v5(181.89,71.62) 180.9,71.62
PEG_HTX_GRX_N9: length 14.5
  BOTTOM w0.076: 179.73,72.42 179.66,72.35 179.5,72.35 179.3,72.55 178.49,72.55 178.32,72.38 177.95,72.38 177.8,72.53 177.8,72.7 177.88,72.78 178.02,72.78 UH1.A19
  BOTTOM w0.152: 179.73,72.42 182.78,72.42 v5(184.19,73.83) 184.74,74.38 185.35,74.38 186.68,75.71 187.84,75.71 187.94,75.82 189.26,75.82 189.37,75.93 189.87,75.93 CH18.1
PEG_HTX_GRX_N10: length 13.2
  BOTTOM w0.076: UH1.C20 176.94,73.35 176.94,73.25 177.16,73.03 178.2,73.03 178.29,72.94 179.27,72.94 179.3,72.97
  BOTTOM w0.152: CH16.1 188.02,76.42 187.2,76.42 186.95,76.17 185.88,76.17 182.67,72.97 v5(180.95,72.97) 179.3,72.97
PEG_HTX_GRX_N11: length 14.1
  BOTTOM w0.076: 180.4,74.13 180.4,74.13 179.73,74.13 179.66,74.2 178.46,74.2 178.25,74 177.87,74 177.75,74.12 177.75,74.23 177.82,74.3 178.07,74.3 UH1.A21
  BOTTOM w0.152: CH14.1 189.21,77.75 188.71,77.75 188.51,77.95 186.51,77.95 186.25,77.69 185.67,77.69 v5(182.52,74.54) 182.11,74.13 180.4,74.13
PEG_HTX_GRX_N12: length 13.5
  BOTTOM w0.076: 180.42,74.69 179.45,74.69 179.2,74.45 178.56,74.45 178.41,74.59 177.15,74.59 176.95,74.79 176.95,74.91 UH1.C22
  BOTTOM w0.152: CH12.1 187.8,78.78 187.51,78.78 187.39,78.91 186.24,78.91 v5(184.39,77.06) 182.21,74.88 180.68,74.88 180.5,74.69 180.42,74.69
PEG_HTX_GRX_N13: length 14.7
  BOTTOM w0.076: UH1.A23 178.03,75.92 177.86,75.92 177.74,75.79 177.74,75.65 177.85,75.54 178.43,75.54 178.57,75.68 179.36,75.68 179.4,75.64 179.86,75.64 179.89,75.68 179.9,75.68
  BOTTOM w0.152: 179.9,75.68 179.98,75.68 180.4,76.09 v5(181.08,76.09) 181.84,76.09 186.42,80.67 187.64,80.67 187.79,80.51 188.74,80.51 189.07,80.18 189.29,80.18 CH10.1
PEG_HTX_GRX_N14: length 13.9
  BOTTOM w0.076: UH1.C24 176.82,76.65 177.1,76.93 177.55,76.93 177.75,76.73 177.75,76.58 177.97,76.36 178.35,76.36 178.45,76.26 179.76,76.26 179.88,76.39
  BOTTOM w0.152: CH8.1 187.83,81.45 186.09,81.45 v5(184.21,79.57) 182.08,77.44 180.94,77.44 179.88,76.39
PEG_HTX_GRX_N15: length 14.5
  BOTTOM w0.076: 179.76,77.34 179.76,77.33 179.64,77.21 178.42,77.21 178.31,77.1 177.92,77.1 177.77,77.26 177.77,77.36 177.84,77.44 UH1.A25
  BOTTOM w0.152: 179.76,77.34 180.66,78.24 181.76,78.24 185.84,82.32 v5(186.83,82.32) 187.44,82.32 187.52,82.39 188.54,82.39 188.71,82.57 189.33,82.57 CH6.1
PEG_HTX_GRX_P0: length 13.8
  BOTTOM w0.076: UH1.C10 176.9,65.51 176.9,65.37 177.14,65.13 178.24,65.13 178.47,64.91 178.82,64.91 178.88,64.84 180.71,64.84 180.86,64.69 180.86,64.64 180.87,64.63
  BOTTOM w0.152: 180.87,64.63 180.9,64.59 181.54,63.95 v5(185.75,63.95) 186.46,63.95 187.35,64.84 188.28,64.84 188.54,65.1 189.3,65.1 CH35.1
PEG_HTX_GRX_P1: length 14.6
  BOTTOM w0.076: UH1.A11 177.98,66.52 177.86,66.52 177.75,66.4 177.75,66.19 177.84,66.1 178.17,66.1 178.27,66.2 178.92,66.2 179.36,65.76 180.37,65.76 180.47,65.86
  BOTTOM w0.152: 180.47,65.86 180.53,65.92 181.17,65.92 v5(181.53,65.56) 182.02,65.07 185.9,65.07 187.28,66.44 187.61,66.44 188.43,67.27 189.81,67.27 189.83,67.26 CH33.1
PEG_HTX_GRX_P2: length 13.6
  BOTTOM w0.076: UH1.C12 176.9,67.08 176.9,66.94 177.1,66.75 178.23,66.75 178.36,66.62 179.16,66.62 179.28,66.5
  BOTTOM w0.152: CH31.1 188.63,67.81 188.33,67.81 187.41,66.9 187.09,66.9 185.73,65.54 v5(184.65,65.54) 182.19,65.54 181.32,66.42 179.36,66.42 179.28,66.5
PEG_HTX_GRX_P3: length 14.5
  BOTTOM w0.076: 179.95,67.59 179.93,67.59 179.9,67.55 179.32,67.55 179.04,67.83 178.39,67.83 178.27,67.7 177.88,67.7 177.76,67.81 177.76,67.99 177.85,68.08 177.99,68.08 UH1.A13
  BOTTOM w0.152: CH29.1 189.89,69.8 188.73,69.8 187.6,68.67 187,68.67 186.87,68.54 186.36,68.54 v5(186.11,68.28) 185.84,68.02 185.27,68.02 184.32,67.06 182.25,67.06 181.73,67.59 179.95,67.59
PEG_HTX_GRX_P4: length 13.3
  BOTTOM w0.076: UH1.C14 176.88,68.68 176.88,68.53 177.12,68.3 178.21,68.3 178.37,68.13 179.74,68.13 179.78,68.09 179.86,68.09 179.89,68.06 179.9,68.06
  BOTTOM w0.152: 179.9,68.06 v5(181.33,68.06) 184.57,68.06 184.99,68.47 185.56,68.47 186.66,69.58 187.09,69.58 187.66,70.15 188.02,70.15 188.29,70.42 188.5,70.42 CH27.1
PEG_HTX_GRX_P5: length 14.2
  BOTTOM w0.076: UH1.A15 178,69.64 177.81,69.64 177.74,69.57 177.74,69.43 177.91,69.26 178.27,69.26 178.41,69.4 179.17,69.4 179.41,69.16 179.83,69.16 179.87,69.2 179.89,69.2
  BOTTOM w0.152: 179.89,69.2 v5(180.39,69.2) 184.13,69.2 184.54,69.62 185.12,69.62 186.19,70.69 186.62,70.69 187.19,71.26 187.5,71.26 188.13,71.89 189.89,71.89 CH25.1
PEG_HTX_GRX_P6: length 13.6
  BOTTOM w0.076: UH1.C16 176.9,70.24 176.9,70.11 177.13,69.88 178.23,69.88 178.44,69.67 178.91,69.67 179.05,69.81 179.7,69.81 179.82,69.69
  BOTTOM w0.152: CH23.1 188.43,72.65 188.22,72.65 187.28,71.72 187,71.72 186.43,71.15 185.97,71.15 184.94,70.11 184.36,70.11 183.95,69.69 v5(183.41,69.69) 179.82,69.69
PEG_HTX_GRX_P7: length 14.5
  BOTTOM w0.076: UH1.A17 178.03,71.19 177.84,71.19 177.78,71.13 177.78,70.98 177.93,70.83 178.37,70.83 178.48,70.94 178.96,70.94 179.18,70.71 179.8,70.71 179.9,70.81 179.91,70.81
  BOTTOM w0.152: 179.91,70.81 v5(180.46,70.81) 183.43,70.81 183.89,71.27 184.46,71.27 187.31,74.11 188.02,74.11 188.2,73.94 189.9,73.94 CH21.1
PEG_HTX_GRX_P8: length 13.7
  BOTTOM w0.076: UH1.B18 177.35,72.01 177.18,72.01 177.06,71.89 177.06,71.71 177.17,71.61 177.67,71.61 177.81,71.47 178.4,71.47 178.49,71.38 180.63,71.38 180.72,71.29 180.76,71.29
  BOTTOM w0.152: 180.76,71.29 183.24,71.29 183.71,71.76 184.31,71.76 v5(185.22,72.67) 187.13,74.58 188.41,74.58 CH19.1
PEG_HTX_GRX_P9: length 14.5
  BOTTOM w0.076: 179.83,72.18 179.43,72.18 179.23,72.39 178.56,72.39 178.39,72.22 177.88,72.22 177.64,72.46 177.64,72.51 UH1.B19
  BOTTOM w0.152: 179.83,72.18 179.92,72.09 182.92,72.09 v5(183.34,72.52) 184.87,74.05 185.48,74.05 186.82,75.38 187.97,75.38 188.08,75.49 189.4,75.49 189.51,75.6 189.87,75.6 CH17.1
PEG_HTX_GRX_P10: length 13.2
  BOTTOM w0.076: UH1.B20 177.18,73.5 177.1,73.43 177.1,73.31 177.22,73.19 178.27,73.19 178.35,73.11 179.04,73.11 179.18,73.25
  BOTTOM w0.152: CH15.1 188.02,76.75 187.06,76.75 186.81,76.5 185.74,76.5 v5(185.22,75.98) 182.54,73.3 179.23,73.3 179.18,73.25
PEG_HTX_GRX_P11: length 14.1
  BOTTOM w0.076: 180.4,73.8 180.39,73.8 180.22,73.96 179.67,73.96 179.59,74.04 178.53,74.04 178.32,73.83 177.8,73.83 177.58,74.05 177.58,74.14 UH1.B21
  BOTTOM w0.152: 180.4,73.8 182.24,73.8 183.82,75.38 v5(183.84,75.38) 183.84,75.39 185.81,77.36 186.39,77.36 186.64,77.62 188.37,77.62 188.57,77.42 189.38,77.42 CH13.1
PEG_HTX_GRX_P12: length 13.5
  BOTTOM w0.076: UH1.B22 177.22,75.08 177.11,74.97 177.11,74.86 177.22,74.76 178.48,74.76 178.62,74.61 179.13,74.61 179.38,74.85 180.19,74.85 180.41,75.07
  BOTTOM w0.152: 180.41,75.07 180.54,75.21 182.07,75.21 v5(185.17,78.31) 186.11,79.24 187.52,79.24 187.65,79.11 187.88,79.11 CH11.1
PEG_HTX_GRX_P13: length 14.8
  BOTTOM w0.076: 179.9,75.35 179.78,75.47 179.33,75.47 179.29,75.51 178.64,75.51 178.5,75.37 177.78,75.37 177.58,75.58 177.58,75.72 UH1.B23
  BOTTOM w0.152: CH9.1 189.29,79.85 188.93,79.85 188.6,80.18 187.65,80.18 187.5,80.34 186.56,80.34 v5(182.46,76.24) 181.98,75.76 180.53,75.76 180.12,75.35 179.9,75.35
PEG_HTX_GRX_P14: length 13.9
  BOTTOM w0.076: 180.12,76.15 180.06,76.09 178.38,76.09 178.28,76.19 177.9,76.19 177.76,76.34 177.14,76.34 177.06,76.41 177.06,76.66 177.14,76.74 177.34,76.74 UH1.B24
  BOTTOM w0.152: 180.12,76.15 181.07,77.11 182.22,77.11 v5(182.66,77.56) 186.23,81.12 187.83,81.12 CH7.1
PEG_HTX_GRX_P15: length 14.6
  BOTTOM w0.076: UH1.B25 177.6,77.27 177.6,77.19 177.86,76.93 178.38,76.93 178.49,77.05 179.79,77.05
  BOTTOM w0.152: 179.79,77.05 179.93,77.05 180.8,77.91 181.9,77.91 v5(184.92,80.93) 185.98,81.99 187.58,81.99 187.66,82.06 188.67,82.06 188.85,82.24 189.26,82.24 CH5.1
PEG_RCOMP: length 8
  TOP w0.089: v1(176.67,56.12) 176.42,55.86 175.7,55.86 v2(175.65,55.81)
  BOTTOM w0.254: 175.26,58.63 174.88,59.01 174.88,59.89 174.57,60.21 174.31,60.21 UH1.G2
  BOTTOM w0.381: RH24.2 174.74,54.87 175.24,55.37 175.24,55.45 175.6,55.81 v2(175.65,55.81) 175.76,55.92 175.76,58.13 175.26,58.63
PEX_TERMP: length 6.4
  BOTTOM w0.102: 192.72,83.13 194.46,81.4 UV18.AP29
  BOTTOM w0.14: v1(190.21,84.9) RV578.2 191.91,84.9 192.72,84.08 192.72,83.13
PEX_TSTCLK_OUT: length 1.3
  TOP w0.14: v2(199.07,78.43) 199.02,78.48 RV47.2
  BOTTOM w0.102: UV18.AJ26 198.69,78.82 v2(199.07,78.43)
PEX_TSTCLK_OUT#: length 1.5
  TOP w0.14: v2(198.31,78.37) 198.11,78.57 RV47.1
  BOTTOM w0.102: v2(198.31,78.37) 197.84,78.84 UV18.AK26
PLTRST_CPU#: length 128
  TOP w0.14: RH480.1 v2(119.19,92.64) 119.19,92.2 v3(119.41,91.98)
  IN4 w0.091: v2(104.78,19.57) 104.76,19.58 104.72,19.58 104.4,19.91 104.4,20.25 105.29,21.15 106.83,21.15 108.21,22.53 108.21,25.73 107.96,25.97 107.96,34.4 119.89,46.33 119.89,57.32 120.39,57.83 120.39,62.3 122.33,64.23 122.33,65.2 123.21,66.08 123.21,67.79 126.62,71.2 126.62,78.56 130.37,82.31 130.37,82.63 132.18,84.44 v2(132.18,85.38) 132.18,87.47 128.65,91 128.65,96.77 127.41,98.01 125.28,98.01 124.3,97.02 122.23,97.02 120.6,95.39 120.6,94.88 120.55,94.83 120.55,94.29 120.6,94.24 120.6,93.55 119.69,92.64 v2(119.19,92.64)
  BOTTOM w0.076: 134.62,84.43 135.92,84.43 136.48,83.88 137.64,83.88 137.73,83.97 138.43,83.97 UH1.BP35
  BOTTOM w0.089: 101.75,12.18 100.86,11.29 99.28,11.29 99.16,11.41 99.16,11.41 99.14,11.42 99.14,11.42 98.95,11.61 UH2.AK2
  BOTTOM w0.127: 101.75,12.18 102.09,12.51 104.09,12.51 104.4,12.81 105.24,12.81 105.45,13.02 105.45,15.5 105.39,15.56 105.39,17.22 104.78,17.83 v2(104.78,19.57)
  BOTTOM w0.14: 134.62,84.43 133.12,84.43 v2(132.18,85.38)
POWER_SW_IN#: length 26.6
  TOP w0.14: v2(295.86,12.4) 295.75,12.4 295.23,11.88 UE3.B67 ; RE36.1 283.01,4.71 RE110.1 282.58,5.22 283.14,5.78 284.32,5.78 287.18,2.92 292.07,2.92 292.2,3.04 292.2,4.56 RE34.2 292.11,5.43 292.25,5.43 292.48,5.66 292.48,5.67 292.53,5.72 292.53,6.93 CE30.1 293.07,7.45 293.47,7.84 293.47,7.9 294.03,8.46 v1(294.03,8.91) 294.21,9.09 v2(294.54,9.09)
  BOTTOM w0.14: v2(295.86,12.4) 295.82,12.37 295.82,10.53 294.54,9.25 v2(294.54,9.09)
PP_HV:
  vias: v2(23.97,55.71) v2(23.95,55.09) v3(24.78,55.29)
PROC_DETECT#: length 108.9
  TOP w0.14: v2(104.26,34.31) 104.31,34.31 104.9,34.9 v3(106.07,34.9)
  IN2 w0.089: v2(77.33,16.28) 77.33,17.73 75.87,19.19 75.87,24.62 76.37,25.12 76.37,26.12 76.78,26.53
  IN2 w0.099: v2(104.26,34.31) 102.77,34.31 102.42,34.65 100.95,34.65 98.74,32.44 98.37,32.08 89.85,32.08 85.98,28.2 81.1,28.2 79.53,26.63 76.88,26.63 76.78,26.53
  IN6 w0.099: v2(104.26,34.31) 104.34,34.31 104.65,34.62 104.65,37.45 105.24,38.04 108.15,38.04 115.77,45.66 115.77,54.53 117.74,56.49 117.74,60.88 120.54,63.68 120.54,64.45 121.68,65.59 123.99,65.59 124.72,66.32 124.72,69.26 126.61,71.15 126.61,76.41 128.98,78.79 128.98,83.16 v2(129.51,83.69)
  BOTTOM w0.089: UH2.Y44 77.65,16.6 v2(77.33,16.28)
  BOTTOM w0.14: RH519.1 129.78,83.96 v2(129.51,83.69)
PS8713_PD#: length 10.2
  TOP w0.14: v2(314.31,32.33) 316.12,32.33 316.8,33.02 v1(317.51,33.02) 317.83,33.33 RI36.2 317.85,34.19 317.85,37.99 RI46.2
  BOTTOM w0.14: v2(314.31,32.33) 314.03,32.33 313.56,32.8 DI11.2
PSID: length 3.3
  TOP w0.254: v2(19.37,71.83) 18.75,72.45 v1(18.75,73.76) PR102.1
PSID-1: length 7.1
  TOP w0.14: PR103.2 39.98,35 41.73,35 v3(42.93,36.2)
  TOP w0.254: PQ101.2 38.18,33.42 38.38,33.62 38.38,34.33 PR105.1 PR103.2
PSID-2: length 4.8
  TOP w0.14: v1(39.88,33.35) 39.31,32.77 PQ101.1
  TOP w0.254: PQ101.1 39.03,32.36 39.96,31.43 PR104.1 41.3,31.43 PQ100.2
PSID-3: length 310.7
  TOP w0.14: UE3.B24 302.67,14.38 v2(302.15,13.85)
  TOP w0.254: v2(50.53,33.11) 50.08,32.66 v1(47.11,32.66) 46.34,31.9 PR101.2 PR100.2 44.57,32.76 PQ100.3
  IN2 w0.099: v2(307.32,29.68) 307.32,29.45 306.73,28.86 296.31,28.86 293.69,26.24 292.92,26.24 290.62,23.94 289.28,23.94 288.21,22.87 281.94,22.87 281.94,22.87 268.35,22.87 267.41,21.93 264.5,21.93 264.1,21.54 260.63,21.54 259.27,22.89 258.6,22.89 257.45,21.74 254.66,21.74 252.26,19.35 218.33,19.35 218.29,19.31 218.01,19.31 217.97,19.34 207.55,19.34 207.52,19.37 184.47,19.37 184.4,19.31 177.33,19.31 176.4,20.24 175,20.24 174.65,20.59 174.65,21.54 174.26,21.92 173.62,21.92 173.16,21.47 173.16,20.15 173.03,20.02 161.5,20.02 161.09,20.44 161.09,22.46 160.09,23.46 160.09,24.19 157.66,26.62 156.82,26.62 156.38,27.05 156.38,27.8 156.15,28.03 155.21,28.03 152.91,30.34 145.06,30.34 140.6,34.8 116.93,34.8 111.52,40.21 98.36,40.21 95.26,37.11 87.07,37.11 84.09,34.12 81.57,34.12 80.51,33.06 54.69,33.06 54.01,33.74 51.16,33.74 v2(50.53,33.11)
  BOTTOM w0.14: v2(307.32,29.68) 307.32,28.81 308.28,27.85 308.28,25.12 307.77,24.61 307.77,19.57 308,19.34 308,18 307.66,17.67 304.94,17.67 303.67,16.4 303.67,14.72 303.24,14.28 302.58,14.28 v2(302.15,13.85)
PTP_DIS#: length 96.9
  TOP w0.14: v3(274.83,18.44) v2(275.36,17.9) 275.64,17.9 275.93,17.62 UE4.21
  IN3 w0.091: v2(230,9.22) 231.64,10.86 242.37,10.86 242.91,11.4 252.48,11.4 254.53,13.45 259.6,13.45 259.76,13.61 266.26,13.61 268.97,16.32 273.79,16.32 v2(275.36,17.9)
  BOTTOM w0.14: v2(230,9.22) 230,13.33 228.74,14.58 203.02,14.58 202.99,14.61 196.92,14.61 196.92,14.6 193.48,14.6 191,12.13 JTP.3
PTP_INT#: length 294.4
  TOP w0.089: v2(89.68,10.17) 90.11,9.73 90.11,6.08 89.93,5.9 89.35,5.9 89.03,5.58 89.03,4.93 89.35,4.61 89.76,4.61 DH1.1
  TOP w0.14: v2(306.85,26.22) 306.57,26.22 RE138.1 ; v1(184.53,8.83) v2(185.14,8.83) 185.75,9.44 186,9.44 187.14,8.3 187.69,8.3 188.55,7.44 QE13.1
  IN3 w0.091: v2(319.47,25.34) 319.17,25.04 316.48,25.04 312.74,28.79 309.16,28.79 308.16,27.79 308.16,27.52 v2(306.85,26.22)
  IN6 w0.089: v2(89.68,10.17) 90.06,10.55 90.98,10.55 91.98,11.55 95.46,11.55 95.57,11.65 97.65,11.65 98.17,11.13 99.01,11.13 99.28,11.4 101.98,11.4
  IN6 w0.099: 101.98,11.4 102.37,11.4 102.82,11.85 107.44,11.85 108.27,11.02 112.59,11.02 113.4,11.83 115.62,11.83 116.22,11.23 124.77,11.23 125.69,12.16 128.38,12.16 129.01,11.52 145.41,11.52 145.88,11.05 146.97,11.05 147.62,10.4 149.01,10.4 149.82,11.21 151.66,11.21 152.79,10.07 165.26,10.07 165.96,10.78 176.25,10.78 176.29,10.82 186.35,10.82 186.78,11.25 189.68,11.25 v2(190.37,11.95) 191.48,11.95 192.18,11.25 198.07,11.25 199.47,12.65 216.98,12.65 217.88,11.74 219.21,11.74 220.4,10.56 228.26,10.56 228.71,10.11 233.24,10.11 234.4,8.94 252.43,8.94 252.69,9.2 261.89,9.2 262.82,10.14 269.89,10.14 270.68,9.35 270.68,8.99 271.18,8.49 274.6,8.49 275.12,7.98 278.3,7.98 279.89,9.57 283.7,9.57 284.77,8.5 288.9,8.5 289.31,8.9 289.31,9.28 289.14,9.45 289.14,10.08 289.28,10.22 292.58,10.22 293.4,11.03 294.34,11.03 295.13,10.24 303.51,10.24 303.86,9.9 311.39,9.9 314.57,13.08 314.57,16.25 318.52,20.2 318.52,24.38 v2(319.47,25.34)
  BOTTOM w0.14: v2(185.14,8.83) 185.14,13.77 185.93,14.55 188.88,14.55 190.37,13.05 v2(190.37,11.95)
PTP_INT#_EC: length 59.4
  TOP w0.14: UE3.B37 302.02,19.26 301.49,18.73 v2(301.43,18.73) ; RP19.2 291.37,8.14 291.65,8.42 v2(291.65,8.87) ; v2(314.19,9.35) v3(313.7,8.86) ; v2(304.88,24.93) 305.11,25.15 RE138.2
  IN3 w0.091: v2(314.19,9.35) 313.98,9.56 313.98,19.24 312.09,21.13 303.71,21.13 301.86,19.29 301.86,19.16 v2(301.43,18.73)
  IN4 w0.091: v2(301.43,18.73) 301.43,18.77 301.81,19.15 301.81,19.6 303.62,21.41 303.62,23.78 304.76,24.93 v2(304.88,24.93)
  IN6 w0.099: v2(314.19,9.35) 314.19,9.36 314.06,9.49 303.39,9.49 303.05,9.83 294.14,9.83 294,9.69 293.15,9.69 292.33,8.87 v2(291.65,8.87)
PTP_INT#_R: length 7.9
  TOP w0.14: v3(186.82,10.17) 186.9,10.25 RE87.2 188.09,9.91 187.9,9.72 QE13.3 187.49,9.1 v2(187.21,8.83)
  BOTTOM w0.14: JTP.4 190,9.23 189.6,8.83 v2(187.21,8.83)
PWM1_GT: length 34.2
  TOP w0.203: v2(113.42,103.07) 113.42,103.34 113.77,103.69 PU1100.12
  IN4 w0.254: v2(113.42,103.07) 106.44,103.07 105.16,101.79 105.16,92.2 103.33,90.37 103.33,81.02 v2(104.59,79.76)
  BOTTOM w0.254: v2(104.59,79.76) 104.9,80.08 PU1300.1
PWM1_VCORE: length 25.6
  TOP w0.14: v2(129.92,103.89) 129.92,103.96 v3(130.52,104.56)
  TOP w0.203: v2(120.84,103.08) 120.84,103.39 120.54,103.69 PU1100.25
  IN2 w0.254: v2(120.84,103.08) 121.51,103.08 122.26,103.83 122.75,103.83 123.74,104.82 127.05,104.82 127.98,103.89 v2(129.92,103.89)
  BOTTOM w0.254: v2(129.92,103.89) 130.1,103.72 134.6,103.72 135.06,104.18 135.06,104.78 135.59,105.31 135.59,107.64 136.4,108.45 137.43,108.45 137.93,107.96 138.35,107.96 138.58,108.19 138.58,108.66 138.71,108.78 PU1200.1
PWM2_GT: length 43.8
  TOP w0.14: v1(113.74,101.44) 114.16,101.86 v2(114.3,101.86)
  TOP w0.203: v2(114.3,101.86) 114.43,101.86 115,102.43 PU1100.13
  IN4 w0.254: v2(103.7,72.08) 103.76,72.08 104.27,72.59 104.27,77.1 105.7,78.53 105.7,79.09 105.07,79.73 105.07,80.87 104.04,81.9 104.04,90.08 105.87,91.91 105.87,101.49 106.68,102.31 112.27,102.31 112.71,101.86 v2(114.3,101.86)
  BOTTOM w0.254: v2(103.7,72.08) 104.08,72.46 PU1301.1
PWM2_VCORE: length 25.4
  TOP w0.14: v2(138.64,113.9) 138.64,114.52 v1(138.61,114.55)
  TOP w0.203: PU1100.26 120.66,104.09 121.01,103.73 v2(121.15,103.73)
  IN2 w0.254: v2(138.64,113.9) 138.16,114.37 136.72,114.37 131.33,108.97 127.24,108.97 125.08,106.81 123.91,106.81 123.19,106.09 123.19,104.78 122.68,104.26 122.04,104.26 121.51,103.73 v2(121.15,103.73)
  BOTTOM w0.254: PU1201.1 138.75,114.4 138.58,114.22 138.58,113.96 v2(138.64,113.9)
PWM3_VCORE: length 44.7
  TOP w0.14: v2(155.7,117.86) 155.21,117.37 v1(155.21,117.09)
  TOP w0.203: PU1100.27 120.76,104.49 120.92,104.32 v2(121.13,104.32)
  IN2 w0.254: v2(121.13,104.32) 121.43,104.62 122.53,104.62 122.84,104.92 122.84,106.24 123.76,107.17 124.93,107.17 127.09,109.33 131.18,109.33 136.58,114.73 138.6,114.73 139.64,113.69 141.24,113.69 142.19,114.64 143.18,114.64 145.39,116.85 150.58,116.85 151.14,117.41 151.96,117.41 152.14,117.23 155.07,117.23 v2(155.7,117.86)
  BOTTOM w0.254: v2(155.7,117.86) 156,117.86 156.16,117.7 PU1202.1
PWM_SA: length 20.1
  TOP w0.14: v1(121.58,109.14) 121.22,108.78 v2(121.21,108.78)
  TOP w0.203: v2(121.21,108.78) 121.03,108.61 121.03,108.04 120.68,107.69 PU1100.35
  IN1 w0.254: v2(121.21,108.78) 119.81,107.39 119.81,103.79 119.58,103.56 119.58,102.33 118.96,101.7 118.96,100.82 117.7,99.56 117.7,94.79 117.03,94.12 v2(116.97,94.12)
  BOTTOM w0.254: PU1302.3 116.33,94.45 116.66,94.12 v2(116.97,94.12)
PWR_BTN_DOCK1#: length 4
  TOP w0.14: v1(25.6,59.48) 25.72,59.37 RT182.2 26.09,58.57 26.29,58.37 RT194.2 27.48,58 27.29,57.81 QV89.3
PWR_DEBUG#_XDP: length 4.8
  TOP w0.14: v1(131.74,96.72) 131.09,96.72 130.8,96.43 RH488.1 130.47,97.28 RH483.2 129.9,96.73 129.53,96.73 129.31,96.51 JXDP.45
PWR_TB_DOCK#: length 338.8
  TOP w0.14: RT195.2 25.79,55.44 25.56,55.44 24.61,54.49 23.08,54.49 21.91,53.32 20.54,53.32 20.4,53.19 20.4,52.62 19.99,52.22 v2(19.85,52.22) ; RE110.2 280.01,3.79 v2(279.76,4.05)
  IN2 w0.099: v2(24.32,21.24) 24.32,21.6 24.45,21.73 26.96,21.73 28.97,23.74 30.9,23.74 31.76,24.6 36.63,24.6 37.15,25.12 43.18,25.12 46.14,22.17 46.14,20.98 v2(46.25,20.86)
  IN3 w0.089: 75.06,1.71 81.09,1.71 81.39,1.41
  IN3 w0.091: 75.06,1.71 74.86,1.71 74.5,2.07 73.21,2.07 72.43,1.28 66.61,1.28 65.35,2.54 64.54,2.54 64.19,2.89 64.19,3.19 63.27,4.12 63.27,5.28 60.92,7.63 60.92,12.02 59.75,13.19 57.28,13.19 56.23,14.23 56.23,14.83 54.48,16.58 54.48,18.68 52.38,20.78 46.34,20.78 v2(46.25,20.86) ; 81.39,1.41 81.76,1.04 87.46,1.04 87.73,1.32 106.43,1.32 107.01,1.9 108.19,1.9 108.78,1.32 117.89,1.32 123.05,6.47 130.01,6.47 130.44,6.04 131.88,6.04 133.87,4.05 138.1,4.05 140.8,1.34 150.62,1.34 151.65,2.37 200.48,2.37 201.78,1.07 210.89,1.07 213.7,3.88 231.52,3.88 234.01,1.39 234.13,1.28 245.26,1.28 246,2.02 246,3.03 247.12,4.15 249.3,4.15 249.8,3.65 263.95,3.65 264.88,4.58 267.45,4.58 268.61,3.41 279.12,3.41 v2(279.76,4.05)
  IN5 w0.099: v2(24.32,21.24) 23.58,21.24 22.54,20.2 19.82,20.2 17.38,22.64 15.92,22.64 15.26,23.3 15.26,24.59 20.16,29.5 20.16,31.15 19.89,31.43 19.89,38.99 18.65,40.23 18.65,51.01 v2(19.85,52.22)
PWRBTN#_XDP: length 6.8
  TOP w0.14: v2(132.2,93.89) 132.2,94.38 v1(131.93,94.65) 131.74,94.84 130.66,94.84 CH174.1 130.07,94.65 129.59,95.14 129.58,95.14 129.33,95.39 129.21,95.51 JXDP.41
  BOTTOM w0.14: RH6.1 RH2.2 132.2,94.37 v2(132.2,93.89)
PWRBTN_LED#: length 143.7
  TOP w0.14: v2(295.86,16.25) 295.44,16.67 294.95,16.67 294.74,16.88 UE3.B57 ; LED6.1 335.21,119.71 334.19,118.69 v2(333.58,118.69)
  IN6 w0.099: v2(295.86,16.25) 300.76,16.25 301.7,17.19 303.47,17.19 304.07,17.8 310.97,17.8 311.93,18.76 312.79,18.76 315.35,21.31 315.35,27.61 316.82,29.08 316.82,30.07 317.76,31.01 317.76,38.81 318.59,39.64 321.32,39.64 322.97,41.29 322.97,44.02 326.1,47.15 326.1,48.3 328.47,50.67 328.47,52.23 331.9,55.66 331.9,59.3 330.84,60.36 330.84,67.93 332.1,69.19 332.1,85.25 343.47,96.62 v2(343.47,97.24) 343.47,97.52 343.7,97.74 343.7,112.83 337.83,118.69 v2(333.58,118.69)
REFADJ_NVVDD: length 2.5
  BOTTOM w0.203: 167.37,116.82 167.41,116.71 PU1001.6
  BOTTOM w0.254: PR1007.2 167.14,117.28 v1(167.14,117.05) 167.37,116.82
REFADJ_NVVDDS: length 1.9
  BOTTOM w0.203: PR1507.2 178.69,114.31 178.98,114.6 PU1501.6
REFIN_NVVDD: length 4.5
  TOP w0.254: v2(167.99,117.33) 168.33,117.66 PC1017.1
  BOTTOM w0.203: 168.53,117.87 v2(167.99,117.33) 167.81,117.15 PU1001.7
  BOTTOM w0.254: 168.53,117.87 PR1008.1 168.4,118.06 PR1006.1
REFIN_NVVDDS: length 10
  TOP w0.14: PC1518.1 174.51,117.12 v1(174.51,117.94)
  TOP w0.254: v2(178.5,114.88) 178.75,115.13 178.75,116.47 177.74,117.48 176.87,117.48 PR1508.1 176.17,116.79 v2(175.64,116.79) 175.48,116.62 PC1518.1
  BOTTOM w0.203: PU1501.7 178.62,115 v2(178.5,114.88)
  BOTTOM w0.254: PR1509.1 175.78,117.32 175.78,116.92 v2(175.64,116.79)
REM_DIODE1_N: length 458.7
  TOP w0.089: CE69.1 158.68,71.73 158.68,71.1 158.51,70.93 QE15.3 v2(158.02,70.13)
  TOP w0.127: CE32.1 303.79,5.93 v2(303.92,5.8) ; v2(301,12.05) 301,11.37 301.02,11.35 UE3.B13 ; v2(263.12,22.79) v3(263.12,22.11)
  IN2 w0.127: v2(263.12,22.79) 262.95,22.96 260.93,22.96 257.55,26.34 255.05,26.34 253.82,27.56 253.82,39.14 255.69,41.01 255.69,47.92 252.63,50.98 252.63,53.56 251.34,54.85 251.34,96.68 249.02,99 249.02,110.11 246.62,112.52 243.57,112.52 242.82,113.27 239.94,113.27 238.51,111.83 230.97,111.83 230.29,112.26 228.17,112.26 225.64,114.79 225.64,115.35 226.14,115.85 226.14,119.08 226.61,119.55 226.61,120.16 226.2,120.57 174.5,120.57 173.13,119.2 171.3,119.2 170.34,118.25 167.83,118.25 166.35,119.73 165.61,119.73 165.18,120.15 128.41,120.15 123.48,115.22 117.6,115.22 117.1,115.73 117.1,115.83 v2(116.85,116.08)
  IN3 w0.089: 177.45,55.53 177.38,55.61 177.38,55.66 176.3,56.74 172.85,60.19 172.85,62.64 172.43,63.06 171.9,63.06 171.56,62.72 168.6,62.72 167.45,63.87 167.45,64.68 167.07,65.06 167.07,66.72 166.67,67.12 161.11,67.12 160.56,67.67 159.41,67.67 158.46,68.63 158.46,69.69 v2(158.02,70.13)
  IN3 w0.127: v2(263.12,22.79) 263,22.91 261.67,22.91 258.84,25.74 258.63,25.74 252.92,31.44 252.51,31.44 251.98,31.97 232.68,31.97 218.16,46.49 215.71,46.49 214.1,48.1 214.1,48.87 212.85,50.11 208.47,50.11 207.84,50.75 205.18,50.75 204.32,51.61 202.19,51.61 201.81,51.23 194.34,51.23 194.17,51.06 181.93,51.06 177.45,55.53 ; v2(301,12.05) 301,11.08 301.32,10.77 302.61,10.77 304.18,9.2 304.18,6.06 v2(303.92,5.8)
  BOTTOM w0.127: v2(116.85,116.08) 117.02,115.91 117.02,114.46 116.43,113.88 116.43,111.83 116.13,111.53 115.66,111.53 CE45.1 114.34,111.88 QE7.2 113.21,112.06 QE7.1 ; v2(263.12,22.79) 263.31,22.98 263.42,22.98 264.23,22.18 266.32,22.18 267.45,23.31 273.45,23.31 274.58,22.18 274.58,19.76 275.93,18.41 275.93,17.88 277.15,16.65 277.15,5.6 280.11,2.64 301.94,2.64 303.33,4.02 303.33,6.66 303.45,6.79 303.73,6.79 303.92,6.61 v2(303.92,5.8)
