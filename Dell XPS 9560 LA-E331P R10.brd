# Allegro board Dell XPS 9560 LA-E331P R10.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLKDET#: length 4.2
  TOP w0.089: v2(89.6,5.18) 90.32,5.18 91.19,4.32 RH558.1 91.21,4.23 91.77,3.68 92.03,3.68 v3(92.27,3.44)
  BOTTOM w0.089: v2(89.6,5.18) 89.53,5.26 89.27,5.26 UH2.BB22
CLKOUT_LPC0: length 20.3
  IN6 w0.089: v2(91.24,2.49) 91.64,2.88 92.58,2.88 92.72,2.74 92.72,1.98 93.02,1.68 97.96,1.68 100.35,4.07 101.98,4.07
  IN6 w0.099: 101.98,4.07 102.62,4.07 103.53,4.98 v2(103.53,5.32)
  BOTTOM w0.089: UH2.BC17 91.4,4.91 91.68,4.63 91.68,4.45 91.52,4.3 91.52,2.99 91.24,2.7 v2(91.24,2.49)
  BOTTOM w0.14: v2(103.53,5.32) 104.07,5.85 104.46,5.85 104.97,5.34 RH168.1
CLKOUT_LPC1: length 24.1
  TOP w0.14: v2(106.81,9.9) 106.33,9.9 v3(106.06,9.64) 105.93,9.51 105.93,7.89 105.63,7.6 105.63,6.93 105.46,6.76 v2(105.46,6.69)
  IN6 w0.089: 101.98,10.15 99.61,10.15 99.17,9.71 96.86,9.71 96.61,9.46 96.61,9.25 96.31,8.95 94.98,8.95 94.25,8.21 92.76,8.21 92.58,8.39 92.58,8.9 92.24,9.24 91.84,9.24 91.25,8.65 91.25,8.48 90.75,7.97 v2(90.74,7.97)
  IN6 w0.099: v2(106.81,9.9) 106.72,9.99 102.25,9.99 102.09,10.15 101.98,10.15
  BOTTOM w0.089: v2(90.74,7.97) 90.68,7.97 90.29,7.59 UH2.AV19
  BOTTOM w0.14: RH428.1 105.33,6.57 v2(105.46,6.69)
CLKREQ_PCIE#0: length 34.3
  IN1 w0.076: 75.06,4.83 75.12,4.83 75.44,4.52 75.44,3.26 75.77,2.93 76.26,2.93 77.46,4.12 82.1,4.12 82.72,3.5 84.58,3.5 85.41,2.68 87.31,2.68 87.89,2.1 88.38,2.1 v2(88.8,1.69)
  IN1 w0.099: 75.06,4.83 74.47,4.83 74,5.3 68.79,5.3 68.07,4.58 68.07,2.93 69.66,1.34 70.72,1.34 70.85,1.47 v2(70.85,1.75)
  BOTTOM w0.089: v2(88.8,1.69) 88.8,1.68 88.34,2.14 88.34,2.67 88.06,2.95 88.06,3.6 87.89,3.78 87.89,4.7 88.04,4.85 UH2.BC24
  BOTTOM w0.14: v2(70.85,1.75) 70.85,2.15 RH548.2
CLKRUN#: length 263.2
  TOP w0.14: RH85.1 106.42,7.57 v2(106.42,8.33) ; v2(313.86,7.89) v3(313.86,7.12) ; UE3.A32 304.73,19.13 304.79,19.19 304.79,19.44 v2(304.41,19.82)
  IN2 w0.089: 101.98,8.17 100.97,8.17 100.12,7.33 99.63,7.33 99.08,6.78 98.06,6.78 97.7,6.42 96.54,6.42 96.13,6 95.81,6 95.12,5.31 92.15,5.31 91.99,5.47 90.54,5.47 90.26,5.75 90.26,6.44 v2(89.73,6.97)
  IN2 w0.099: v2(313.86,7.89) 313.86,7.85 310.85,4.83 310.21,4.83 309.63,4.25 303.7,4.25 302.78,5.17 301.69,5.17 300.83,4.31 296.36,4.31 296.2,4.15 289.51,4.15 288.79,3.43 269.64,3.43 267.77,5.3 246.18,5.3 244.73,3.84 226.71,3.84 226.04,4.52 213.35,4.52 210.01,7.86 206.66,7.86 204.59,5.79 181.67,5.79 181.48,5.98 179.71,5.98 179.33,6.36 175.92,6.36 175.38,5.82 172.38,5.82 171.92,5.36 163.62,5.36 163.15,5.83 159.78,5.83 159.25,6.36 152.46,6.36 151.58,7.25 151.58,8.21 149.52,10.26 146.94,10.26 146.53,10.67 116.45,10.67 114.77,8.99 107.13,8.99 106.88,8.74 106.55,8.74 106.42,8.61 v2(106.42,8.33) 106.05,8.33 105.63,8.75 102.8,8.75 102.23,8.17 101.98,8.17
  IN3 w0.091: v2(304.41,19.82) 305.33,20.75 311.93,20.75 313.59,19.08 313.59,8.16 v2(313.86,7.89)
  BOTTOM w0.089: v2(89.73,6.97) 89.52,6.76 UH2.AW22
CPU_24MHZ_N: length 139.8
  IN6 w0.107: v2(100.76,24.2) 100.59,24.02 100.43,24.02 100.29,24.16 100.29,28.46 102.63,30.8 104.83,30.8 117.55,43.53 117.55,51.58 119.25,53.28 119.25,59.67 122.3,62.72 123.5,62.72 127.18,66.4 127.18,69.16 128.39,70.37 128.39,75.49 131.89,78.99 131.89,81.56 132.92,82.58 132.92,84.27 133.61,84.96 133.61,88.42 135.94,90.75 156.19,90.75 157.21,89.73 170.06,89.73 170.47,89.32 175.16,89.32 179.19,85.29 179.19,81.61 178.72,81.15 175.74,81.15 175.57,81.32 175.57,81.53 v2(175.82,81.77)
  BOTTOM w0.076: v2(175.82,81.77) 175.82,81.85 UH1.D31
  BOTTOM w0.102: UH2.F1 99.47,23.53 99.65,23.53 100.12,24 100.56,24 v2(100.76,24.2)
CPU_24MHZ_P: length 141.7
  IN6 w0.107: v2(100.76,23.62) 100.56,23.82 100.34,23.82 100.09,24.08 100.09,28.54 102.55,31 104.74,31 117.35,43.61 117.35,51.66 119.05,53.36 119.05,59.76 122.22,62.93 123.42,62.93 126.98,66.49 126.98,69.25 128.18,70.46 128.18,75.58 131.69,79.08 131.69,81.64 132.72,82.67 132.72,84.35 133.4,85.04 133.4,88.5 135.85,90.95 156.27,90.95 157.29,89.94 170.14,89.94 170.56,89.52 175.24,89.52 179.39,85.37 179.39,81.53 178.81,80.95 175.66,80.95 175.37,81.23 175.37,81.57 v2(175.17,81.77)
  BOTTOM w0.076: v2(175.17,81.77) 175.17,81.85 UH1.E31
  BOTTOM w0.102: UH2.G1 99.33,22.91 100.19,23.77 100.61,23.77 v2(100.76,23.62)
CPU_TRIGGER: length 165.5
  TOP w0.14: v2(179.52,76.65) 179.39,76.65 RH192.1 179.52,75.03 v3(179.52,73.54)
  IN5 w0.099: v2(104.8,21.27) 105.31,20.76 105.31,19.11 106.29,18.13 106.88,18.13 107.14,17.86 175.24,17.86 177.03,19.65 v2(177.03,21.12)
  IN6 w0.089: v2(179.52,76.65) 179.52,71.87 181.1,70.28
  IN6 w0.099: 181.1,70.28 183.21,68.18 183.21,66.39 184.97,64.63 186.62,64.63 193.2,58.05 193.2,46.09 179.21,32.1 179.21,27.45 177.1,25.35 177.1,24.65 177.61,24.14 177.61,21.6 177.13,21.12 v2(177.03,21.12)
  BOTTOM w0.089: UH2.AK1 99.48,11.46 100.76,11.46 101.59,12.29 101.59,12.54
  BOTTOM w0.127: v2(104.8,21.27) 104.56,21.03 104.56,20.49 104.36,20.29 104.36,17.92 105.16,17.12 105.16,15.46 105.22,15.4 105.22,13.12 105.14,13.04 104.29,13.04 104.01,12.76 101.8,12.76 101.59,12.54
CPU_TRIGGER_R: length 6.4
  TOP w0.089: v1(178.09,76.95) 177.72,76.58 RH192.2 176.17,75.9 176.12,75.85 174.23,75.85 v2(173.84,76.24)
  BOTTOM w0.076: UH1.J23 173.21,76.24 v2(173.84,76.24)
CPU_XDP_TCK: length 39.6
  TOP w0.14: RH498.2 RH491.2 130.99,103.01 v3(130.7,102.71) 130.7,102.05 131.27,101.48 v2(131.27,100.1) 131.17,100.01 130.64,100.01 130.28,99.65 129.64,99.65 129.5,99.51 JXDP.57
  IN2 w0.089: 134.62,78.99 135,78.99 v2(135.41,79.39)
  IN2 w0.099: 134.62,78.99 132.94,78.99 132.09,79.83 132.09,80.26 130.17,82.18 130.17,85.02 128.98,86.21
  IN2 w0.102: v2(131.27,100.1) 130.76,99.6 130.76,97.21 131.62,96.35 131.62,95.92 132.8,94.74 132.8,93.13 128.98,89.31 128.98,86.21
  BOTTOM w0.076: v2(135.41,79.39) 135.93,78.87 137.06,78.87 137.47,79.28 137.81,79.28 UH1.BR28
CPU_XDP_TDI: length 25.8
  TOP w0.14: v2(139.04,94.75) 139.04,94.66 v3(139.41,94.29)
  IN2 w0.102: v2(139.04,94.75) 139.04,92.41 135.4,88.77 135.4,83.42 135.69,83.12 137.29,83.12 138.47,81.95 141.04,81.95 v2(141.23,82.13)
  BOTTOM w0.076: UH1.BL32 140.9,82.46 v2(141.23,82.13)
  BOTTOM w0.14: v2(139.04,94.75) 136.96,96.83 RH541.2 RH495.2
CPU_XDP_TDO: length 27.2
  TOP w0.14: v3(134.18,96.21) 134.11,96.15 v2(133.14,96.15)
  IN2 w0.099: v2(133.14,96.15) 133.21,96.07 133.21,92.96 129.39,89.14 129.39,86.38
  IN2 w0.102: v2(136.04,79.39) 135.43,80 133.88,80 133.32,80.57 132.36,80.57 130.59,82.34 130.59,85.18 129.39,86.38
  BOTTOM w0.076: UH1.BT28 136.92,79.04 136.5,79.04 136.14,79.39 v2(136.04,79.39)
  BOTTOM w0.14: RH540.2 RH496.2 133.67,96.68 v2(133.14,96.15)
CPU_XDP_TMS: length 35.1
  TOP w0.14: v2(134.14,79.39) 134.14,80.06 v3(134.48,80.4)
  IN2 w0.099: v2(131.29,98.73) 131.29,97.23 131.64,96.88 132.37,96.88 132.7,96.55
  IN2 w0.102: 132.7,96.55 132.7,95.13 133.01,94.83 133.01,93.04 129.19,89.22 129.19,86.29 130.37,85.11 130.37,82.26 132.27,80.37 133.17,80.37 v2(134.14,79.39)
  BOTTOM w0.076: UH1.BP28 138.42,79.91 137.37,79.91 137.26,79.79 134.62,79.79
  BOTTOM w0.127: 134.45,79.71 v2(134.14,79.39)
  BOTTOM w0.14: RH542.2 131.18,95.5 131.7,96.02 RH494.2 131.18,97.35 131.18,98.62 v2(131.29,98.73) ; 134.45,79.71 134.53,79.79 134.62,79.79
CPU_XDP_TRST#: length 124.9
  TOP w0.089: v2(97.23,6.91) 97.35,6.78 98.65,6.78 99.33,7.47 99.33,7.9 99.91,8.48 100.5,8.48 101.35,9.33 101.35,10.42 101.71,10.78 101.98,10.78
  TOP w0.127: v2(115.25,46.17) v3(115.25,45.07) 115.25,40.05 105.9,30.7 101.95,30.7 98.7,27.45 98.7,25.5 99.48,24.72 99.48,22.76 99.56,22.68 101.06,21.18 101.35,21.18 102.18,20.34 102.73,20.34 105.54,17.53
  TOP w0.14: 101.98,10.78 105.85,10.78 106.38,11.31 111.33,11.31 112.72,12.7 112.72,15.48 111.99,16.21 110.05,16.21 110.04,16.2 108.14,16.2 106.94,17.41 105.66,17.41 105.54,17.53
  IN4 w0.091: v2(127.98,82.11) 125.16,79.29 125.16,71.42 122.02,68.28 122.02,66.99 119.9,64.87 119.77,64.87 118.11,63.21 118.11,55.44 118.46,55.09 118.46,53.25 117.36,52.14 117.36,48.28 v2(115.25,46.17)
  BOTTOM w0.076: UH1.BP30 138.53,81.15 138.24,81.44 137.9,81.44 137.71,81.63 135.2,81.63 134.89,81.31 134.62,81.31
  BOTTOM w0.089: UH2.AY5 97.28,6.85 v2(97.23,6.91)
  BOTTOM w0.14: 134.62,81.31 131.67,81.31 RH497.2 130.54,81.4 RH543.2 128.69,81.4 v2(127.98,82.11)
CR_CLK_REQ#: length 323.6
  TOP w0.14: RP2.6 68.21,5.64 68.35,5.5 68.35,5 68.16,4.82 67.68,4.82 67.36,4.5 v2(67.36,4.39) ; v3(324.35,34.27) 324.65,34.58 v2(325.16,34.58)
  IN3 w0.091: v2(325.16,34.58) 325.31,34.43 328.99,34.43 330.43,32.99 338.54,32.99 339.66,34.11 v2(341.31,34.11)
  IN5 w0.089: 75.06,4.47 75.17,4.36 75.23,4.36 75.54,4.05 79.73,4.05 79.92,4.25 82.07,4.25 82.26,4.05 86.14,4.05 86.78,3.42 87.07,3.42 87.59,2.89 87.59,2.36 87.86,2.09 89.06,2.09 v2(89.47,1.69)
  IN5 w0.099: v2(67.36,4.39) 67.36,4.5 68.13,5.27 69.39,5.27 69.63,5.03 74.5,5.03 74.76,4.77 75.06,4.47
  IN6 w0.089: v2(89.47,1.69) 89.65,1.5 98.03,1.5 100.38,3.84 101.98,3.84
  IN6 w0.099: v2(325.16,34.58) 325.4,34.33 325.4,31.31 324.76,30.66 324.76,26.93 320.08,22.26 320.08,10.14 316.22,6.28 307.9,6.28 306.28,4.66 304.47,4.66 304.13,4.32 303.53,4.32 302.88,4.97 301.75,4.97 301.16,4.37 295.82,4.37 295.6,4.16 282.07,4.16 281.75,4.48 273.41,4.48 272.35,5.54 268.23,5.54 267.59,6.18 262.89,6.18 262.11,5.4 245.48,5.4 244.68,4.6 243.5,4.6 242.8,3.9 240.49,3.9 239.71,4.68 227.88,4.68 226.69,5.86 213.83,5.86 210.69,9 205.91,9 205.29,8.38 202.66,8.38 201.66,7.38 179.97,7.38 179,6.41 176.18,6.41 174.57,4.81 169.56,4.81 167.42,2.67 151.13,2.67 150.08,1.62 140.18,1.62 136.27,5.53 133.35,5.53 132.69,6.19 130.39,6.19 129.79,6.79 126.96,6.79 126.87,6.87 119.68,6.87 115.98,3.16 109.16,3.16 108.6,2.6 106.37,2.6 105.12,3.84 101.98,3.84
  BOTTOM w0.089: v2(89.47,1.69) 89.07,2.09 89.07,2.67 88.85,2.89 88.63,2.89 88.42,3.1 88.42,3.86 88.42,3.86 88.28,3.99 88.28,4.24 88.39,4.35 88.38,4.35 88.38,4.66 88.28,4.76 88.28,5.24 UH2.BB24
  BOTTOM w0.14: UR1.2 340.98,34.44 v2(341.31,34.11)
CS_1.2V: length 3.9
  BOTTOM w0.14: PR601.2 287.77,26.18 286.34,26.18 v1(286.12,25.97)
  BOTTOM w0.203: PR601.2 288.08,26.81 288.27,27 PU600.13
CSSN_1: length 7.1
  TOP w0.254: PR302.1 51.88,10.91 51.88,9.79 v3(53.6,8.07) 54.48,7.18 54.48,6.59 v2(54.37,6.48)
  BOTTOM w0.254: PR300.2 55.02,7.13 v2(54.37,6.48)
CSSP_1: length 6.6
  TOP w0.254: PR301.1 52.39,10.92 52.39,9.96 v3(52.58,9.77) 54.87,7.49 54.87,6.61 v2(55.02,6.45)
  BOTTOM w0.254: PR300.3 55.02,6.44 v2(55.02,6.45)
DAT_TP_SIO: length 154.7
  TOP w0.14: UE3.B40 300.52,19.41 v2(300.39,19.27) ; v2(197.91,9.11) 198.46,8.56 201.04,8.56 201.44,8.17 201.44,6.65 198.53,3.74 188.95,3.74 186.85,5.85 CE78.1 ; RE26.2 300.99,23.07 300.66,22.74 v2(300.48,22.74)
  IN3 w0.091: v2(197.91,9.11) 198.28,8.74 199.48,8.74 202.53,11.78 213.66,11.78 216.21,9.24 228.74,9.24 230.55,11.05 242.29,11.05 242.83,11.59 252.4,11.59 254.45,13.64 259.52,13.64 259.68,13.8 266.18,13.8 268.89,16.52 271.53,16.52 273.6,18.59 277.63,18.59 277.96,18.91 279.68,18.91 282.3,21.54 291.15,21.54 292.8,23.19 300.04,23.19 v2(300.48,22.74)
  IN4 w0.091: v2(300.39,19.27) 300.39,20.77 299.95,21.21 299.95,22.34 300.36,22.74 v2(300.48,22.74)
  BOTTOM w0.14: v2(197.91,9.11) 198.53,9.74 DE4.3 199.21,10.27 199.39,10.45 199.39,10.86 198.42,11.84 198.42,12.51 198.05,12.88 195.34,12.88 194.55,12.09 194.55,10.77 193.51,9.74 193.03,9.74 192.84,9.92 192.18,9.92 192,10.11 JTP.2
DAUL_IN: length 20.2
  TOP w0.102: PL201.1 21.72,21.41 21.65,21.34 21.65,20.9 22.04,20.52 v1(22.1,20.52)
  TOP w0.254: PQ204.3 18.19,34.51 16.96,33.28 16.96,31.63 17.21,31.38 PR202.1 18.09,30.48 17.78,30.17 17.78,27.95 PC222.1 18.48,26.55 18.67,26.36 v2(18.67,25.27) ; v2(29.43,29.08) 29,28.65 PC220.1 27.99,28.65 27.7,28.94 PR200.1 ; PR224.1 23.13,9.64 23,9.51 PQ217.3 23.8,8.7 23.97,8.86 24.41,8.86 24.57,8.71 PR223.1 v2(25.85,8.71)
  vias: v2(16.77,24.67) v2(16.77,24.08) v2(17.4,25.27) v2(17.4,24.67) v2(17.4,24.08) v2(18.04,25.27) v2(18.04,24.67) v2(18.04,24.08) v2(18.67,24.67) v2(18.67,24.08) v2(19.18,24.39) v2(19.81,24.27) v2(27.28,30.85) v2(27.56,31.38) v2(27.84,30.15) v2(27.86,30.74) v2(28.13,31.25) v2(28.44,30.16) v2(28.46,30.74) v2(29.05,30.74) v2(29.05,30.16) v2(29.64,30.2) v2(29.67,29.61) v2(30.01,29.13)
DCIN_ACOK: length 389.5
  TOP w0.14: v2(309.35,7.46) 309.36,7.46 309.77,7.88 309.77,8.68 DE11.1
  TOP w0.254: v2(27.32,7.06) 26.93,7.45 PR228.1 26.67,7.45 v1(26.67,8.45) 26.67,8.58 26.04,9.22 25.66,9.22 24.89,9.98 23.78,9.98 23.65,10.11 23.65,10.6 23.32,10.93 22.73,10.93 22.34,11.32 PQ229.2 ; PR231.1 18.3,3.81 17.83,4.28 v2(17.6,4.28) ; PR259.2 11.07,21.84 v2(10.97,21.74) ; v2(27.24,30.21) 26.81,29.78 PR209.1
  IN1 w0.254: v2(17.6,4.28) 18.8,5.47 18.8,8.66 18.15,9.31 18.15,11.02 12,17.17 12,20.33 10.97,21.36 v2(10.97,21.74)
  IN2 w0.089: 75.06,12.68 75.48,12.25 77.74,12.25 77.98,12.49 77.98,14.46 78.94,15.42 80.86,15.42 80.97,15.31 84.07,15.31 85.17,16.41 85.17,17.82 85.46,18.11 86.19,18.11 88.29,20.2 91.06,20.2 91.34,19.93 91.34,18.63 95.25,14.72 95.93,14.72 96.48,14.17 98.44,14.17 99.57,13.04 101.98,13.04
  IN2 w0.099: v2(215.15,8.85) 215.15,9.91 213.6,11.46 201.69,11.46 200.9,10.68 199.95,10.68 199.7,10.42 197.05,10.42 196.98,10.35 188.21,10.35 187.88,10.68 184,10.68 183.84,10.84 178.76,10.84 177.85,11.75 155.32,11.75 153.72,13.34 149.44,13.34 148.5,14.28 129.83,14.28 129.12,14.99 120.39,14.99 120.15,14.75 106.62,14.75 105.72,13.85 104,13.85 103.19,13.04 101.98,13.04 ; 75.06,12.68 72.93,14.81 72.93,22.81 71.61,24.13 66.23,24.13 65.72,24.63 60.2,24.63 56.24,28.59 47.13,28.59 44.59,31.14 39.27,31.14 38.87,30.74 35.96,30.74 35.32,31.38 30.99,31.38 30.64,31.72 28.73,31.72 28.43,32.01 27.35,32.01 26.84,31.5 26.84,30.61 v2(27.24,30.21)
  IN2 w0.254: v2(27.24,30.21) 26.09,29.05 19.12,29.05 13.51,23.44 12.78,23.44 11.09,21.74 v2(10.97,21.74)
  IN5 w0.099: v2(309.35,7.46) 308.88,6.99 307.11,6.99 306.62,6.5 302.41,6.5 300.98,5.07 297.85,5.07 297.62,5.31 295.29,5.31 295.29,5.3 290.84,5.3 290.61,5.07 285.84,5.07 284.55,6.36 276.3,6.36 274.49,8.16 263.18,8.16 262.03,9.31 252.95,9.31 252.02,8.39 229.71,8.39 228.54,9.56 216.1,9.56 215.39,8.85 v2(215.15,8.85)
  IN6 w0.254: v2(8.7,21.96) 8.72,21.98 10.2,21.98 10.44,21.74 v2(10.97,21.74)
  BOTTOM w0.254: PQ230.2 8.06,21.3 8.7,21.93 v2(8.7,21.96) 9.08,21.96 PR251.1 10.31,20.72 PC216.1 10.88,20.41 11.43,20.95 PU202.7 ; v2(17.6,4.28) 19.13,4.28 20.51,5.66 25.85,5.66 27.24,7.06 v2(27.32,7.06)
DCIN_ACOK#: length 81.1
  TOP w0.102: v2(28.07,9.03) 28.07,9.41 v1(28.26,9.6)
  TOP w0.254: v2(8.84,22.58) 9.31,22.58 PR252.1 ; PR268.1 30.54,29.07 30.54,28.08 30.8,27.82 31.5,27.82 31.69,27.63 v2(31.69,27.16) ; v2(10.99,1.62) 10.57,2.04 10.29,2.04 10.23,2.1 PU204.2 9.53,2.1 9.51,2.09 9.15,2.09 PR283.1 ; PR235.1 28.66,8.43 v2(28.07,9.03)
  IN1 w0.254: v2(28.07,9.03) 28.07,17.15 29.08,18.17 31.65,18.17 32.54,19.06 32.54,25.51 31.69,26.36 v2(31.69,27.16) ; v2(10.99,1.62) 11.43,2.07 11.43,2.87 11.22,3.08 11.22,3.67 11.7,4.15 11.7,5.9 11.3,6.3 11.3,9.56 11.8,10.05 11.8,14.92 11.53,15.19 11.53,17.94 11.05,18.42 10.67,18.42 10.29,18.8 10.29,21.3 9.02,22.58 v2(8.84,22.58)
  IN2 w0.254: v2(10.99,1.62) 11.47,1.62 11.6,1.5 23.08,1.5 28.07,6.49 v2(28.07,9.03)
  BOTTOM w0.254: PQ228.2 8.84,23.18 v2(8.84,22.58) 8.61,22.58 7.99,21.95 7.99,21.73 7.7,21.44 6.16,19.9 PQ230.1
DDC_CLK_HDMI: length 20.1
  IN3 w0.091: v2(18.87,92.8) 18.63,93.04 15.77,93.04 15.22,92.48 15.22,91.12 14.06,89.96 14.06,89.25 13.63,88.82 12.61,88.82 12.36,89.07 11.52,89.07 11.21,88.76 11.21,88.44 11.32,88.05 11.32,87.71 11.23,87.55 11.23,87.33 11.38,87.01 11.38,86.8 11.75,86.43 JHDMI1.15
  BOTTOM w0.14: v2(18.87,92.8) 19.42,92.8 20.07,92.15 21.55,92.15 v1(22.11,92.7) 22.99,93.58 QX1.6 RV124.1
DDC_DAT_HDMI: length 17.1
  IN3 w0.091: v2(18.87,93.42) 18.71,93.25 15.68,93.25 15,92.57 15,91.21 13.84,90.05 13.84,89.35 13.53,89.04 12.7,89.04 12.45,89.29 11.43,89.29 10.99,88.85 10.99,88.41 11.1,88.02 11.1,87.77 11.01,87.6 11.01,87.28 11.16,86.96 11.16,86.75 11.07,86.66 10.84,86.66 JHDMI1.16
  BOTTOM w0.14: QX1.3 20.96,95.4 RV125.1 18.97,93.42 v2(18.87,93.42)
DDI1_CPU_AUXN: length 192.2
  TOP w0.17: CT26.2 34.02,41.28 34.95,41.28 35.18,41.51 35.18,44.08 35.56,44.46 35.9,44.46 v2(36,44.56)
  IN3 w0.089: 141.11,78.88 141.11,78.89 141.09,78.9 141.09,79.98 142,80.88 144.16,80.88 144.33,80.71 147.88,80.71 148,80.83 172.53,80.83 173.09,80.27 173.09,80.09 174.22,78.96 174.76,78.96 v2(175.13,78.59)
  IN3 w0.112: v2(36,44.56) 35.88,44.45 35.55,44.45 35.26,44.15 35.26,39.14 37.12,37.28 37.12,35.86 40.47,32.5 42.45,32.5 46.72,28.23 48.58,28.23 49.87,26.94 55.64,26.94 55.65,26.93 55.97,26.93 56.38,26.52 57.15,26.52 58.04,25.63 73.46,25.63 74.88,27.05 79.31,27.05 80.33,28.08 86.68,28.08 88.33,29.72 106.49,29.72 134.66,57.9 134.66,65.51 135.14,65.99 135.14,68.92 137.98,71.76 137.98,76.19 138.24,76.44 140.4,76.44 141.11,77.15 141.11,78.88
  BOTTOM w0.076: UH1.E27 175.48,78.94 v2(175.13,78.59)
DDI1_CPU_AUXN_C: length 4.4
  TOP w0.089: CT26.1 33.35,41.33 32.15,41.33 31.55,41.93 30.94,41.93 30.79,42.08 30.4,42.08 v2(29.96,41.64)
  BOTTOM w0.102: UT1.W11 30.07,41.53 v2(29.96,41.64)
DDI1_CPU_AUXP: length 192.2
  TOP w0.17: CT25.2 34.02,40.85 35.13,40.85 35.61,41.33 35.61,43.9 35.74,44.03 35.95,44.03 v2(36,43.98)
  IN3 w0.089: v2(175.78,78.59) 175.72,78.59 175.36,78.95 175.08,78.95 174.85,79.19 174.31,79.19 173.31,80.18 173.31,80.37 172.62,81.06 147.91,81.06 147.79,80.93 144.42,80.93 144.25,81.11 141.91,81.11 140.87,80.07 140.87,78.9 140.86,78.89 140.86,78.88
  IN3 w0.112: v2(36,43.98) 36,44 35.79,44.2 35.65,44.2 35.5,44.05 35.5,39.24 37.36,37.38 37.36,35.96 40.57,32.75 42.56,32.75 46.82,28.48 48.68,28.48 49.98,27.19 55.54,27.19 56.06,27.19 56.49,26.77 57.26,26.77 58.14,25.88 73.35,25.88 74.78,27.3 79.2,27.3 80.23,28.33 86.58,28.33 88.22,29.97 106.39,29.97 134.42,58 134.42,65.62 134.89,66.09 134.89,69.02 137.74,71.86 137.74,76.29 138.13,76.69 140.29,76.69 140.86,77.25 140.86,78.88
  BOTTOM w0.076: v2(175.78,78.59) 175.78,78.79 176.01,79.01 UH1.D27
DDI1_CPU_AUXP_C: length 4.3
  TOP w0.089: CT25.1 33.16,40.98 v5(32.49,40.98) 32.07,40.98 31.87,41.18 31.68,41.18 31.59,41.27 31.59,41.46 31.47,41.58 31.29,41.58 31.23,41.51 31.23,41.29 31.13,41.19 31,41.19 30.9,41.29 30.9,41.58 30.83,41.64 v2(30.61,41.64)
  BOTTOM w0.102: v2(30.61,41.64) UT1.Y11
DDI1_DDPB_CTRLCLK: length 106.7
  TOP w0.089: RP1.3 100.42,7 99.34,5.91 99.34,5.04 v1(99.29,4.99) 99.23,4.93 97.52,4.93 v2(96.99,5.45)
  IN3 w0.089: v2(96.99,5.45) 96.99,5.76 96.61,6.14 96.19,6.14 95.6,6.73 95.6,7.83 95.22,8.21 94.84,8.21 94.48,7.86 93.75,7.86 93.4,8.21 91.81,8.21 90.95,9.08 89.85,9.08 88.82,8.05 88.82,7.32 87.76,6.26 87.76,5.88 87.58,5.7 87.11,5.7 86.5,6.32 85.5,6.32 85.09,5.91 84.87,5.91 84.11,5.15 83.52,5.15 83.02,5.65 82.49,5.65 81.79,4.95 79.48,4.95 79.18,4.66 78.27,4.66 77.65,5.28 77.65,5.83 77.09,6.38 76.04,6.38 75.31,5.66 75.06,5.66
  IN3 w0.112: v2(30.6,44.23) 31.12,44.23 31.75,43.6 31.75,42.85 32.02,42.59 32.02,41.67 32.78,40.9 32.78,35.44 35.33,32.9 36.86,32.9 37.5,32.26 37.5,31.66 39.41,29.74 39.7,29.74 41.2,28.24 42.38,28.24 42.88,27.74 42.88,27.01 45.9,23.98 49.75,23.98 50.22,23.5 53.16,23.5 53.36,23.3 54.18,23.3 54.48,23.6 56.11,23.6 57,22.7 58.58,22.7 59.44,21.85 59.44,21.3 61.75,19 61.75,18.48 62.53,17.7 62.53,16.22 63.69,15.06 63.69,15.06 64.04,14.71 64.04,8.21 66.55,5.7 69.6,5.7 69.9,5.39 71.73,5.39 72,5.66 75.06,5.66
  BOTTOM w0.089: UH2.BA5 97.29,5.75 v2(96.99,5.45)
  BOTTOM w0.102: v2(30.6,44.23) 30.6,44.21 30.89,43.92 UT1.Y5
DDI1_DDPB_CTRLDAT: length 116
  TOP w0.089: RP1.4 100.37,6.5 99.61,5.74 99.61,4.85 99.01,4.25 v1(98.2,4.25) 98.08,4.25 v2(97.77,4.57)
  IN3 w0.089: 27.13,34.3 27.13,35.47 26.55,36.04 23.34,36.04 22.32,37.06 22.32,41.05 23.82,42.54 25.6,42.54 27.3,44.24 v2(28.01,44.24) ; 75.06,3.43 75.52,3.43 76.04,3.95 79.48,3.95 79.77,4.24 85.12,4.24 85.84,4.97 86.66,4.97 87.18,4.45 87.8,4.45 88.79,5.44 89.02,5.44 89.2,5.61 90.18,5.61 90.32,5.47 91.93,5.47 91.93,5.47 92.36,5.47 92.65,5.18 94.96,5.18 95.69,4.45 96.03,4.45 96.1,4.37 97.57,4.37 v2(97.77,4.57)
  IN3 w0.112: 27.13,34.3 27.52,33.9 27.52,32.32 27.75,32.1 28.34,32.1 28.72,31.72 28.75,31.72 28.96,31.5 32.2,31.5 33.81,29.89 36.03,29.89 36.95,28.98 36.95,28.09 37.47,27.57 39.52,27.57 40.51,26.57 40.9,26.57 45.73,21.74 46.79,21.74 46.9,21.64 50.68,21.64 50.88,21.84 52.28,21.84 53.28,20.84 54.56,20.84 55.77,19.63 57.34,19.63 57.73,19.24 57.73,17.67 58.6,16.8 59.23,16.8 61.59,14.43 61.59,8.02 63.95,5.66 63.95,4.64 65.3,3.29 65.78,3.29 66.27,2.8 68.89,2.8 69.36,3.27 70.39,3.27 70.67,3.56 73.32,3.56 73.46,3.43 75.06,3.43
  BOTTOM w0.089: UH2.BC4 97.77,5.03 v2(97.77,4.57)
  BOTTOM w0.102: UT1.R4 v2(28.01,44.24)
DDI1_HTX_TBRX_N0: length 194.9
  IN3 w0.112: v2(171.88,87.37) 171.72,87.52 171.11,87.52 170.43,88.21 169.94,88.21 169.18,88.97 164.45,88.97 163.7,89.73 137.24,89.73 135.69,88.18 135.69,85.74 132.11,82.15 132.11,81.29 130.68,79.87 130.68,69.24 131.57,68.35 131.57,66.35 132.56,65.36 132.56,57.67 105.98,31.09 87.72,31.09 86.2,29.56 79.9,29.56 78.86,28.52 78.72,28.38 74.25,28.38 73.15,27.28 70.21,27.28 69.44,28.05 66.52,28.05 66.05,27.58 60.48,27.58 60.16,27.91 56.92,27.91 56.78,28.05 56.47,28.35 50.36,28.35 49.15,29.56 47.27,29.56 42.48,34.35 41.25,34.35 40.04,35.56 39.41,35.56 38.44,36.52 38.44,38.02 37.66,38.8 37.66,40.69 38.11,41.13 38.11,42.01 37.43,42.69 36.84,42.69 v2(36.58,42.43)
  BOTTOM w0.076: v2(171.88,87.37) 171.88,87.49 171.96,87.58 172.01,87.58 172.07,87.64 172.13,87.64 172.29,87.49 172.29,87.05 172.65,86.69 172.65,85.43 172.55,85.34 172.39,85.34 172.33,85.4 UH1.K37
  BOTTOM w0.17: v2(36.58,42.43) 36.56,42.44 35.55,42.44 CT18.2
DDI1_HTX_TBRX_N0_C: length 3.4
  BOTTOM w0.089: 33.66,42.49 33.5,42.49 33.14,42.86 32.44,42.86 32.31,42.73 32.07,42.73 31.95,42.85 31.95,42.91 32.01,42.97 UT1.AC7
  BOTTOM w0.17: 33.66,42.49 v1(33.85,42.49) 34.51,42.49 CT18.1
DDI1_HTX_TBRX_N1: length 193.9
  IN3 w0.112: v2(37.07,41.63) 36.93,41.49 36.59,41.49 36.29,41.18 36.29,39.06 37.78,37.57 37.78,36.25 39.16,34.87 39.79,34.87 40.97,33.69 42.21,33.69 47,28.9 48.87,28.9 50.08,27.69 56.15,27.69 56.66,27.18 59.84,27.18 60.1,26.92 66.33,26.92 66.79,27.39 69.16,27.39 69.93,26.62 73.5,26.62 74.6,27.72 78.99,27.72 79.1,27.83 80.17,28.9 86.47,28.9 87.96,30.39 106.21,30.39 133.5,57.67 133.5,67.61 131.49,69.62 131.49,76 133.05,77.56 133.05,78.93 135.08,80.96 135.08,83.14 136.39,84.46 136.39,87.86 137.52,88.99 163.18,88.99 163.95,88.23 169.1,88.23 170.72,86.6 170.72,85.72 171.86,84.58 172.4,84.58 172.49,84.5 172.49,84.38 172.36,84.25 172.36,84.25 172.36,83.94 172.36,83.94 172.36,83.82 v2(172.73,83.45)
  BOTTOM w0.076: UH1.J34 173.05,83.76 v2(172.73,83.45)
  BOTTOM w0.17: CT20.2 36.69,41.63 v2(37.07,41.63)
DDI1_HTX_TBRX_N1_C: length 4.6
  BOTTOM w0.089: 33.66,41.64 32.97,41.64 32.33,42.28 32.02,42.28 31.94,42.21 31.94,42.12 32.01,42.05 UT1.AC9
  BOTTOM w0.17: 33.66,41.64 35.79,41.64 CT20.1
DDI1_HTX_TBRX_N2: length 189.1
  IN3 w0.112: v2(173.8,88.81) 173.66,88.94 173.66,89.23 173.32,89.57 171.87,89.57 170.37,91.07 164.93,91.07 164.08,91.92 155.54,91.92 155.06,91.44 136.63,91.44 134.18,88.99 134.18,86.64 130.25,82.7 130.25,82.35 128.2,80.3 128.2,67.05 123.48,62.33 122.77,62.33 121.54,61.1 121.54,56.51 116.69,51.66 115.38,51.66 104.87,41.15 104.87,40.29 97.31,32.74 87.08,32.74 85.55,31.2 79.3,31.2 78.05,29.95 74.96,29.95 73.6,29.95 72.91,29.26 70.45,29.26 69.79,29.93 51.01,29.93 49.75,31.19 47.88,31.19 43.15,35.92 41.92,35.92 40.04,37.79 40.04,39.37 39.75,39.66 39.75,40.58 39.48,40.85 39.11,40.85 v2(38.93,41.03)
  BOTTOM w0.076: v2(173.8,88.81) 173.75,88.77 173.75,88.45 173.99,88.21 173.99,86.07 174.22,85.84 174.22,85.38 UH1.H36
  BOTTOM w0.17: v2(38.93,41.03) 38.06,41.03 37.57,40.54 36.57,40.54 36.43,40.68 35.44,40.68 CT22.2
DDI1_HTX_TBRX_N2_C: length 3.5
  BOTTOM w0.089: UT1.AC11 32.01,41.13 31.94,41.2 31.94,41.29 32.02,41.36 32.32,41.36 32.42,41.26
  BOTTOM w0.102: 33.66,40.64 33.64,40.64 33.61,40.6 33.4,40.6 33.06,40.94 32.74,40.94 32.42,41.26
  BOTTOM w0.17: 33.66,40.64 v1(33.91,40.64) 34.62,40.64 CT22.1
DDI1_HTX_TBRX_N3: length 190.5
  IN3 w0.112: v2(172.41,88.95) 172.19,88.72 171.75,88.72 171.32,89.15 170.18,89.15 169.4,89.92 165.01,89.92 163.69,91.25 155.87,91.25 155.4,90.78 136.96,90.78 134.81,88.62 134.81,86.21 131.07,82.48 131.07,81.61 129.15,79.69 129.15,66.24 131.53,63.86 131.53,58.12 113.41,40.01 107.02,40.01 102.51,35.5 101.24,35.5 97.78,32.03 87.37,32.03 85.88,30.54 79.59,30.54 78.34,29.29 73.87,29.29 72.77,28.19 70.59,28.19 69.81,28.96 66.14,28.96 65.68,28.5 64.22,28.5 63.46,29.26 50.73,29.26 49.47,30.52 47.61,30.52 42.87,35.26 41.64,35.26 40.4,36.5 39.75,36.5 39.35,36.9 39.35,39.11 39.08,39.38 38.82,39.38 v2(38.63,39.57)
  BOTTOM w0.076: UH1.J38 173.28,86.46 173.28,86.98 173.41,87.12 173.41,87.97 172.96,88.43 172.87,88.43 172.72,88.58 172.72,88.64 v2(172.41,88.95)
  BOTTOM w0.17: CT24.2 36.89,39.49 38.56,39.49 v2(38.63,39.57)
DDI1_HTX_TBRX_N3_C: length 5
  BOTTOM w0.102: 33.66,39.49 33.57,39.49 32.73,40.34 32.48,40.34 32.37,40.44 32.02,40.44 31.94,40.37 31.94,40.28 32.01,40.21 UT1.AC13
  BOTTOM w0.17: CT24.1 36.03,39.49 33.66,39.49
DDI1_HTX_TBRX_P0: length 195
  IN3 w0.112: v2(36.58,43.01) 36.65,42.93 37.53,42.93 38.36,42.11 38.36,41.03 37.91,40.59 37.91,38.9 38.69,38.12 38.69,36.62 39.51,35.8 40.15,35.8 41.35,34.6 42.58,34.6 47.37,29.81 49.25,29.81 50.46,28.6 56.58,28.6 57.02,28.15 60.26,28.15 60.58,27.83 65.95,27.83 66.42,28.3 69.54,28.3 70.31,27.53 73.05,27.53 74.15,28.63 78.61,28.63 79.79,29.81 86.1,29.81 87.62,31.33 105.87,31.33 132.32,57.78 132.32,65.26 131.33,66.25 131.33,68.25 130.44,69.14 130.44,79.97 131.86,81.39 131.86,82.26 135.44,85.84 135.44,88.28 137.13,89.98 163.8,89.98 164.55,89.22 169.28,89.22 170.05,88.46 170.53,88.46 171.21,87.77 171.7,87.77 v2(171.88,87.95)
  BOTTOM w0.076: UH1.K36 172.41,85.15 172.62,85.15 172.83,85.36 172.83,86.84 172.5,87.17 172.5,87.56 172.11,87.95 v2(171.88,87.95)
  BOTTOM w0.17: CT17.2 36.45,42.87 36.58,43 v2(36.58,43.01)
DDI1_HTX_TBRX_P0_C: length 3.4
  BOTTOM w0.089: 33.66,42.87 33.38,42.87 33.21,43.04 32.57,43.04 32.41,43.2 31.86,43.2 UT1.AB7
  BOTTOM w0.17: CT17.1 33.66,42.87
DDI1_HTX_TBRX_P1: length 193.8
  IN3 w0.112: v2(37.07,41.04) 36.87,41.24 36.69,41.24 36.53,41.08 36.53,39.16 38.03,37.67 38.03,36.35 39.26,35.11 39.9,35.11 41.07,33.93 42.31,33.93 47.1,29.14 48.98,29.14 50.18,27.94 56.25,27.94 56.76,27.43 59.95,27.43 60.21,27.17 66.22,27.17 66.69,27.63 69.26,27.63 70.04,26.86 73.4,26.86 74.5,27.96 78.89,27.96 80.07,29.14 86.37,29.14 87.86,30.63 106.11,30.63 133.25,57.78 133.25,67.51 131.24,69.52 131.24,76.1 132.8,77.66 132.8,79.03 134.83,81.06 134.83,83.25 136.15,84.56 136.15,87.96 137.42,89.24 163.29,89.24 164.05,88.48 169.2,88.48 170.97,86.71 170.97,85.82 171.96,84.83 172.5,84.83 172.74,84.59 172.91,84.59 173.29,84.21 173.29,83.9 173.2,83.81 173.02,83.81 v2(172.73,84.1)
  BOTTOM w0.076: UH1.J35 173.05,84.41 v2(172.73,84.1)
  BOTTOM w0.17: CT19.2 36.96,41.16 v2(37.07,41.04)
DDI1_HTX_TBRX_P1_C: length 4.7
  BOTTOM w0.102: UT1.AB9 31.86,41.82 32.36,41.82 32.93,41.25 33.66,41.25
  BOTTOM w0.17: 33.66,41.25 35.85,41.25 CT19.1
DDI1_HTX_TBRX_P2: length 189.2
  IN3 w0.112: v2(38.93,40.45) 39.08,40.6 39.38,40.6 39.51,40.48 39.51,39.56 39.8,39.27 39.8,37.69 41.82,35.68 43.04,35.68 47.78,30.94 49.64,30.94 50.91,29.68 69.69,29.68 70.35,29.02 73.01,29.02 73.7,29.71 74.86,29.71 78.15,29.71 79.4,30.96 85.65,30.96 87.18,32.49 97.42,32.49 105.11,40.19 105.11,41.04 115.48,51.42 116.79,51.42 121.79,56.41 121.79,60.99 122.87,62.08 123.59,62.08 128.45,66.94 128.45,80.2 130.49,82.24 130.49,82.6 134.43,86.53 134.43,88.89 136.73,91.19 155.16,91.19 155.64,91.67 163.98,91.67 164.82,90.83 170.26,90.83 171.77,89.32 173.22,89.32 173.42,89.13 173.42,88.85 173.29,88.72 173.16,88.72 v2(173.09,88.8)
  BOTTOM w0.076: v2(173.09,88.8) 173.3,88.8 173.42,88.68 173.42,88.31 173.66,88.07 173.66,85.94 173.48,85.76 173.48,85.58 173.56,85.51 173.69,85.51 UH1.H37
  BOTTOM w0.17: v2(38.93,40.45) 38.77,40.6 38.24,40.6 37.75,40.11 36.39,40.11 36.25,40.25 35.45,40.25 CT21.2
DDI1_HTX_TBRX_P2_C: length 3.5
  BOTTOM w0.102: 33.66,40.2 33.45,40.2 32.92,40.74 32.42,40.74 32.26,40.9 31.86,40.9 UT1.AB11
  BOTTOM w0.17: 33.66,40.2 34.7,40.2 CT21.1
DDI1_HTX_TBRX_P3: length 190.5
  IN3 w0.112: v2(172.4,88.38) 172.3,88.48 171.65,88.48 171.22,88.9 170.08,88.9 169.3,89.68 164.91,89.68 163.59,91 155.97,91 155.5,90.53 137.06,90.53 135.05,88.52 135.05,86.11 131.32,82.37 131.32,81.5 129.4,79.59 129.4,66.34 131.78,63.97 131.78,58.02 113.51,39.76 107.13,39.76 102.62,35.25 101.35,35.25 97.88,31.78 87.47,31.78 85.98,30.3 79.69,30.3 78.44,29.04 73.98,29.04 72.88,27.94 70.48,27.94 69.71,28.71 66.24,28.71 65.78,28.25 64.12,28.25 63.36,29.02 50.63,29.02 49.37,30.28 47.5,30.28 42.77,35.01 41.54,35.01 40.3,36.26 39.65,36.26 39.11,36.8 39.11,39.01 38.98,39.13 38.78,39.13 v2(38.63,38.99)
  BOTTOM w0.076: v2(172.4,88.38) 172.64,88.38 172.77,88.25 172.88,88.25 173.23,87.91 173.23,87.21 173.08,87.06 173.08,86.24 173.12,86.2 UH1.J37
  BOTTOM w0.17: CT23.2 38.56,39.06 v2(38.63,38.99)
DDI1_HTX_TBRX_P3_C: length 5
  BOTTOM w0.102: UT1.AB13 31.86,39.98 32.57,39.98 33.42,39.13 33.46,39.13 33.49,39.1 33.61,39.1 33.64,39.06 33.66,39.06
  BOTTOM w0.17: CT23.1 v1(33.91,39.06) 33.66,39.06
DDI1_PCH_HPD: length 106
  IN3 w0.089: 75.06,6.17 75.72,6.83 78.41,6.83 78.6,6.64 79.31,6.64 79.74,6.21 82.71,6.21 83.59,5.33 84.04,5.33 84.8,6.09 85.02,6.09 85.43,6.5 87.74,6.5 88.64,7.4 88.64,8.12 89.77,9.25 92.08,9.25 92.37,8.96 93.3,8.96 93.51,8.75 93.51,8.37 93.85,8.04 94.41,8.04 94.77,8.39 95.29,8.39 95.78,7.9 95.78,6.81 96.16,6.42 97.3,6.42 97.74,6.87 v2(97.74,7.15)
  IN3 w0.112: 75.06,6.17 74.97,6.08 71.83,6.08 71.56,5.81 70.01,5.81 69.7,6.12 66.72,6.12 65.22,7.62 65.22,10.93 64.45,11.69 64.45,13.36 65,13.92 65,16.09 64.01,17.09 64.01,19.68 62.74,20.95 62.74,21.92 61.53,23.12 57.24,23.12 56.35,24.01 54.3,24.01 54.01,23.72 53.53,23.72 53.33,23.92 50.39,23.92 49.92,24.4 46.1,24.4 43.46,27.04 43.46,27.75 42.55,28.66 41.37,28.66 39.87,30.16 39.6,30.16 38.33,31.43 38.32,31.43 v2(38.22,31.52)
  IN5 w0.089: v2(32.64,46.06) 32.41,46.06 32.03,45.68 32.03,44.4 32.31,44.12 33.24,44.12 33.66,43.7
  IN5 w0.119: v2(38.22,31.52) 38.24,31.54 38.24,37.17 34.98,40.42 34.98,42.37 33.66,43.7
  BOTTOM w0.089: UH2.AW4 97.95,6.93 v2(97.74,7.15) ; 33.66,46.33 33.57,46.24 32.82,46.24 v2(32.64,46.06) 32.6,46.02 31.54,46.02 31.41,45.89 31.41,45.51 UT1.AA2
  BOTTOM w0.17: RT41.2 33.66,46.33
DDI2_CPU_AUXN: length 186.5
  TOP w0.17: v2(35.19,36.95) 35.35,37.11 35.35,37.21 35.26,37.29 35.26,38.89 v5(34.89,39.26) 34.44,39.71 34.09,39.71 CT107.2
  IN3 w0.089: 141.77,78.96 141.77,78.97 141.75,78.98 141.75,79.79 142.42,80.46 143.73,80.46 144.61,79.57 169.85,79.57 170.48,80.21 172.2,80.21 172.76,79.65 172.76,79.45 173.58,78.64 173.58,77.8 173.86,77.51 174.33,77.51 174.41,77.43 174.64,77.43 175.06,77.85 v2(175.15,77.85)
  IN3 w0.112: 141.77,78.96 141.77,72.39 139.32,69.95 138.5,69.95 137.35,68.8 137.35,65.39 137.7,65.05 137.7,58.89 135.46,56.66 134.36,56.66 107.84,30.14 107.84,29.35 107.55,29.06 88.6,29.06 86.8,27.26 86.09,27.26 84.69,25.85 83.42,25.85 83.03,25.47 79.35,25.47 78.85,24.97 57.76,24.97 56.95,25.78 50.8,25.78 50.58,26.01 47.55,26.01 46.66,26.89 46.66,27.36 42.19,31.83 40.2,31.83 35.8,36.23 35.8,36.82 35.56,37.05 35.29,37.05 v2(35.19,36.95)
  BOTTOM w0.076: UH1.E26 175.15,77.9 v2(175.15,77.85)
DDI2_CPU_AUXN_C: length 4.5
  TOP w0.089: CT107.1 33.22,39.71 v5(32.27,39.71) 31.9,39.71 31.71,39.9 31.16,39.9 30.83,40.23 30.56,40.23 29.96,40.84 v2(29.96,40.99)
  BOTTOM w0.102: v2(29.96,40.99) UT1.W12
DDI2_CPU_AUXP: length 186.5
  TOP w0.17: v2(35.73,37.44) 35.69,37.47 35.69,39.07 34.62,40.14 CT108.2
  IN3 w0.089: v2(174.52,77.82) 174.59,77.82 174.75,77.98 174.75,78.16 174.68,78.23 174.24,78.23 174.14,78.13 174.14,77.8 174.08,77.74 173.95,77.74 173.8,77.89 173.8,78.73 172.99,79.54 172.99,79.74 172.29,80.43 170.39,80.43 169.75,79.8 144.7,79.8 143.82,80.68 142.33,80.68 141.53,79.88 141.53,78.98 141.52,78.97 141.52,78.96
  IN3 w0.112: v2(35.73,37.44) 35.73,37.24 36.04,36.92 36.04,36.33 40.3,32.08 42.29,32.08 46.91,27.46 46.91,26.99 47.65,26.25 50.68,26.25 50.91,26.03 57.06,26.03 57.87,25.22 78.75,25.22 79.24,25.71 82.93,25.71 83.31,26.09 84.58,26.09 85.99,27.5 86.7,27.5 88.5,29.31 107.45,29.31 107.6,29.46 107.6,30.24 134.26,56.9 135.36,56.9 137.45,58.99 137.45,64.94 137.11,65.29 137.11,68.9 138.4,70.19 139.22,70.19 141.52,72.5 141.52,78.96
  BOTTOM w0.076: UH1.F26 174.83,78.13 v2(174.52,77.82)
DDI2_CPU_AUXP_C: length 4.6
  TOP w0.089: CT108.1 33.28,40.06 32.05,40.06 31.86,40.25 31.31,40.25 31.15,40.4 31.15,40.52 31.29,40.66 31.29,40.79 31.19,40.89 31.09,40.89 v5(30.94,40.74) 30.79,40.59 30.7,40.59 30.49,40.79 30.49,40.88 v2(30.61,40.99)
  BOTTOM w0.102: v2(30.61,40.99) UT1.Y12
DDI2_DDPC_CTRLCLK: length 101.2
  TOP w0.089: RP1.1 100.36,8 100.23,7.87 100.23,7.78 v1(99.29,6.84) 98.64,6.19 v2(98.39,6.19)
  IN3 w0.089: 75.06,4.41 75.42,4.41 75.71,4.12 79.4,4.12 79.7,4.42 85.05,4.42 85.77,5.14 86.74,5.14 87.25,4.63 87.72,4.63 88.7,5.61 88.95,5.61 89.13,5.79 89.78,5.79 90.26,6.28 91.38,6.28 92.01,5.65 92.43,5.65 92.72,5.36 95.03,5.36 95.76,4.63 96.1,4.63 96.18,4.55 97.24,4.55 97.76,5.08 98.07,5.08 98.39,5.4 v2(98.39,6.19)
  IN3 w0.112: 75.06,4.41 73.35,4.41 72.94,4 72.22,4 72.08,4.14 69.64,4.14 68.72,3.22 66.44,3.22 65.79,3.87 65.79,4.59 62.77,7.61 62.77,14.04 60.12,16.69 60.12,17.77 57.12,20.77 55.4,20.77 54.12,22.05 52.84,22.05 52.64,22.25 50.63,22.25 50.43,22.05 47.07,22.05 46.96,22.16 45.9,22.16 41.07,26.99 40.68,26.99 39.18,28.49 38.89,28.49 37.01,30.38 36.08,30.38 31.54,34.92 31.54,35.66 32.2,36.32 32.2,40.64 31.24,41.59 v4(31.24,42.29)
  BOTTOM w0.089: v2(98.39,6.19) 98.68,5.9 UH2.BB3
  BOTTOM w0.102: v4(31.24,42.29) 31.24,42.31 30.93,42.62 UT1.Y8
DDI2_DDPC_CTRLDAT: length 104.2
  TOP w0.089: RP1.2 100.44,7.5 98.66,5.71 v1(98.22,5.71) 97.92,5.71 97.72,5.51 v2(97.72,5.51)
  IN3 w0.089: v2(97.72,5.51) 97.72,5.51 97.72,5.28 97.16,4.73 96.25,4.73 96.17,4.8 95.84,4.8 95.1,5.54 94,5.54 93.7,5.83 93.7,6.05 93.3,6.45 90.19,6.45 89.71,5.97 89.05,5.97 88.88,5.79 88.63,5.79 87.64,4.8 87.33,4.8 86.78,5.35 85.72,5.35 84.97,4.6 79.62,4.6 79.33,4.3 75.91,4.3 75.38,4.83 75.06,4.83
  IN3 w0.112: 75.06,4.83 72.35,4.83 72.08,4.56 69.56,4.56 69.25,4.87 66.2,4.87 63.19,7.88 63.19,14.34 60.54,16.99 60.54,17.94 57.07,21.41 55.36,21.41 54.29,22.47 53.01,22.47 52.81,22.67 50.46,22.67 50.26,22.47 47.24,22.47 47.05,22.67 46.03,22.67 41.3,27.41 40.86,27.41 39.35,28.91 39.07,28.91 37.18,30.79 36.25,30.79 32.39,34.66 32.39,40.72 31.62,41.49 31.62,42.42 31.37,42.67 29.6,42.67 28.66,43.61 v2(27.36,43.61)
  BOTTOM w0.089: v2(97.72,5.51) 97.72,5.51 97.22,5.01 UH2.BD6
  BOTTOM w0.102: v2(27.36,43.61) 27.36,43.61 27.36,44.24 UT1.N4
DDI2_HTX_TBRX_N0: length 190.9
  IN3 w0.112: v2(174.35,83.42) 174.18,83.58 174.18,83.66 173.83,84.01 173.83,87.9 174.42,88.48 174.42,89.55 173.73,90.23 172.15,90.23 170.56,91.82 165.28,91.82 164.51,92.59 155.27,92.59 154.81,92.14 136.36,92.14 133.5,89.27 133.5,87.65 130.2,84.35 129.16,84.35 128.7,83.89 128.7,81.83 127.47,80.6 127.47,71.76 125.57,69.87 125.57,65.38 123.19,63 122.46,63 120.78,61.31 120.78,57.89 118.5,55.61 118.5,54.42 116.42,52.33 115.12,52.33 104.2,41.42 104.2,40.57 97.04,33.4 86.79,33.4 85.26,31.87 79.02,31.87 78.16,31 77.77,30.62 75.24,30.62 73.33,30.62 72.63,29.92 70.77,29.92 70.07,30.62 53.37,30.62 52.14,31.85 49.53,31.85 48.54,32.84 47.3,32.84 46.93,33.21 46.93,33.93 46.05,34.81 45.32,34.81 43.46,36.68 43.18,36.68 42.6,37.25 42.6,37.61 41.91,38.3 41.05,38.3 v2(40.84,38.5)
  BOTTOM w0.076: v2(174.35,83.42) 174.04,83.11 UH1.H33
  BOTTOM w0.17: v2(40.84,38.5) 40.79,38.45 35.45,38.45 CT30.2
DDI2_HTX_TBRX_N0_C: length 3.7
  BOTTOM w0.102: 33.57,38.48 33.37,38.48 32.49,39.36 32.49,39.41 32.37,39.52 32.02,39.52 31.94,39.45 31.94,39.36 32.01,39.29 UT1.AC15
  BOTTOM w0.17: 33.57,38.48 34.3,38.48 34.36,38.43 34.63,38.43 CT30.1
DDI2_HTX_TBRX_N1: length 189.4
  IN3 w0.112: v2(48.59,35.16) 48.79,34.96 50.1,34.96 50.62,34.44 51.69,34.44 52.21,33.92 53.65,33.92 54.51,33.06 75.14,33.06 75.46,33.38 77.62,33.38 78.1,33.86 84.1,33.86 85.64,35.39 96.21,35.39 102.02,41.19 102.02,42.05 117.79,57.82 117.79,62.62 123.51,68.34 123.51,71.04 125.31,72.83 125.31,84.52 129.26,88.48 129.26,89.84 134.17,94.75 136,94.75 136.44,94.31 154.15,94.31 154.79,94.94 170.82,94.94 171.56,94.2 172.8,94.2 174.38,92.61 175.17,92.61 176.48,91.31 176.48,88.67 176.63,88.52 176.79,88.52 176.88,88.6 v2(176.88,88.82)
  BOTTOM w0.076: UH1.G38 174.32,86.36 174.2,86.48 174.2,86.67 174.41,86.88 174.41,87.61 175.44,88.63 176.69,88.63 v2(176.88,88.82)
  BOTTOM w0.17: CT32.2 36.86,36.56 37.7,36.56 38.04,36.22 43.8,36.22 45.24,34.78 47.67,34.78 47.98,35.09 48.52,35.09 v2(48.59,35.16)
DDI2_HTX_TBRX_N1_C: length 5.6
  BOTTOM w0.102: 33.66,37.58 33.22,37.58 32.49,38.31 32.49,38.49 32.37,38.6 32.02,38.6 31.94,38.53 31.94,38.44 32.01,38.37 UT1.AC17
  BOTTOM w0.17: 33.66,37.58 v1(33.88,37.58) 33.88,37.57 34.96,36.5 36.01,36.5 CT32.1
DDI2_HTX_TBRX_N2: length 187.5
  IN3 w0.112: v2(47.5,33.87) 47.65,33.71 47.98,33.71 48.11,33.59 48.73,33.59 49.72,32.59 52.36,32.59 53.67,31.28 69.59,31.28 69.59,31.28 70.35,31.28 70.35,31.28 71.38,31.28 71.81,31.71 73.6,31.71 73.8,31.71 74.24,31.28 75.51,31.28 75.51,31.28 75.85,31.28 75.85,31.28 76.08,31.28 76.08,31.28 77.5,31.28 78.75,32.53 84.82,32.53 86.36,34.07 96.76,34.07 103.47,40.77 103.47,41.62 119.95,58.11 119.95,61.91 123.06,65.02 123.49,65.02 124.9,66.43 124.9,70.2 126.75,72.05 126.75,80.83 127.17,81.26 127.17,82.68 126.77,83.08 126.77,84.11 128.19,85.53 129.14,85.53 132.81,89.19 132.81,89.6 136.05,92.85 154.58,92.85 155.27,93.54 169.94,93.54 172.59,90.89 174.08,90.89 175.11,89.87 175.11,88.14 174.55,87.58 174.55,85.2 174.93,84.82 174.93,84.26 v2(175.08,84.11)
  BOTTOM w0.076: v2(175.08,84.11) 174.99,84.11 UH1.F35
  BOTTOM w0.17: v2(47.5,33.87) 47.4,33.77 46.85,33.77 46.32,33.23 45.35,33.23 43.51,35.07 36.86,35.07 CT34.2
DDI2_HTX_TBRX_N2_C: length 5.7
  BOTTOM w0.102: UT1.AC19 32.01,37.45 31.94,37.52 31.94,37.61 32.02,37.68 32.37,37.68 32.48,37.58 32.49,37.58 33.15,36.92 33.2,36.92 33.28,36.84 33.33,36.84 33.34,36.83
  BOTTOM w0.17: 33.34,36.83 33.72,36.45 33.75,36.42 33.96,36.2 34.08,36.09 34.38,35.79 34.65,35.52 35.21,34.96 v1(35.33,34.96) 35.93,34.96 CT34.1
DDI2_HTX_TBRX_N3: length 190.8
  IN3 w0.112: v2(50.04,33.98) 50.24,33.78 51.42,33.78 51.94,33.26 53.38,33.26 54.25,32.39 75.43,32.39 75.69,32.65 77.93,32.65 78.47,33.19 84.44,33.19 85.98,34.73 96.49,34.73 102.72,40.96 102.72,41.81 118.5,57.59 118.5,62.23 121.96,65.69 123.2,65.69 124.23,66.72 124.23,70.59 126,72.37 126,84.28 130.36,88.64 130.36,89.59 134.34,93.56 154.35,93.56 155.03,94.24 170.55,94.24 171.28,93.52 172.43,93.52 175.8,90.15 175.8,88.29 175.97,88.12 175.97,87.31 v2(175.63,86.97)
  BOTTOM w0.076: UH1.E36 175.77,85.36 175.77,85.94 175.67,86.04 175.67,86.92 v2(175.63,86.97)
  BOTTOM w0.17: CT36.2 34.2,33 34.2,32.79 34.35,32.64 35.01,32.64 36.34,33.97 36.82,33.97 37.01,34.16 43.12,34.16 45.07,32.21 47.29,32.21 48.86,33.78 49.84,33.78 v2(50.04,33.98)
DDI2_HTX_TBRX_N3_C: length 4.1
  BOTTOM w0.102: 33.04,34.95 32.79,35.2 32.79,36.3 32.56,36.53 UT1.AC21
  BOTTOM w0.17: CT36.1 34.41,33.87 33.91,34.36 33.63,34.36 v5(33.33,34.66) 33.04,34.95
DDI2_HTX_TBRX_P0: length 190.9
  IN3 w0.112: v2(40.84,37.92) 40.98,38.05 41.81,38.05 42.36,37.5 42.36,37.15 43.07,36.44 43.35,36.44 45.22,34.57 45.94,34.57 46.68,33.83 46.68,33.11 47.19,32.59 48.44,32.59 49.43,31.6 52.04,31.6 53.13,30.52 53.27,30.37 69.97,30.37 70.67,29.68 72.74,29.68 73.43,30.37 75.13,30.37 75.14,30.37 77.87,30.37 79.13,31.62 85.36,31.62 86.89,33.16 97.14,33.16 104.45,40.47 104.45,41.32 115.22,52.09 116.52,52.09 118.75,54.32 118.75,55.51 121.02,57.79 121.02,61.21 122.57,62.75 123.29,62.75 125.82,65.28 125.82,69.77 127.71,71.66 127.71,80.5 128.95,81.73 128.95,83.79 129.27,84.11 130.3,84.11 133.74,87.55 133.74,89.17 136.47,91.89 154.92,91.89 155.37,92.35 164.4,92.35 165.17,91.58 170.46,91.58 172.05,89.99 173.63,89.99 174.17,89.44 174.17,88.58 173.59,88 173.59,83.9 173.94,83.56 173.94,83.37 173.86,83.29 173.65,83.29 v2(173.53,83.41)
  BOTTOM w0.076: UH1.H34 173.55,83.41 v2(173.53,83.41)
  BOTTOM w0.17: CT29.2 35.45,38.02 v5(36.37,38.02) 40.74,38.02 v2(40.84,37.92)
DDI2_HTX_TBRX_P0_C: length 3.7
  BOTTOM w0.102: 33.57,38.05 33.56,38.05 33.53,38.09 33.41,38.09 33.37,38.12 33.22,38.12 32.28,39.06 31.86,39.06 UT1.AB15
  BOTTOM w0.17: 33.57,38.05 34.12,38.05 34.18,37.99 34.68,37.99 CT29.1
DDI2_HTX_TBRX_P1: length 189.4
  IN3 w0.112: v2(177.09,88.27) 176.87,88.27 176.87,88.27 176.53,88.27 176.23,88.57 176.23,91.21 175.07,92.37 174.28,92.37 172.7,93.95 171.46,93.95 170.71,94.7 154.89,94.7 154.26,94.06 136.34,94.06 135.9,94.5 134.27,94.5 129.51,89.73 129.51,88.38 125.55,84.42 125.55,72.73 123.76,70.94 123.76,68.24 118.04,62.52 118.04,57.72 102.26,41.94 102.26,41.09 96.32,35.14 85.74,35.14 84.2,33.61 78.2,33.61 77.72,33.14 75.57,33.14 75.24,32.81 54.41,32.81 53.55,33.67 52.11,33.67 51.59,34.2 50.52,34.2 50,34.72 48.76,34.72 48.6,34.57 v2(48.59,34.58)
  BOTTOM w0.076: UH1.F37 174.69,86.13 174.75,86.19 174.75,87.47 175.57,88.29 176.83,88.29 176.9,88.37 177,88.37 v2(177.09,88.27)
  BOTTOM w0.17: CT31.2 36.86,36.13 37.52,36.13 37.86,35.78 43.63,35.78 45.06,34.35 47.85,34.35 48.15,34.65 48.52,34.65 v2(48.59,34.58)
DDI2_HTX_TBRX_P1_C: length 5.5
  BOTTOM w0.089: 33.64,37.14 33.65,37.14
  BOTTOM w0.102: 33.64,37.14 33.33,37.14 32.82,37.65 32.71,37.76 32.33,38.14 31.86,38.14 UT1.AB17
  BOTTOM w0.17: 33.65,37.14 33.7,37.14 34.71,36.14 34.71,36.14 v1(34.72,36.13) 34.79,36.06 36.13,36.06 CT31.1
DDI2_HTX_TBRX_P2: length 187.5
  IN3 w0.112: v2(174.3,84.08) 174.42,83.96 174.6,83.96 174.69,84.04 174.69,84.72 174.3,85.1 174.3,87.68 174.87,88.24 174.87,89.76 173.98,90.65 172.49,90.65 169.84,93.3 155.37,93.3 154.68,92.61 136.16,92.61 133.05,89.5 133.05,89.09 129.24,85.28 128.29,85.28 127.01,84.01 127.01,83.18 127.41,82.78 127.41,81.15 126.99,80.73 126.99,71.95 125.14,70.1 125.14,66.33 123.59,64.77 123.16,64.77 120.2,61.81 120.2,58.01 103.71,41.52 103.71,40.67 96.87,33.82 86.46,33.82 84.92,32.28 78.85,32.28 77.74,31.18 77.6,31.03 75.41,31.03 74.13,31.03 73.7,31.47 71.91,31.47 71.48,31.04 70.24,31.04 53.57,31.04 52.26,32.35 49.62,32.35 48.63,33.34 48.01,33.34 47.88,33.47 47.68,33.47 v2(47.5,33.28)
  BOTTOM w0.076: v2(174.3,84.08) 174.37,84.08 UH1.F34
  BOTTOM w0.17: CT33.2 36.83,34.64 43.33,34.64 45.17,32.8 46.5,32.8 47.03,33.33 47.45,33.33 v2(47.5,33.28)
DDI2_HTX_TBRX_P2_C: length 5.7
  BOTTOM w0.102: UT1.AB19 31.86,37.22 31.96,37.22 31.97,37.22 32.34,37.22 33.03,36.52
  BOTTOM w0.17: CT33.1 36.13,34.53 35.03,34.53 v1(33.44,36.11) 33.03,36.52
DDI2_HTX_TBRX_P3: length 190.9
  IN3 w0.112: v2(175.59,87.55) 175.55,87.51 175.26,87.51 175.16,87.61 175.16,87.79 175.34,87.97 175.44,87.97 175.55,88.08 175.55,90.05 172.33,93.27 171.18,93.27 170.45,94 155.13,94 154.45,93.32 134.44,93.32 130.61,89.49 130.61,88.54 126.25,84.18 126.25,72.27 124.48,70.49 124.48,66.62 123.3,65.44 122.06,65.44 118.75,62.13 118.75,57.49 102.96,41.71 102.96,40.86 96.59,34.48 86.08,34.48 84.55,32.95 78.58,32.95 78.03,32.4 75.8,32.4 75.53,32.14 54.15,32.14 53.28,33.01 51.84,33.01 51.31,33.53 49.92,33.53 v2(49.71,33.32)
  BOTTOM w0.076: UH1.E37 175.49,85.73 175.49,86.57 175.14,86.91 175.14,87.11 v2(175.59,87.55)
  BOTTOM w0.17: v2(49.71,33.32) 49.68,33.35 49.04,33.35 47.47,31.78 44.89,31.78 42.94,33.73 37.19,33.73 37,33.54 36.52,33.54 35.19,32.2 34.18,32.2 33.77,32.61 CT35.2
DDI2_HTX_TBRX_P3_C: length 4
  BOTTOM w0.102: 33.09,34.3 33.09,34.34 33.01,34.43 33.01,34.47 32.43,35.05 32.43,36.15 32.28,36.3 31.86,36.3 UT1.AB21
  BOTTOM w0.17: CT35.1 33.63,33.93 33.45,33.93 33.2,34.19 33.09,34.29 33.09,34.3
DDI2_PCH_HPD: length 113.6
  TOP w0.089: v2(98.35,7.15) 98.35,7.26 v1(97.83,7.78)
  IN3 w0.089: v2(98.35,7.15) 97.36,6.15 97.36,5.17 97.09,4.9 96.32,4.9 96.25,4.98 95.91,4.98 95.18,5.71 94.89,5.71 94.62,5.98 94.62,6.73 94.37,6.97 93.63,6.97 93.6,6.94 92.94,6.94 92.7,7.18 92.7,7.57 92.39,7.87 91.58,7.87 91.3,7.59 90.13,7.59 89.93,7.38 89.13,7.38 87.96,6.21 87.96,5.83 87.65,5.53 86,5.53 85.79,5.73 84.94,5.73 83.99,4.78 79.55,4.78 79.25,4.48 77.1,4.48 76.34,5.25 75.06,5.25
  IN3 w0.112: 75.06,5.25 72.18,5.25 71.91,4.98 69.73,4.98 69.42,5.28 66.37,5.28 63.61,8.05 63.61,14.54 63.04,15.1 63.03,15.1 62.09,16.04 62.09,17.55 61.57,18.07 61.04,18.07 60.02,19.08 60.02,20.09 59.54,20.57 58.8,20.57 57.39,21.98 57.13,21.98 56.75,22.36 55.75,22.36 55.72,22.33 55.02,22.33 54.47,22.89 53.19,22.89 52.99,23.09 50.28,23.09 50.08,22.89 47.42,22.89 47.22,23.09 46.21,23.09 42.46,26.83 42.46,27.57 42.21,27.82 41.03,27.82 39.53,29.33 39.24,29.33 37.36,31.21 36.43,31.21 32.59,35.05 32.59,40.81 31.82,41.58 31.82,42.5 31.23,43.1 31.1,43.1 v2(30.61,43.59)
  IN6 w0.119: v2(30.61,43.59) 31.01,43.19 34.1,43.19 36.76,40.53 37.22,40.53 37.66,40.97 v2(37.66,41.41)
  BOTTOM w0.089: v2(98.35,7.15) 98.35,6.95 UH2.AY2
  BOTTOM w0.102: UT1.Y6 v2(30.61,43.59)
  BOTTOM w0.17: RT42.2 36.11,43.44 36.15,43.49 36.98,43.49 37.66,42.81 v2(37.66,41.41)
DDR4_DRAMRST#: length 82.4
  TOP w0.14: RD31.1 134.18,17.36 134.18,17.36 134.18,17.16 v2(134.48,16.85)
  IN4 w0.091: v2(210.89,16.86) 210.89,16.86 210.42,17.33 185.83,17.33 184.91,16.41 179.1,16.41 177.26,18.25 154.8,18.25 154.21,17.66 135.28,17.66 v2(134.48,16.85)
  BOTTOM w0.102: v2(134.48,16.85) 134.12,17.21 JDIMM1.108 ; v2(210.89,16.86) 210.89,16.86 210.43,17.32 JDIMM2.108
DDR_A_ACT#: length 50.4
  IN6 w0.089: v2(150.06,57.99) 150.22,57.83 150.22,54.24 149.86,53.89
  IN6 w0.117: 149.86,53.89 149.86,48.66 148.52,47.32 148.52,45.65 144.34,41.46 144.34,40.83 135.94,32.43 135.94,29.43 135.36,28.86 135.36,26.62 135.17,26.43 135.17,22.06 v2(135.78,21.45)
  BOTTOM w0.076: v2(150.06,57.99) 150.59,58.51 150.59,59.5 150.47,59.61 150.47,60.63 150.55,60.71 150.76,60.71 150.83,60.78 150.83,60.96 UH1.AU3
  BOTTOM w0.221: JDIMM1.114 135.62,19.34 135.26,19.71 135.26,20.93 v2(135.78,21.45)
DDR_A_ALERT#: length 51.6
  IN6 w0.117: v2(135.77,20.01) 134.75,21.03 134.75,26.6 134.94,26.79 134.94,29.03 135.52,29.61 135.52,32.61 143.91,41 143.91,41.64 148.1,45.82 148.1,47.49 149.43,48.82 149.43,53.98 149.91,54.46 149.91,57.52 149.65,57.78 149.65,58.88 v2(149.62,58.92)
  BOTTOM w0.076: v2(149.62,58.92) 149.62,59.1 150.14,59.62 150.14,61.73 UH1.AU5
  BOTTOM w0.221: v2(135.77,20.01) 135.77,19.94 136.12,19.58 JDIMM1.116
DDR_A_BG0: length 54.5
  IN6 w0.117: v2(133.93,20.48) 132.24,22.18 132.24,31.64 132.29,31.7 132.29,32.7 141.37,41.78 141.37,42.43 145.72,46.78 145.72,49.64 146.52,50.44 146.52,53.13 146.98,53.58 v2(146.98,54.02)
  BOTTOM w0.076: UH1.AU1 150.75,59.17 150.75,59.17 150.75,58.18 149.39,56.82 149.11,56.82 146.98,54.69 v2(146.98,54.02)
  BOTTOM w0.221: JDIMM1.115 135.88,25.07 135.27,24.46 135.27,22.1 134.44,21.26 134.44,20.99 v2(133.93,20.48)
DDR_A_BG1: length 52.1
  IN6 w0.117: v2(147.73,54.91) 147.74,54.9 147.74,53.7 146.94,52.91 146.94,50.26 146.15,49.47 146.15,46.61 141.99,42.45 141.99,41.8 132.71,32.53 132.71,31.47 132.66,31.41 132.66,23.05 133.09,22.62 v2(133.93,21.78)
  BOTTOM w0.076: UH1.AU2 150.75,60.13 151.03,59.85 151.03,58.22 148.56,55.75 148.56,55.74 v2(147.73,54.91)
  BOTTOM w0.221: v2(133.93,21.78) 134.06,21.78 134.75,22.46 134.75,24.79 135.37,25.42 JDIMM1.113
DDR_A_BS0: length 53.6
  IN6 w0.089: 159.17,50 159.17,50.44 158.61,51 158.61,58.49 158.49,58.62 v2(157.41,58.62)
  IN6 w0.117: 159.17,50 159.17,45.55 157.91,44.3 157.91,42.26 149.37,33.72 149.37,31.81 147.4,29.83 147.4,25.25 145.7,23.55 145.7,22.11 145.82,21.98 v2(146.47,21.98)
  BOTTOM w0.076: v2(157.41,58.62) 157.8,59.01 157.8,62.14 158,62.34 UH1.AH5
  BOTTOM w0.221: v2(146.47,21.98) 147.35,21.98 147.47,21.85 147.47,21.31 146.96,20.79 146.96,20.07 146.64,19.75 JDIMM1.150
DDR_A_BS1: length 51.2
  IN6 w0.089: 158.32,50 158.32,50.33 158.15,50.5 158.15,56.22 157.73,56.65 v2(157.41,56.65)
  IN6 w0.117: 158.32,50 158.32,45.9 157.07,44.65 157.07,42.61 148.44,33.98 148.44,33.12 148.36,33.04 148.17,33.04 147.89,33.31 147.77,33.31 147.55,33.09 147.55,32.94 148.32,32.17 148.32,32.02 148.07,31.77 147.9,31.77 147.42,32.25 147.24,32.25 147.01,32.02 147.01,31.84 147.49,31.36 147.49,31.19 147.24,30.94 147.08,30.94 146.93,31.1 146.76,31.1 145.78,30.11 145.78,29.15 146.13,28.79 146.13,27.18 146.25,27.06 146.43,27.06 146.55,26.95 146.55,26.71 146.43,26.6 146.25,26.6 146.13,26.48 146.13,26.25 146.25,26.13 146.43,26.13 146.55,26.01 146.55,25.78 146.43,25.66 146.25,25.66 146.13,25.55 146.13,25.18 144.8,23.85 v2(144.8,23.25)
  BOTTOM w0.076: v2(157.41,56.65) 158.3,57.54 UH1.AH1
  BOTTOM w0.221: v2(144.8,23.25) 144.8,24.94 145.37,25.51 JDIMM1.145
DDR_A_CAS#: length 51.3
  IN6 w0.117: v2(150.74,21.95) 151.29,21.95 151.99,22.65 151.99,24.25 153.04,25.3 153.04,26.88 152.59,27.33 152.59,28.7 155.13,31.24 155.13,33.44 162.18,40.49 162.18,41.3 164.17,43.28 164.17,49.71 160.58,53.3 v2(160.58,53.8)
  BOTTOM w0.076: v2(160.58,53.8) 160.58,54.23 161.7,55.35 161.7,59.58 UH1.AD1
  BOTTOM w0.221: JDIMM1.156 148.14,19.24 148.14,19.31 148.9,20.06 149.38,20.06 150.03,20.71 150.03,21.39 150.59,21.95 v2(150.74,21.95)
DDR_A_D0: length 61.7
  IN6 w0.079: v2(107.65,21.34) 107.65,23.57 107.98,23.9 107.98,30.2 120.09,42.31 120.09,46.94 122.8,49.65 122.8,49.77 122.66,49.91 122.66,50.02 122.77,50.13 122.88,50.13 123.02,49.99 123.13,49.99 131.94,58.8 131.94,60.9 132.97,61.92 135.52,61.92 v2(135.54,61.9)
  BOTTOM w0.076: v2(135.54,61.9) 135.54,62.54 136.05,63.05 136.71,63.05 136.79,62.97 137.14,62.97 137.19,63.03 138.02,63.03 UH1.BR6
  BOTTOM w0.14: v2(107.65,21.34) 108.01,21.34 109.13,20.22 JDIMM1.8
DDR_A_D1: length 61.8
  IN6 w0.079: v2(136.93,63.33) 136.27,63.33 135.54,62.61 132.56,62.61 131.38,61.42 131.38,59.03 128.45,56.1 128.32,56.1 128.06,56.37 127.97,56.37 127.77,56.17 127.77,56.06 128.02,55.8 128.02,55.69 127.91,55.58 127.8,55.58 127.55,55.84 127.44,55.84 127.27,55.67 127.27,55.56 127.47,55.36 127.47,55.23 127.38,55.14 127.25,55.14 127.05,55.34 126.94,55.34 126.83,55.23 126.83,55.12 127.05,54.9 127.05,54.77 126.95,54.67 126.82,54.67 126.6,54.89 126.49,54.89 126.38,54.78 126.38,54.67 126.64,54.41 126.64,54.3 126.53,54.19 126.42,54.19 126.16,54.45 126.05,54.45 119.53,47.93 119.53,42.54 107.42,30.43 107.42,25.73 106.94,25.25 106.94,24.22 v2(107.34,23.82)
  BOTTOM w0.076: UH1.BT6 v2(136.93,63.33)
  BOTTOM w0.14: v2(107.34,23.82) 107.81,24.3 107.81,24.43 108.88,25.5 JDIMM1.7
