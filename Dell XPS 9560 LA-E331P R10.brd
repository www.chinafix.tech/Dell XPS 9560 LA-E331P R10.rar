# Allegro board Dell XPS 9560 LA-E331P R10.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBC_CLK0: length 39.9
  IN6 w0.097: v2(219.25,67.59) 218.91,67.93 218.91,68.63 219.38,69.1 220.71,69.1 221.11,69.5 239.08,69.5 239.31,69.27 239.52,69.27 v2(239.73,69.06) 239.95,69.29 240.48,69.29 242.63,67.13 242.63,66.91 242.63,66.9 242.63,66.13 242.9,65.86 242.9,65.55 242.1,64.75 242.1,63.87 241.81,63.59 241.81,60.02 242.53,59.31 242.53,58.42 242.89,58.05 242.89,57.76 242.9,57.75 242.9,57.6 243.32,57.17 v2(243.32,56.9)
  BOTTOM w0.102: UV25.J12 242.92,57.3 v2(243.32,56.9)
  BOTTOM w0.114: UV18.D12 219.64,67.21 v2(219.25,67.59)
  BOTTOM w0.17: RV629.1 240.23,69.25 239.91,69.25 v2(239.73,69.06)
FBC_CLK0#: length 39.7
  IN6 w0.097: v2(218.31,67.76) 218.74,68.19 218.74,68.7 219.31,69.27 220.64,69.27 221.04,69.67 239.15,69.67 239.38,69.44 239.52,69.44 v2(239.73,69.65) 239.91,69.46 240.55,69.46 242.81,67.2 242.81,66.21 243.07,65.94 243.07,65.47 242.28,64.67 242.28,63.8 241.99,63.51 241.99,60.09 242.7,59.38 242.7,58.49 243.07,58.12 243.07,57.83 243.18,57.71 v2(243.32,57.71)
  BOTTOM w0.102: UV25.J11 242.93,58.1 v2(243.32,57.71)
  BOTTOM w0.114: UV18.E12 218.83,67.2 218.38,67.65 218.38,67.7 v2(218.31,67.76)
  BOTTOM w0.17: RV628.1 240.13,69.58 239.8,69.58 v2(239.73,69.65)
FBC_CLK1: length 42.7
  IN6 w0.097: v2(242.52,88.21) 242.8,88.21 243.14,87.87 243.14,87.36 242.33,86.56 242.33,83.39 241.12,82.17 241.12,81.47 241.7,80.89 241.7,77.87 237.49,73.66 237.49,72.86 v2(237.29,72.65) 237.49,72.45 237.49,72.01 236.62,71.13 221.74,71.13 221.11,71.76 219.45,71.76 218.71,72.5 218.71,73.18 219.02,73.49 v2(219.22,73.49)
  BOTTOM w0.102: v2(242.52,88.21) 242.52,88.24 UV26.J12
  BOTTOM w0.114: UV18.E20 218.84,73.87 v2(219.22,73.49)
  BOTTOM w0.17: RV638.1 237.47,73.1 237.47,72.84 v2(237.29,72.65)
FBC_CLK1#: length 42.6
  IN6 w0.097: v2(243.31,88.23) 243.31,88.23 243.31,87.29 242.51,86.49 242.51,83.32 241.29,82.1 241.29,81.55 241.88,80.96 241.88,78.99 241.88,78.98 241.88,78.94 241.87,78.93 241.87,77.8 237.66,73.59 237.66,72.86 v2(237.87,72.65) 237.66,72.45 237.66,71.94 236.69,70.96 221.67,70.96 221.04,71.59 219.38,71.59 218.54,72.43 218.54,73.29 v2(218.36,73.47)
  BOTTOM w0.102: v2(243.31,88.23) UV26.J11
  BOTTOM w0.114: UV18.F20 217.99,73.85 v2(218.36,73.47)
  BOTTOM w0.17: RV637.1 237.8,73.03 237.8,72.72 v2(237.87,72.65)
FBC_CS#_H: length 31.6
  TOP w0.102: v2(220.13,72.62) 220.42,72.91 220.42,73.9 222.54,76.02 224.09,76.02 224.32,76.24 224.32,77.22 224.45,77.35 ; 235.92,87.05 241.55,87.05 241.55,87.06 241.87,87.06 242.09,87.28 242.09,87.65 241.72,88.02 v2(241.72,88.24)
  TOP w0.221: 235.92,87.05 234.15,87.05 v1(226.32,79.22) 224.45,77.35
  BOTTOM w0.102: UV18.D18 219.64,72.25 220.01,72.62 v2(220.13,72.62) ; UV26.L12 v2(241.72,88.24)
FBC_CS#_L: length 26.5
  TOP w0.102: 225.14,64.97 223.2,64.97 221.73,66.44 221.22,66.44 v2(220.03,67.64) ; v2(240.95,57.71) 240.59,58.07 240.59,58.57 240.19,58.97
  TOP w0.221: 240.19,58.97 235.75,58.97 v1(235.28,59.44) 230.17,64.56 225.96,64.56 225.55,64.97 225.14,64.97
  BOTTOM w0.107: UV25.G12 241.32,57.34 v2(240.95,57.71)
  BOTTOM w0.17: v2(220.03,67.64) 220.03,67.66 UV18.D13
FBC_D0: length 22.7
  IN6 w0.102: v2(236.92,64.11) 235.94,63.13 ; v2(216.75,65.12) 217.3,64.56 218.97,64.56 218.98,64.56 219.81,64.56 220.03,64.78 220.98,64.78 221.9,63.86
  IN6 w0.117: 221.9,63.86 222.61,63.86 222.76,63.72 225.47,63.72 226.06,63.13 235.94,63.13
  BOTTOM w0.102: v2(216.75,65.12) 216.75,65.11 217.14,64.72 UV18.G9 ; UV25.A4 v2(236.92,64.11)
FBC_D1: length 19.5
  IN6 w0.102: 222.12,64.91 221.79,65.24 219.31,65.24 v2(219.22,65.14)
  IN6 w0.117: v2(236.92,65.71) 235.98,64.76 223.21,64.76 223.07,64.91 222.12,64.91
  BOTTOM w0.102: v2(219.22,65.14) 218.84,64.76 218.84,64.76 UV18.E9 ; UV25.A2 v2(236.92,65.71)
FBC_D2: length 22.1
  IN6 w0.102: 235.92,62.6 236.22,62.6 v2(236.92,63.3) ; 222.12,62.95 221.6,62.95 221.24,63.32 221.24,63.54 221,63.77 220.88,63.77 220.29,64.35 218.89,64.35 218.89,64.36 218.5,64.36 v2(217.57,63.44)
  IN6 w0.117: 235.92,62.6 224.55,62.6 224.3,62.86 222.44,62.86 222.36,62.95 222.12,62.95
  BOTTOM w0.102: UV18.G8 217.14,63.87 v2(217.57,63.44) ; UV25.B4 v2(236.92,63.3)
FBC_D3: length 22.8
  IN6 w0.102: 222.12,64.38 221.47,65.03 219.77,65.03 219.5,64.76 219.06,64.76 219.05,64.77 218.07,64.77 v2(217.66,65.17) ; 236.73,64.52 237.08,64.52 237.3,64.75 237.3,65.29 v2(237.72,65.71)
  IN6 w0.117: 236.73,64.52 236.44,64.24 223,64.24 222.85,64.38 222.12,64.38
  BOTTOM w0.102: UV25.B2 v2(237.72,65.71) ; v2(217.66,65.17) 217.99,64.85 UV18.F9
FBC_D4: length 25.4
  IN6 w0.102: v2(218.41,65.97) 218.69,65.97 219.32,66.6 222.12,66.6 ; 238.76,66.88 238.9,66.74 238.9,64.52 v2(239.32,64.11)
  IN6 w0.117: 222.12,66.6 222.17,66.55 222.72,66.55 223.04,66.87 235.84,66.87 236.38,67.42 238.22,67.42 238.76,66.88
  BOTTOM w0.102: UV18.F11 v2(218.41,65.97) ; UV25.E4 v2(239.32,64.11)
FBC_D5: length 26.6
  IN6 w0.102: v2(239.32,64.91) 239.7,65.29 239.7,66.68 239.5,66.88 ; 222.12,67.45 221.48,66.8 219.07,66.8 218.62,66.35 217.94,66.35 v2(217.56,65.97)
  IN6 w0.117: 239.5,66.88 238.44,67.94 236.17,67.94 235.67,67.45 222.12,67.45
  BOTTOM w0.102: UV25.E2 v2(239.32,64.91) ; UV18.G11 v2(217.56,65.97)
FBC_D6: length 29.8
  IN6 w0.102: 240.76,66.88 240.54,66.66 240.54,64.49 v2(240.92,64.11) ; v2(217.57,66.84) 218.05,67.33 218.68,67.33 218.8,67.21 220.14,67.21 220.47,67.54 220.47,67.79 221.55,68.87 222.12,68.87
  IN6 w0.117: 240.76,66.88 240.76,67.1 238.87,68.99 235.73,68.99 235.24,68.49 223.06,68.49 222.68,68.87 222.12,68.87
  BOTTOM w0.102: UV25.F4 v2(240.92,64.11) ; UV18.F12 217.92,67.2 v2(217.57,66.84)
FBC_D7: length 27.9
  IN6 w0.102: 240.23,66.65 240.23,65.82 v2(240.12,65.71) ; 220.9,67.14 220.78,67.01 218.72,67.01 218.6,67.13 218.28,67.13 218.06,66.91 218.06,66.8 217.72,66.46 217.06,66.46 v2(216.75,66.78)
  IN6 w0.117: 220.9,67.14 222.12,68.35 222.47,68.35 222.85,67.97 235.45,67.97 235.95,68.46 238.65,68.46 240.23,66.88 240.23,66.65
  BOTTOM w0.102: v2(216.75,66.78) 217.14,67.17 UV18.G12 ; UV25.F2 v2(240.12,65.71)
FBC_D8: length 21.8
  IN6 w0.102: 222.12,59.9 221.86,59.9 220.91,60.85 220.66,60.85 219.32,62.19 217.95,62.19 v2(217.56,62.57) ; 235.92,57.96 v2(236.15,57.72)
  IN6 w0.117: 222.12,59.9 223.26,59.9 224.39,58.77 235.1,58.77 235.92,57.96
  BOTTOM w0.102: UV18.G6 217.14,62.15 v2(217.56,62.57)
  BOTTOM w0.107: UV25.A11 236.15,57.74 v2(236.15,57.72)
FBC_D9: length 21.7
  IN6 w0.102: 222.12,58.02 221.62,58.02 221.21,58.43 221.21,59.44 220.98,59.67 220.73,59.67 220.41,59.99 220.41,60.24 220.13,60.52 218.72,60.52 v2(218.34,60.9)
  IN6 w0.117: v2(234.7,56.16) 233.13,57.73 222.57,57.73 222.28,58.02 222.12,58.02
  BOTTOM w0.102: UV25.A13 235.79,56.5 ; UV18.F5 v2(218.34,60.9)
  BOTTOM w0.221: 235.79,56.5 235.65,56.5 235.56,56.6 235.14,56.6 v2(234.7,56.16)
FBC_D10: length 21.9
  IN6 w0.102: 235.92,59.3 236.66,59.3 237.3,58.66 237.3,58.1 v2(236.93,57.74) ; v2(219.24,62.6) 220.74,61.1 222.12,61.1
  IN6 w0.117: 222.12,61.1 222.89,61.1 224.09,59.89 225.05,59.89 225.65,59.3 235.92,59.3
  BOTTOM w0.102: UV18.E6 v2(219.24,62.6) ; v2(236.93,57.74) 236.93,57.72 UV25.B11
FBC_D11: length 21.7
  IN6 w0.102: 222.12,59.38 222.12,59.41 221.84,59.7 221.77,59.7 220.83,60.64 220.42,60.64 219.32,61.74 v2(218.36,61.74) ; v2(236.89,56.9) 236.51,57.28 235.92,57.28
  IN6 w0.117: 235.92,57.28 235.31,57.28 234.34,58.25 223.25,58.25 222.12,59.38
  BOTTOM w0.102: v2(236.89,56.9) 236.92,56.9 UV25.B13 ; v2(218.36,61.74) 217.99,62.11 UV18.F6
FBC_D12: length 26.8
  IN6 w0.102: 235.92,55.19 238.15,55.19 238.9,55.95 238.9,58.09 v2(239.32,58.5) ; 221.07,57.29 218.92,59.43 218.92,59.54 218.37,60.09 v2(218.34,60.09)
  IN6 w0.117: 235.92,55.19 234.14,55.19 232.66,56.68 221.67,56.68 221.07,57.29
  BOTTOM w0.102: UV25.E11 v2(239.32,58.5) ; UV18.F4 v2(218.34,60.09)
FBC_D13: length 27
  IN6 w0.102: v2(239.32,56.1) 239.32,55.72 238.41,54.81 ; 220.33,57.29 220.33,57.6 218.72,59.21 218.72,59.46 218.49,59.68 218.22,59.68 217.51,60.39 v2(217.51,60.91)
  IN6 w0.117: 220.33,57.29 221.45,56.16 232.44,56.16 233.93,54.67 238.26,54.67 238.41,54.81
  BOTTOM w0.102: UV18.G4 217.09,60.5 v2(217.51,60.91) ; UV25.E13 v2(239.32,56.1)
FBC_D14: length 29.2
  IN6 w0.102: 218.82,57.29 218.34,57.77 v2(218.34,58.43) ; v2(240.1,57.72) 240.52,57.3 240.52,55.07
  IN6 w0.117: 240.52,55.07 239.06,53.61 233.42,53.61 232.01,55.02 221.09,55.02 218.82,57.29
  BOTTOM w0.102: v2(240.1,57.72) 240.48,58.1 UV25.F11
  BOTTOM w0.127: UV18.E2 218.74,58.9 218.34,58.49 v2(218.34,58.43)
FBC_D15: length 27.3
  IN6 w0.102: v2(240.09,56.87) 239.71,56.5 239.71,55.38 239.15,54.81 ; 219.59,57.29 219.59,58.05 v2(218.34,59.3)
  IN6 w0.117: 219.59,57.29 221.24,55.63 232.22,55.63 233.71,54.15 238.48,54.15 239.15,54.81
  BOTTOM w0.102: UV18.F3 v2(218.34,59.3) ; v2(240.09,56.87) 240.11,56.87 240.11,56.91 UV25.F13
FBC_D16: length 37.5
  IN1 w0.102: 249.11,54.81 249.11,55.73 249.32,55.94 249.32,56.67 249.83,57.17 v2(249.83,58.25)
  IN1 w0.117: 249.11,54.81 249.11,54.36 247.18,52.43 239.85,52.43 239.42,52.86 238.64,52.86 238.64,52.86 232.16,52.86 230.37,54.65 223.85,54.65 220.71,57.79 220.71,58.41 v2(220.79,58.49)
  BOTTOM w0.102: UV18.C2 220.44,58.78 220.73,58.49 v2(220.79,58.49) ; UV25.U11 249.47,58.26 249.79,58.26 249.8,58.25 v2(249.83,58.25)
FBC_D17: length 42.1
  TOP w0.221: v1(249.72,54.72) 250.23,54.72 v2(250.38,54.87)
  IN1 w0.117: v2(250.38,54.87) 250.38,53.41 248.35,51.38 238.2,51.38 237.77,51.81 231.73,51.81 229.93,53.6 222.95,53.6 219.53,57.02 219.53,59.59 v2(220.03,60.08)
  BOTTOM w0.102: v2(220.03,60.08) 219.64,60.47 UV18.D4 ; UV25.U13 249.64,56.19
  BOTTOM w0.221: v2(250.38,54.87) 249.69,55.56 249.69,55.86 249.68,55.86 249.68,56.14 249.64,56.19
FBC_D18: length 42
  IN1 w0.102: 249.89,56.67 249.75,56.52 249.75,54.81 ; v2(248.92,58.49) 249.07,58.64 249.89,58.64
  IN1 w0.117: 249.89,58.64 250.11,58.64 250.51,58.24 250.51,57.29 249.89,56.67 ; 249.75,54.81 249.75,54.11 247.54,51.9 239.63,51.9 239.2,52.34 238.86,52.34 238.85,52.33 231.94,52.33 230.15,54.13 223.63,54.13 220.07,57.69 220.07,59.15 v2(220,59.22)
  BOTTOM w0.102: v2(220,59.22) 219.59,59.63 UV18.D3 ; v2(248.92,58.49) 248.91,58.49 UV25.T11
FBC_D19: length 33.3
  IN1 w0.117: v2(222.12,57.6) 222.12,57.29 224.24,55.17 230.59,55.17 232.38,53.38 238.42,53.38 238.42,53.38 239.63,53.38 239.98,53.03 247.04,53.03 v2(248.55,54.54)
  BOTTOM w0.102: UV18.C1 220.87,57.67 222.06,57.67 v2(222.12,57.6) ; 248.23,54.94 248.17,55 248.17,55.28 248.16,55.29 248.16,55.95 248.52,56.31 UV25.T13
  BOTTOM w0.221: 248.23,54.94 248.23,54.86 v2(248.55,54.54)
FBC_D20: length 30.5
  IN1 w0.102: v2(246.57,57.73) 246.57,57.61 246.94,57.25 246.94,56.13 246.51,55.7 244.92,55.7 244.33,55.11 235.92,55.11
  IN1 w0.117: 235.92,55.11 232.89,55.11 231.26,56.74 226.19,56.74 223.49,59.44 221.81,59.44 v2(221.68,59.32)
  BOTTOM w0.102: v2(221.68,59.32) 221.3,59.7 UV18.B3 ; UV25.N11 246.49,57.73 v2(246.57,57.73)
FBC_D21: length 29.9
  IN1 w0.102: 235.92,59.69 244.52,59.69 245.16,59.05 245.76,59.05 246.1,58.71 246.1,57.38 v2(246.54,56.94)
  IN1 w0.117: v2(220.79,60.14) 221.68,61.03 222.53,61.03 222.68,61.19 226.69,61.19 228.2,59.69 235.92,59.69
  BOTTOM w0.102: UV25.N13 246.54,56.93 v2(246.54,56.94) ; UV18.C4 220.51,60.55 220.79,60.27 v2(220.79,60.14)
FBC_D22: length 26.6
  IN1 w0.102: v2(245.68,58.56) 245.24,58.12 236.78,58.12 236.77,58.11 235.92,58.11
  IN1 w0.117: 235.92,58.11 227.67,58.11 225.25,60.54 222.77,60.54 v2(222.76,60.52)
  BOTTOM w0.102: v2(222.76,60.52) 222.25,61.03 221.84,61.03 221.47,61.4 UV18.B5 ; v2(245.68,58.56) 245.32,58.19 UV25.M11
FBC_D23: length 28.4
  IN1 w0.102: 235.92,55.63 244.27,55.63 244.78,56.14 v2(245.68,56.14)
  IN1 w0.117: v2(221.81,60.52) 222.31,60.02 224.5,60.02 226.95,57.57 231.31,57.57 233.24,55.63 235.92,55.63
  BOTTOM w0.102: UV18.C5 220.81,61.4 220.91,61.3 220.91,61.26 221.29,60.88 221.37,60.88 221.73,60.52 v2(221.81,60.52) ; UV25.M13 245.32,56.5 v2(245.68,56.14)
FBC_D24: length 31.2
  IN1 w0.102: 247.65,66.88 247.84,66.68 247.84,66.52 248.5,65.86 248.5,65.05 249.53,64.02 v2(249.75,64.02)
  IN1 w0.117: v2(224.91,65.92) 226.07,67.08 241.08,67.08 241.6,67.6 246.74,67.6 247.27,67.06 247.46,67.06 247.65,66.88
  BOTTOM w0.102: UV18.A11 224.43,66.4 v2(224.91,65.92) ; UV25.U4 249.38,63.7
  BOTTOM w0.221: v2(249.75,64.02) 249.43,63.7 249.38,63.7
FBC_D25: length 32.9
  IN1 w0.102: 249.59,66.88 249.66,66.81 v2(249.66,65.71)
  IN1 w0.117: v2(220.82,66.02) 221.31,66.51 222.68,66.51 224.29,68.13 240.64,68.13 241.16,68.64 247.83,68.64 249.59,66.88
  BOTTOM w0.102: v2(220.82,66.02) UV18.C11 ; UV25.U2 249.38,65.37
  BOTTOM w0.221: 249.38,65.37 249.66,65.65 v2(249.66,65.71)
FBC_D26: length 43.5
  IN1 w0.102: 249.89,62.45 249.55,62.11 v2(248.6,62.11)
  IN1 w0.117: v2(218.44,66.75) 220.55,66.75 221.69,67.89 221.69,67.92 222.42,68.65 240.43,68.65 241.25,69.47 247.74,69.47 250.51,66.7 250.51,63.07 249.89,62.45
  BOTTOM w0.102: v2(218.44,66.75) 219.29,66.75 UV18.D11 ; UV25.T4 248.53,63.7 248.92,63.32 248.92,62.43 v2(248.6,62.11)
FBC_D27: length 30.9
  IN1 w0.102: 248.71,66.88 248.71,66.45 248.85,66.3 248.85,65.74 v2(248.92,65.67)
  IN1 w0.117: v2(221.62,65.99) 222.95,65.99 224.57,67.6 240.86,67.6 241.38,68.12 247.47,68.12 248.71,66.88
  BOTTOM w0.102: v2(248.92,65.67) 248.88,65.67 UV25.T2 ; UV18.B11 221.24,66.36 v2(221.62,65.99)
FBC_D28: length 27.7
  IN1 w0.098: v2(245.75,63.32) 245.36,63.7 242.72,63.7 242.66,63.76 241.91,63.76 241.88,63.73 235.93,63.73 235.92,63.74
  IN1 w0.117: v2(220.85,64.33) 221.33,64.81 223.83,64.81 224.21,64.43 235.22,64.43 235.92,63.74
  BOTTOM w0.102: UV25.N4 246.12,63.69 v2(245.75,63.32) ; UV18.D8 219.91,63.9 220.35,64.33 v2(220.85,64.33)
FBC_D29: length 31
  IN1 w0.102: 235.92,61.17 236.12,60.97 245.39,60.97 246.5,62.08 246.5,62.87 246.64,63.01 246.64,64.78 245.75,65.67 v2(245.75,65.73)
  IN1 w0.117: 235.92,61.17 234.22,62.86 222.92,62.86 222.89,62.88 222.75,62.88 222.57,63.06 v2(222.57,63.32)
  BOTTOM w0.102: v2(222.57,63.32) 222.04,63.85 UV18.A8 ; UV25.N2 245.75,65.68 v2(245.75,65.73)
FBC_D30: length 26.4
  IN1 w0.098: 244.74,63.13 v2(244.89,63.28) ; 235.92,62.92 239.42,62.92
  IN1 w0.102: 239.42,62.92 244.54,62.92 244.74,63.13
  IN1 w0.117: v2(220.84,63.39) 221.74,64.29 223.61,64.29 223.99,63.91 234.93,63.91 235.92,62.92
  BOTTOM w0.102: UV18.C8 220.85,63.48 220.85,63.4 v2(220.84,63.39) ; v2(244.89,63.28) UV25.M4
FBC_D31: length 30.7
  IN1 w0.098: 243.19,61.93 236.36,61.93
  IN1 w0.102: 236.36,61.93 236.15,61.93 ; v2(244.98,64.08) 245.43,64.52 245.93,64.52 246.25,64.2 246.25,63.01 245.18,61.93 243.19,61.93
  IN1 w0.117: v2(221.74,63.38) 222.12,63.76 223.39,63.76 223.77,63.38 234.7,63.38 236.15,61.93
  BOTTOM w0.102: v2(244.98,64.08) 244.98,64.97 245.32,65.3 UV25.M2 ; UV18.B8 221.74,63.39 v2(221.74,63.38)
FBC_D32: length 22.9
  IN6 w0.102: v2(217.56,76.85) 217.75,77.03 221.9,77.03 222.27,77.4 225.37,77.4 ; v2(236.91,81.83) 236.52,82.22 236.32,82.22
  IN6 w0.117: 236.32,82.22 235.96,82.22 231.14,77.4 225.37,77.4
  BOTTOM w0.102: v2(236.91,81.83) 236.91,81.84 UV26.U4 ; v2(217.56,76.85) 217.91,77.2 UV18.F24
FBC_D33: length 22.9
  IN6 w0.102: 224.54,76.4 223.97,76.97 222.5,76.97 222.1,76.57 218.33,76.57 217.74,75.97 v2(217.56,75.97) ; 235.92,80.28 236.12,80.47 v2(236.12,81.03)
  IN6 w0.117: 224.54,76.4 224.93,76 231.65,76 235.92,80.28
  BOTTOM w0.102: UV26.U2 v2(236.12,81.03) ; UV18.G23 v2(217.56,75.97)
FBC_D34: length 22.4
  IN6 w0.102: 224.97,77.77 224.81,77.61 222.19,77.61 221.82,77.24 218.87,77.24 v2(218.42,77.69) ; 236.05,82.98 236.57,82.98 v2(236.92,82.63)
  IN6 w0.117: 236.05,82.98 235.97,82.98 231.3,78.3 225.51,78.3 224.97,77.77
  BOTTOM w0.102: UV18.E24 218.84,77.27 v2(218.42,77.69) ; UV26.T4 v2(236.92,82.63)
FBC_D35: length 24.8
  IN6 w0.102: 235.99,81.42 236.53,81.42 v2(236.92,81.03) ; 225,76.89 224.69,77.2 222.44,77.2 222.02,76.77 218.12,76.77 217.81,76.47 217.4,76.47 216.74,77.13 v2(216.74,77.62)
  IN6 w0.117: 235.99,81.42 235.96,81.42 235.73,81.2 235.73,80.83 231.78,76.88 225.01,76.88 225,76.89
  BOTTOM w0.102: v2(216.74,77.62) 217.14,77.22 UV18.G24 ; UV26.T2 v2(236.92,81.03)
FBC_D36: length 25.4
  IN6 w0.102: 223.34,74.25 222.51,74.25 221.64,75.12 v2(220.04,75.12) ; v2(240.12,81.83) 239.94,81.83 239.52,81.42 239.16,81.42 238.9,81.15 238.9,79.95 237.96,79.01
  IN6 w0.117: 223.34,74.25 233.21,74.25 237.96,79.01
  BOTTOM w0.102: UV26.N4 v2(240.12,81.83) ; v2(220.04,75.12) 219.64,74.72 UV18.D21
FBC_D37: length 27.3
  IN6 w0.102: 239.44,79.01 240.5,80.07 240.5,80.65 v2(240.12,81.03) ; 221.99,73.29 220.97,74.31 v2(219.24,74.31)
  IN6 w0.117: 239.44,79.01 233.02,72.59 223.36,72.59 222.72,73.22 222.06,73.22 221.99,73.29
  BOTTOM w0.102: UV26.N2 v2(240.12,81.03) ; UV18.E21 219.22,74.31 v2(219.24,74.31)
FBC_D38: length 30.5
  IN6 w0.102: v2(216.74,75.12) 217.12,74.74 221.73,74.74 222.42,74.05 222.79,74.05 223.12,73.72 ; v2(240.15,82.58) 240.5,82.23 240.5,81.68 240.28,81.45 240,81.45 239.71,81.17 239.71,80.02 238.7,79.01
  IN6 w0.117: 238.7,79.01 233.41,73.72 223.12,73.72
  BOTTOM w0.102: v2(216.74,75.12) 216.74,75.1 UV18.G21 ; v2(240.15,82.58) 240.17,82.58 UV26.M4
FBC_D39: length 30.9
  IN6 w0.102: 220.49,73.29 220.45,73.33 220.45,73.6 220.19,73.87 218.03,73.87 v2(217.57,74.32) ; 241.19,79.01 241.43,79.25 241.43,79.73 v2(240.92,80.24)
  IN6 w0.117: 220.49,73.29 220.75,73.04 221.17,73.04 222.46,71.74 234.57,71.74 241.19,78.36 241.19,79.01
  BOTTOM w0.102: v2(240.92,80.24) 240.92,80.23 UV26.M2 ; UV18.F21 217.94,74.7 217.57,74.34 v2(217.57,74.32)
FBC_D40: length 26.1
  IN6 w0.102: v2(236.92,87.43) 237.34,87.02 237.34,86.34 237.11,86.11 236.32,86.11 ; 223.97,79.71 223.78,79.52 223.78,79.1 223.12,78.45 222.26,78.45 221.95,78.76 219.77,78.76 219.5,79.04 219.01,79.04 219,79.03 217.83,79.03 v2(217.56,79.3)
  IN6 w0.117: 236.32,86.11 230.23,80.03 224.29,80.03 223.97,79.71
  BOTTOM w0.102: UV26.U11 v2(236.92,87.43) ; UV18.G27 217.16,79.7 v2(217.56,79.3)
FBC_D41: length 23.5
  IN6 w0.102: 235.92,87.34 236.5,87.92 236.5,88.62 v2(236.92,89.04) ; v2(219.19,80.08) 219.57,80.46 220.2,80.46 220.64,80.02 221.52,80.02 222.03,80.53 222.47,80.53 222.64,80.36 223.17,80.36 223.92,81.11
  IN6 w0.117: 235.92,87.34 229.7,81.11 223.92,81.11
  BOTTOM w0.102: v2(219.19,80.08) 219.25,80.08 UV18.D27 ; UV26.U13 v2(236.92,89.04)
FBC_D42: length 26.8
  IN6 w0.102: 235.92,84.98 236.04,85.1 236.81,85.1 238.12,86.42 238.12,87.03 v2(237.72,87.43) ; 224.1,78.96 223.38,78.25 222.17,78.25 221.88,78.54 219.71,78.54 219.41,78.84 219.1,78.84 219.03,78.77 218.24,78.77 218.02,78.54 218.02,78.54 217.92,78.44 v2(217.54,78.44)
  IN6 w0.117: 235.92,84.98 230.44,79.5 224.64,79.5 224.1,78.96
  BOTTOM w0.102: UV18.G26 217.54,78.5 v2(217.54,78.44) ; UV26.T11 v2(237.72,87.43)
FBC_D43: length 25
  IN6 w0.102: 236.54,87.08 236.54,87.27 236.54,87.28 236.54,87.59 236.78,87.84 237.02,87.84 237.34,88.16 237.34,88.65 v2(237.72,89.04) ; v2(218.48,80.11) 218.89,79.7 223.22,79.7
  IN6 w0.117: 236.54,87.08 230.05,80.59 224.11,80.59 223.22,79.7
  BOTTOM w0.102: UV26.T13 v2(237.72,89.04) ; UV18.E27 218.84,79.75 218.5,80.08 218.5,80.09 v2(218.48,80.11)
FBC_D44: length 28.1
  IN6 w0.102: 223.68,81.95 223.35,81.62 220.43,81.62 220.26,81.8 v2(219.24,81.8) ; 238.74,90.45 238.94,90.25 238.94,89.68 239.2,89.42 239.48,89.42 239.7,89.19 239.7,87.85 v2(240.12,87.43)
  IN6 w0.117: 238.74,90.45 236.55,90.45 228.83,82.73 224.46,82.73 223.68,81.95
  BOTTOM w0.102: UV26.N11 v2(240.12,87.43) ; UV18.E29 v2(219.24,81.8)
FBC_D45: length 27.8
  IN6 w0.102: 225.06,83.25 224.47,83.25 223.04,81.83 220.52,81.83 220.32,82.03 219.55,82.03 219.4,82.18 218.72,82.18 v2(218.41,81.87) ; v2(240.12,89.04) 240.12,89.3 239.72,89.7 239.72,90.05 239.1,90.66 236.04,90.66 235.92,90.54
  IN6 w0.117: 235.92,90.54 235.9,90.54 228.61,83.25 225.06,83.25
  BOTTOM w0.102: v2(218.41,81.87) 217.99,81.45 UV18.F29 ; UV26.N13 v2(240.12,89.04)
FBC_D46: length 31.1
  IN6 w0.102: v2(219.24,82.7) 219.64,82.7 219.87,82.93 220.18,82.93 220.44,82.67 220.44,82.48 220.69,82.23 221.82,82.23 222.04,82.46 222.04,82.74 222.26,82.96 222.58,82.96 222.6,82.94 223.23,82.94 223.85,83.56 ; 240.22,91.07 240.22,91.07 241.3,89.99 241.3,87.82 v2(240.92,87.43)
  IN6 w0.117: 223.85,83.56 224.64,84.35 227.92,84.35 235.16,91.6 239.69,91.6 240.22,91.07
  BOTTOM w0.102: UV18.E30 v2(219.24,82.7) ; UV26.M11 v2(240.92,87.43)
FBC_D47: length 27.1
  IN6 w0.102: 235.92,91.07 239.42,91.07 240.5,89.99 240.5,89.45 v2(240.92,89.04) ; 224.67,83.64 224.57,83.64 222.96,82.03 220.6,82.03 220.09,82.55 v2(220.03,82.55)
  IN6 w0.117: 224.67,83.64 224.85,83.83 228.13,83.83 235.37,91.07 235.92,91.07
  BOTTOM w0.102: UV18.D30 219.64,82.22 219.96,82.55 v2(220.03,82.55) ; UV26.M13 v2(240.92,89.04)
FBC_D48: length 38.7
  IN1 w0.102: v2(223.02,83.32) 224.09,83.32 224.49,83.72 225.43,83.72
  IN1 w0.117: 225.43,83.72 228.55,83.72 235.84,91 242.17,91 242.86,91.7 244.47,91.7 244.85,92.09 245.63,92.09 245.86,91.86 249.18,91.86 249.6,91.43 249.6,90.04 249.11,89.54 249.09,89.54 249.08,89.54 248.69,89.54 248.51,89.35 248.51,87.31 248.76,87.06 249.27,87.06 v2(249.68,87.47)
  BOTTOM w0.102: UV18.A32 222.85,83.9 223.02,83.73 v2(223.02,83.32) ; v2(249.68,87.47) UV26.A11
FBC_D49: length 38.3
  IN1 w0.102: 224.65,84.27 224.14,83.77 222.22,83.77 222.16,83.7 221.16,83.7 v2(220.85,83.39) ; 249.62,89.42 249.28,89.08 v2(248.96,89.08)
  IN1 w0.117: 249.62,89.42 250.13,89.92 250.13,91.79 248.77,93.15 239.5,93.15 239.01,92.65 236.75,92.65 228.37,84.27 224.65,84.27
  BOTTOM w0.102: v2(220.85,83.39) 220.5,83.05 UV18.C31 ; UV26.A13 v2(248.96,89.08)
FBC_D50: length 41.4
  IN1 w0.102: v2(220.84,84.36) 220.84,84.01 220.94,83.91 222.07,83.91 222.14,83.97 222.3,83.97 223.85,83.97 224.73,84.84 225.43,84.84 ; v2(248.92,87.45) 249.3,87.83 249.3,88.32 249.89,88.91
  IN1 w0.117: 249.89,88.91 250.7,89.72 250.7,91.96 248.98,93.67 239.29,93.67 238.79,93.17 236.53,93.17 228.2,84.84 225.43,84.84
  BOTTOM w0.102: UV26.B11 248.91,87.45 v2(248.92,87.45) ; UV18.C32 220.44,83.96 v2(220.84,84.36)
FBC_D51: length 34.2
  IN1 w0.102: v2(248.92,89.92) 248.98,89.92 249.09,90.03 249.09,90.85 ; v2(222.38,83.38) 222.82,82.94 224.6,82.94 224.85,83.19 225.43,83.19
  IN1 w0.117: 249.09,90.85 249.08,90.86 249.08,91.21 248.96,91.32 245.66,91.32 245.41,91.56 245.07,91.56 244.4,90.9 243.85,90.9 243.57,91.18 243.08,91.18 242.4,90.5 236.09,90.5 228.79,83.19 225.43,83.19
  BOTTOM w0.102: UV18.B32 221.24,83.89 221.74,83.38 v2(222.38,83.38) ; v2(248.92,89.92) 248.92,89.84 UV26.B13
FBC_D52: length 31.5
  IN1 w0.098: 242.15,86.11 243.05,87.02 243.96,87.02
  IN1 w0.102: 242.15,86.11 236.08,86.11 ; v2(246.47,88.19) 246.11,87.83 245.17,87.83 244.36,87.02 243.96,87.02 ; v2(219.2,80.97) 219.64,81.41 221.77,81.41 221.98,81.62 224.73,81.62 224.74,81.62 224.9,81.62 225.05,81.48 225.43,81.48
  IN1 w0.117: 236.08,86.11 235.28,86.11 230.65,81.48 225.43,81.48
  BOTTOM w0.102: UV18.D29 219.63,81.4 v2(219.2,80.97) ; v2(246.47,88.19) UV26.E11
FBC_D53: length 33.8
  IN1 w0.102: v2(222.88,80.95) 224.37,80.95 224.97,80.35 225.43,80.35 ; v2(246.53,89.84) 246.92,89.45 247.48,89.45 247.7,89.23 247.7,87.28 247.36,86.94 246.38,86.94 246.06,87.26 245.17,87.26 244.86,86.94 244.86,86.05 244.21,85.4 243,85.4 242.94,85.45 236.68,85.45 236.14,84.91 235.92,84.91
  IN1 w0.117: 225.43,80.35 231.11,80.35 235.67,84.91 235.92,84.91
  BOTTOM w0.102: UV18.A29 222.49,80.95 v2(222.88,80.95) ; v2(246.53,89.84) UV26.E13
FBC_D54: length 30.6
  IN1 w0.102: v2(245.36,85.92) 244.63,85.19 242.92,85.19 242.76,85.04 236.87,85.04 235.92,84.08 ; v2(220.84,81.03) 220.84,80.86 221.17,80.53 224.16,80.53 224.85,79.83 225.43,79.83
  IN1 w0.117: 225.43,79.83 231.33,79.83 235.59,84.08 235.92,84.08
  BOTTOM w0.102: UV26.F11 244.86,87.37 244.86,86.24 245.18,85.92 v2(245.36,85.92) ; v2(220.84,81.03) 220.8,81.03 UV18.C29
FBC_D55: length 32.7
  IN1 w0.102: v2(221.55,80.97) 221.61,80.97 222.06,81.42 224.58,81.42 225.12,80.87 225.43,80.87 ; 235.92,85.43 236.14,85.43 236.36,85.66 243.03,85.66 243.08,85.6 244.09,85.6 244.65,86.17 244.65,87.02 245.09,87.46 245.26,87.46 246.1,87.46 246.41,87.77 246.7,87.77 246.94,88.01 246.94,88.53 v2(245.68,89.79)
  IN1 w0.117: 235.92,85.43 235.45,85.43 230.9,80.87 225.43,80.87
  BOTTOM w0.102: UV26.F13 245.32,89.44 v2(245.68,89.79) ; v2(221.55,80.97) 221.24,81.28 UV18.B29
FBC_D56: length 39.1
  IN1 w0.102: v2(222.7,74.63) 222.64,74.63 222.12,74.11 222.12,72.7 223.06,71.76 225.62,71.76 ; 249.89,81.57 v2(249.64,81.82)
  IN1 w0.117: 225.62,71.76 241.56,71.76 246.57,76.78 247.71,76.78 247.73,76.78 248.07,76.78 250.19,78.9 250.19,81.27 249.89,81.57
  BOTTOM w0.102: v2(249.64,81.82) 249.64,81.91 UV26.A4 ; v2(222.7,74.63) 222.7,74.68 222.35,75.03 221.77,75.03 221.44,74.7 UV18.B21
FBC_D57: length 34.2
  IN1 w0.102: 247.69,79.01 247.8,79.11 247.8,80.1 247.78,80.12 247.78,80.47 247.98,80.67 248.48,80.67 v2(248.92,80.24) ; v2(221.68,75.97) 221.68,75.95 222.44,75.19 223.46,75.19 224.46,74.19 225.49,74.19
  IN1 w0.117: 247.69,79.01 247.15,78.47 246.04,78.47 241.76,74.19 225.49,74.19
  BOTTOM w0.102: UV18.C23 220.47,76.4 220.8,76.73 221.37,76.73 221.57,76.54 221.57,76.08 v2(221.68,75.97) ; UV26.A2 v2(248.92,80.24)
FBC_D58: length 35.8
  IN1 w0.102: v2(248.91,82.62) 248.54,82.26 248.54,82 248.54,81.99 248.54,81.68 248.76,81.45 249.2,81.45 249.35,81.3 249.35,79.59 249.3,79.54 249.3,79.01 ; v2(222.63,73.67) 223.39,72.91 226,72.91 226.24,73.15
  IN1 w0.117: 249.3,79.01 249.3,78.93 247.68,77.31 247.66,77.3 246.35,77.3 242.2,73.15 226.24,73.15
  BOTTOM w0.102: v2(222.63,73.67) 222.37,73.93 222.37,74.04 222.04,74.37 UV18.A21 ; UV26.B4 v2(248.91,82.62)
FBC_D59: length 32.8
  IN1 w0.102: v2(248.16,80.27) 248.22,80.21 248.22,79.01 ; 226.01,73.67 226.01,73.67 224.41,73.67 v2(223.39,74.68)
  IN1 w0.117: 248.22,79.01 248.22,78.76 247.29,77.83 246.14,77.83 241.98,73.67 226.01,73.67
  BOTTOM w0.102: v2(248.16,80.27) UV26.B2 ; UV18.C21 220.55,74.7 220.98,75.13 221.43,75.13 221.53,75.23 222.44,75.23 222.48,75.19 222.51,75.19 222.57,75.13 222.95,75.13 v2(223.39,74.68)
FBC_D60: length 28.6
  IN1 w0.102: 241.88,79.01 242.9,80.02 242.9,81.24 243.08,81.42 244.24,81.42 244.5,81.68 244.5,82.01 244.73,82.24 245.38,82.24 v2(245.75,82.61) ; 225.43,77.18 224.71,77.18 224.27,77.62 v2(221.64,77.62)
  IN1 w0.117: 225.43,77.18 240.16,77.18 241.77,78.79 241.77,78.89 241.88,79.01
  BOTTOM w0.102: v2(221.64,77.62) 221.64,77.61 UV18.B24 ; UV26.E4 v2(245.75,82.61)
FBC_D61: length 29.9
  IN1 w0.102: v2(220.9,77.65) 221.33,77.22 224.22,77.22 224.79,76.66 225.43,76.66 ; 242.83,79.01 243.71,79.89 243.71,80.05 243.71,80.37 243.96,80.62 244.37,80.62 244.54,80.78 244.54,80.78 244.54,81.19 244.76,81.42 246.13,81.42 v2(246.51,81.03)
  IN1 w0.117: 242.83,79.01 240.48,76.66 225.43,76.66
  BOTTOM w0.102: UV18.C24 220.45,77.2 220.9,77.65 v2(220.9,77.65) ; v2(246.51,81.03) 246.12,80.65 UV26.E2
FBC_D62: length 28.3
  IN1 w0.102: 241.24,79.01 242.13,79.89 242.13,81.98 242.4,82.25 244.28,82.25 244.52,82.5 244.73,82.5 v2(244.89,82.65) ; 225.43,77.7 224.47,77.7 224.19,77.99 223.53,77.99 v2(222.64,78.88)
  IN1 w0.117: 225.43,77.7 239.94,77.7 241.24,79.01
  BOTTOM w0.102: UV26.F4 245.31,82.23 v2(244.89,82.65) ; UV18.B26 221.4,78.9 221.74,78.56 222.31,78.56 222.64,78.88 v2(222.64,78.88)
FBC_D63: length 29.9
  IN1 w0.102: 225.43,76.13 224.99,76.13 224.23,76.89 222.49,76.89 222.44,76.84 221.17,76.84 220.35,77.67 220.35,77.78 220.03,78.09 v2(220.03,79.32) ; 243.72,79.01 244.94,80.23 v2(244.94,80.23)
  IN1 w0.117: 225.43,76.13 240.85,76.13 243.72,79.01
  BOTTOM w0.102: UV26.F2 244.94,80.25 v2(244.94,80.23) ; v2(220.03,79.32) 220.44,78.91 UV18.C26
FBC_DBI0#: length 21.9
  IN6 w0.102: 237.88,66.88 238.12,66.64 238.12,66.24 238.52,65.85 v2(238.52,65.71) ; v2(219.24,65.98) 219.65,66.4 221.76,66.4 222.12,66.03
  IN6 w0.117: 222.12,66.03 223,66.03 223.29,66.33 236.06,66.33 236.62,66.89 237.87,66.89 237.88,66.88
  BOTTOM w0.102: v2(219.24,65.98) 218.84,66.38 UV18.E11 ; UV25.D2 v2(238.52,65.71)
FBC_DBI1#: length 23.4
  IN6 w0.102: v2(238.52,56.87) 238.13,56.48 238.13,55.97 237.87,55.72 235.92,55.72 ; v2(219.2,60.08) 219.2,59.48 221.39,57.29 221.81,57.29
  IN6 w0.117: 221.81,57.29 221.89,57.2 232.87,57.2 234.36,55.72 235.92,55.72
  BOTTOM w0.102: v2(238.52,56.87) 238.53,56.87 238.53,56.89 UV25.D13 ; v2(219.2,60.08) 218.81,59.7 UV18.E3
FBC_DBI2#: length 31
  IN1 w0.102: 247.21,54.81 247.32,54.92 v2(247.32,56.9)
  IN1 w0.117: v2(223.14,59) 223.14,57.96 224.88,56.22 231.04,56.22 232.84,54.43 237.99,54.43 237.99,54.43 240.07,54.43 240.32,54.17 246.57,54.17 247.21,54.81
  BOTTOM w0.102: UV25.P13 v2(247.32,56.9) ; v2(223.14,59) 222.74,59 UV18.A3
FBC_DBI3#: length 29.6
  IN1 w0.098: 242.14,64.52 243.73,66.11 245.11,66.11
  IN1 w0.102: v2(247.27,64.91) 246.06,66.11 245.11,66.11 ; 235.92,64.95 235.98,64.95 236.41,64.52 242.14,64.52
  IN1 w0.117: 235.92,64.95 224.42,64.95 224.04,65.33 223.98,65.33 v2(223.46,65.86)
  BOTTOM w0.102: UV18.C9 220.58,64.7 220.92,65.03 221.3,65.03 221.55,65.29 222.89,65.29 v2(223.46,65.86) ; v2(247.27,64.91) 246.92,65.26 UV25.P2
FBC_DBI4#: length 25.5
  IN6 w0.102: 237.22,79.01 238.14,79.92 238.14,80.65 v2(238.52,81.03) ; 223.34,75.1 222.27,75.1 221.86,75.5 217.89,75.5 v2(217.81,75.42)
  IN6 w0.117: 237.22,79.01 233.17,74.96 223.71,74.96 223.57,75.1 223.34,75.1
  BOTTOM w0.102: UV18.F23 217.99,75.6 v2(217.81,75.42) ; UV26.P2 v2(238.52,81.03)
FBC_DBI5#: length 28.4
  IN6 w0.102: 223.96,81.92 223.46,81.42 220.35,81.42 220.22,81.56 219.53,81.56 219.4,81.42 218.18,81.42 217.94,81.18 217.94,80.51 v2(217.59,80.16) ; 235.97,89.16 235.97,89.42 236.79,90.24 237.85,90.24 238.12,89.97 238.12,89.69 238.39,89.43 238.67,89.43 239.06,89.04 v2(239.32,89.04)
  IN6 w0.117: 223.96,81.92 224.25,82.21 229.05,82.21 235.97,89.13 235.97,89.16
  BOTTOM w0.102: UV26.P13 v2(239.32,89.04) ; UV18.F27 217.99,79.73 217.59,80.13 v2(217.59,80.16)
FBC_DBI6#: length 32
  IN1 w0.102: 235.92,88.84 236.49,89.42 243.97,89.42 244.77,90.22 245.9,90.22 246.13,89.99 246.13,89.7 246.76,89.07 v2(247.32,89.07) ; 225.43,82 225.21,82 225.13,81.92 221.54,81.92 v2(220.84,82.62)
  IN1 w0.117: 235.92,88.84 229.08,82 225.43,82
  BOTTOM w0.102: UV18.C30 220.44,82.22 v2(220.84,82.62)
  BOTTOM w0.13: v2(247.32,89.07) 246.96,89.44 UV26.D13
FBC_DBI7#: length 28.2
  IN1 w0.102: v2(223.93,76.46) 223.93,76.21 224.53,75.61 225.43,75.61 ; v2(246.55,80.27) 245.68,80.27 244.6,79.19 244.6,79.01
  IN1 w0.117: 225.43,75.61 241.7,75.61 244.6,78.51 244.6,79.01
  BOTTOM w0.102: UV18.A24 222.26,76.97 223.46,76.97 223.9,76.53 223.9,76.49 v2(223.93,76.46)
  BOTTOM w0.107: v2(246.55,80.27) 246.56,80.27 UV26.D2
FBC_EDC0: length 21.1
  IN6 w0.102: v2(238.52,64.91) 238.13,65.3 238.13,65.84 237.88,66.09 236.64,66.09 236.19,65.63 ; 222.12,65.48 220.54,65.48 v2(220.04,65.98)
  IN6 w0.117: 222.12,65.48 223.24,65.48 223.43,65.29 235.84,65.29 236.19,65.63
  BOTTOM w0.102: UV18.D10 219.64,65.58 v2(220.04,65.98) ; UV25.C2 v2(238.52,64.91)
FBC_EDC1: length 23.5
  IN6 w0.102: v2(237.72,56.9) 238.1,57.29 238.1,58.66 236.94,59.82 235.92,59.82
  IN6 w0.117: v2(223.84,61.6) 223.84,60.91 224.33,60.42 225.27,60.42 225.87,59.82 235.92,59.82
  BOTTOM w0.102: UV18.D5 220.05,61.81 220.56,61.81 220.91,62.16 220.91,62.34 221.1,62.53 222.45,62.53 222.93,62.05 223.39,62.05 v2(223.84,61.6) ; v2(237.72,56.9) 237.72,56.9 UV25.C13
FBC_EDC2: length 34
  IN1 w0.102: v2(248.1,56.98) 248.22,56.86 248.22,54.95 248.09,54.81
  IN1 w0.117: v2(220.82,59.29) 221.24,58.88 221.24,58.17 221.39,58.02 222.34,58.02 224.67,55.7 230.8,55.7 232.13,54.36 232.16,54.36 232.62,53.9 238.2,53.9 238.2,53.91 239.85,53.91 240.15,53.6 246.87,53.6 248.09,54.81
  BOTTOM w0.102: v2(248.1,56.98) 248.1,56.98 247.72,56.59 UV25.R13 ; v2(220.82,59.29) 220.82,59.31 UV18.C3
FBC_EDC3: length 29.5
  IN1 w0.102: 246.63,66.88 246.83,66.68 246.83,66.43 247.14,66.11 247.71,66.11 v2(248.12,65.71)
  IN1 w0.117: 246.63,66.88 246.44,67.07 242.96,67.07 242,66.12 228.16,66.12 227.52,65.48 224.66,65.48 v2(224.28,65.86)
  BOTTOM w0.102: v2(248.12,65.71) UV25.R2 ; UV18.B9 221.34,64.7 221.68,65.03 223.58,65.03 224.28,65.73 v2(224.28,65.86)
FBC_EDC4: length 23.7
  IN6 w0.102: v2(237.72,81.03) 237.3,80.62 237.3,79.83 237.2,79.73 ; 222.46,75.99 222.09,76.37 218.8,76.37 v2(218.45,76.02)
  IN6 w0.117: 222.46,75.99 223.67,75.99 224.18,75.48 232.95,75.48 237.2,79.73
  BOTTOM w0.102: UV18.E23 218.46,76.02 218.45,76.02 218.45,76.02 v2(218.45,76.02) ; UV26.R2 v2(237.72,81.03)
FBC_EDC5: length 27.1
  IN6 w0.102: v2(218.38,80.97) 218.82,80.53 219.3,80.53 219.58,80.81 219.58,81.13 219.81,81.35 220.12,81.35 220.35,81.13 220.35,80.6 220.63,80.32 221.54,80.32 221.95,80.73 222.56,80.73 222.72,80.57 223.04,80.57 224.16,81.69 224.47,81.69 ; 236.29,88.95 236.76,89.42 237.88,89.42 238.26,89.04 v2(238.52,89.04)
  IN6 w0.117: 236.29,88.95 236.29,88.45 229.53,81.69 224.47,81.69
  BOTTOM w0.102: UV26.R13 v2(238.52,89.04) ; v2(218.38,80.97) 218.41,80.97 UV18.E28
FBC_EDC6: length 32.6
  IN1 w0.102: 235.92,89.58 236.44,90.1 236.44,90.11 236.57,90.24 242.44,90.24 243.16,90.96 243.48,90.96 243.76,90.69 245.65,90.69 245.92,90.42 247.27,90.42 247.74,89.96 247.74,89.65 248.12,89.27 v2(248.12,89.04) ; 225.43,82.53 225.25,82.53 224.9,82.18 222,82.18 221.66,82.51 v2(221.66,82.62)
  IN1 w0.117: 235.92,89.58 228.86,82.53 225.43,82.53
  BOTTOM w0.102: UV18.B30 221.65,82.62 v2(221.66,82.62)
  BOTTOM w0.107: UV26.C13 v2(248.12,89.04)
FBC_EDC7: length 30.6
  IN1 w0.102: v2(222.75,76.51) 222.75,76.48 224.51,74.72 225.43,74.72 ; v2(248.14,81.05) 247.42,81.05 247.14,80.78 247.14,80.27 246.76,79.89 246.38,79.89 246.06,79.57 246.06,79.23 245.84,79.01
  IN1 w0.117: 245.84,79.01 241.55,74.72 225.43,74.72
  BOTTOM w0.102: v2(222.75,76.51) 222.63,76.4 UV18.A23
  BOTTOM w0.107: UV26.C2 v2(248.14,81.05)
FBC_MA0_MA10_H: length 30.1
  TOP w0.102: v2(242.52,81.83) 242.52,81.57 242.1,81.15 242.1,79.01 ; 226.7,73.56 225.44,73.56 224.54,72.65 224.09,72.65 222.58,71.14 220.2,71.14 v2(220.04,70.97)
  TOP w0.221: 226.7,73.56 v1(232.83,73.56) 235.22,73.56 235.51,73.85 237.87,73.85 242.1,78.07 242.1,79.01
  BOTTOM w0.102: UV18.D16 219.64,70.57 v2(220.04,70.97) ; UV26.K4 v2(242.52,81.83)
FBC_MA0_MA10_L: length 26.9
  BOTTOM w0.102: UV18.D15 219.99,69.34 224.76,69.34 224.99,69.57 ; 241.18,62.18 241.81,62.81 241.81,63.39 UV25.H4
  BOTTOM w0.221: 241.18,62.18 240.98,61.98 236.22,61.98 v1(228.63,69.57) 224.99,69.57
FBC_MA1_MA9_H: length 27.3
  TOP w0.102: 240.54,79.01 240.54,82.21 v2(241.87,83.54) ; v2(224.18,73.29) 225.9,75.01 226.7,75.01
  TOP w0.221: 240.54,79.01 240.54,78.77 238.09,76.32 235.69,76.32 234.38,75.01 226.7,75.01
  BOTTOM w0.102: v2(224.18,73.29) 222.9,72.02 222.22,72.02 UV18.A18
  BOTTOM w0.107: v2(241.87,83.54) 241.87,83.54 241.87,83.28 UV26.K5
FBC_MA1_MA9_L: length 24.4
  BOTTOM w0.102: UV25.H5 242.12,62.18 ; UV18.A14 223.02,68.9 223.08,68.84 224.99,68.84
  BOTTOM w0.221: 224.99,68.84 228.33,68.84 v1(229.77,67.4) 235.92,61.25 241.28,61.25 242.12,62.09 242.12,62.18
FBC_MA2_BA0_H: length 35.2
  TOP w0.102: v2(242.51,87.45) 242.51,87.52 242.1,87.93 242.1,88.39 241.86,88.63 235.92,88.63 ; 222.07,77.35 221.76,77.03 220.28,77.03 219.66,76.41 219.66,74.19 219.4,73.93 218.28,73.93 217.98,73.63 217.98,73.04 v2(217.56,72.62)
  TOP w0.221: 235.92,88.63 v1(235.18,88.63) 233.35,88.63 222.07,77.35
  BOTTOM w0.102: UV18.F18 v2(217.56,72.62) ; UV26.K11 v2(242.51,87.45)
FBC_MA2_BA0_L: length 32.8
  TOP w0.102: v2(217.61,69.28) 217.22,68.9 217.22,68.03 218.05,67.2 219.09,67.2 ; 235.92,57.33 242.14,57.33 v2(242.52,57.7)
  TOP w0.119: 222.57,64.54 221.5,65.61 220.67,65.61 220.43,65.86 220.43,66.48 219.7,67.2 219.09,67.2
  TOP w0.147: 224.23,64.54 222.57,64.54
  TOP w0.221: 235.92,57.33 235.77,57.33 229.27,63.83 v1(226.33,63.83) 225.66,63.83 224.95,64.54 224.23,64.54
  BOTTOM w0.102: UV25.H11 v2(242.52,57.7) ; UV18.F14 v2(217.61,69.28)
FBC_MA3_BA3_H: length 31.6
  TOP w0.102: v2(241.71,87.44) 241.3,87.85 235.92,87.85 ; 223.42,77.35 223.22,77.15 222.58,77.15 222.15,76.72 220.79,76.72 220.45,76.37 220.45,74.43 219.6,73.58 219.6,72.99 v2(219.24,72.62)
  TOP w0.221: 223.42,77.35 v1(232.01,85.94) 233.92,87.85 235.92,87.85
  BOTTOM w0.102: UV18.E18 218.84,72.22 v2(219.24,72.62) ; UV26.K10 v2(241.71,87.44)
FBC_MA3_BA3_L: length 28.2
  TOP w0.102: v2(219.29,68.47) 219.67,68.09 221.2,68.09 221.97,67.32 221.97,66.58 223.27,65.29 225.62,65.29
  TOP w0.221: v2(241.72,58.5) 240.62,59.6 236.15,59.6 230.47,65.29 225.62,65.29
  BOTTOM w0.102: UV18.E14 219.26,68.47 v2(219.29,68.47)
  BOTTOM w0.107: UV25.H10 v2(241.72,58.5)
FBC_MA4_BA2_H: length 28.3
  BOTTOM w0.102: UV26.H11 243.33,87.45 243.33,87.01 242.83,86.5 ; UV18.A20 222.04,73.72 222.47,73.29 222.82,73.29 223.84,74.31
  BOTTOM w0.221: 242.83,86.5 242.31,85.99 235.52,85.99 v1(226.38,76.85) 223.84,74.31
FBC_MA4_BA2_L: length 27.5
  TOP w0.102: 243.65,59.32 243.65,59 243.74,58.92 243.74,58.09 v2(244.1,57.73) ; 225.48,66.35 223.16,66.35 v2(222.55,66.97)
  TOP w0.221: 225.48,66.35 226.23,66.35 226.47,66.12 230.67,66.12 236.46,60.33 v1(242.81,60.33) 243.14,60.33 243.65,59.82 243.65,59.32
  BOTTOM w0.102: UV25.K11 244.09,57.73 v2(244.1,57.73) ; UV18.A12 222.32,67.2 v2(222.55,66.97)
FBC_MA5_BA1_H: length 28.3
  TOP w0.102: v2(221.64,74.3) 222.56,75.22 223.62,75.22 225.05,76.66 225.05,76.92
  TOP w0.147: v2(243.33,86.18) 243.12,85.98 236.39,85.98
  TOP w0.221: 225.05,76.92 234.11,85.98 v1(235.38,85.98) 236.39,85.98
  BOTTOM w0.102: UV26.H10 243.72,86.94 243.33,86.55 v2(243.33,86.18)
  BOTTOM w0.107: UV18.B20 v2(221.64,74.3)
FBC_MA5_BA1_L: length 26.3
  BOTTOM w0.102: UV18.B12 221.57,67.53 222.76,67.53 223.4,66.89 224.75,66.89 224.99,66.65 ; UV25.K10 243.41,59.22 236.39,59.22 236.24,59.06 235.98,59.06
  BOTTOM w0.221: 235.98,59.06 235.01,59.06 v1(228.33,65.74) 227.42,66.65 224.99,66.65
FBC_MA6_MA11_H: length 36.9
  TOP w0.102: v2(216.74,72.62) 217.49,71.87 221.18,71.87 222.44,73.14 222.77,73.14 223.25,73.62
  TOP w0.147: v2(244.12,82.63) 244.52,83.04 244.52,84.35 243.89,84.99 236.87,84.99 236.86,84.97 ; 223.25,73.62 224.5,74.87 224.5,74.96
  TOP w0.221: 236.86,84.97 v1(235.33,83.45) 228.38,76.49 226.03,76.49 224.5,74.96
  BOTTOM w0.102: UV26.H5 v2(244.12,82.63) ; v2(216.74,72.62) 217.14,72.22 UV18.G18
FBC_MA6_MA11_L: length 32.1
  TOP w0.102: 220.34,68.92 218.31,68.92 218.05,69.18 218.05,69.38 217.68,69.74 217.4,69.74 217.02,70.12 v2(216.74,70.12)
  TOP w0.221: 220.34,68.92 222.38,68.92 224.45,66.85 230.97,66.85 236.58,61.24 v1(240.02,61.24) 242.16,61.24 v2(243.35,62.43)
  BOTTOM w0.102: UV18.G15 217.14,69.72 v2(216.74,70.12) ; v2(243.35,62.43) 243.35,62.54 UV25.K5
FBC_MA7_MA8_H: length 29.9
  BOTTOM w0.102: UV18.B18 221.24,72.21 221.55,72.53 221.9,72.53 221.9,72.53 222.17,72.53 222.18,72.53 222.3,72.53 222.44,72.38 222.84,72.38 223.11,72.65 223.11,72.77 224.02,73.67 224.24,73.67 224.36,73.8 ; 242.92,84.31 243.41,83.82 243.41,82.55 UV26.H4
  BOTTOM w0.221: 224.36,73.8 224.39,73.83 224.92,73.83 v1(229.58,78.49) 236.16,85.07 242.15,85.07 242.92,84.31
FBC_MA7_MA8_L: length 28.6
  BOTTOM w0.102: 243.97,62.18 244.03,62.24 244.03,63.39 UV25.K4 ; 224.99,68.11 223.44,68.11 223.02,68.53 221.6,68.53 UV18.B14
  BOTTOM w0.221: 224.99,68.11 228.03,68.11 v1(231,65.14) 235.62,60.52 241.58,60.52 242.6,61.54 243.33,61.54 243.97,62.18
FBC_MA12_RFU_H: length 33.2
  TOP w0.102: v2(218.41,70.97) 218.88,71.45 222.39,71.45 223.86,72.91 224.33,72.91 225.71,74.28 226.7,74.28 ; 241.37,79.01 241.37,80.78 242.14,81.55 242.14,81.99 242.36,82.22 242.64,82.22 242.95,82.53 v2(242.95,83.64)
  TOP w0.221: 226.7,74.28 v1(229.22,74.28) 234.68,74.28 235.99,75.6 238.4,75.6 241.37,78.57 241.37,79.01
  BOTTOM w0.102: UV26.J5 242.92,83.6 v2(242.95,83.64) ; UV18.F17 v2(218.41,70.97)
FBC_MA12_RFU_L: length 29.7
  TOP w0.102: v2(218.43,69.34) 222.8,69.34 224.56,67.58 226.7,67.58
  TOP w0.221: 226.7,67.58 231.27,67.58 236.87,61.98 242.08,61.98 242.7,62.6 242.7,62.68 v2(243.32,63.3)
  BOTTOM w0.102: v2(218.43,69.34) 218.43,69.34 218.79,69.7 UV18.E15 ; UV25.J5 v2(243.32,63.3)
FBC_RAS#_H: length 30
  BOTTOM w0.102: 241.35,83.72 241.43,83.64 241.43,83.36 241.63,83.16 241.63,82.89 241.29,82.55 241.19,82.55 241.01,82.36 241.01,81.75 UV26.L3 ; UV18.D17 219.97,71.73 222.22,71.73 222.31,71.64 223.23,71.64 224.54,72.95 224.99,72.95
  BOTTOM w0.221: 224.99,72.95 225.39,72.95 v1(228.46,76.02) 236.5,84.06 241.01,84.06 241.35,83.72
FBC_RAS#_L: length 26.1
  TOP w0.102: 235.92,64.52 240.54,64.52 v2(240.92,64.91) ; 226.7,68.3 224.44,68.3 223.08,69.67 219.72,69.67 v2(219.27,70.12)
  TOP w0.221: 235.92,64.52 v1(235.17,65.27) 232.14,68.3 226.7,68.3
  BOTTOM w0.102: v2(219.27,70.12) 219.27,69.29 219.64,68.93 UV18.D14 ; UV25.G3 v2(240.92,64.91)
FBC_RST#_H: length 29
  TOP w0.102: v2(224.35,72.17) 224.76,72.59 225.07,72.59 ; 242.83,79.34 242.9,79.42 242.9,80.65 v2(242.52,81.03) 243.46,81.98 RV615.1
  TOP w0.221: 242.83,79.34 242.83,77.77 238.18,73.12 235.85,73.12 235.56,72.83 225.31,72.83 225.07,72.59
  BOTTOM w0.102: UV26.J2 v2(242.52,81.03) ; UV18.A17 223.57,71.4 v2(224.35,72.17)
FBC_RST#_L: length 26.2
  TOP w0.102: 236.32,65.69 236.69,65.32 242.14,65.32 v2(242.52,65.71) 242.52,65.04 242.13,64.65 242.13,63.78 RV616.1
  TOP w0.221: 236.32,65.69 232.98,69.03 224.87,69.03 223.79,70.11 v2(223.79,70.2)
  BOTTOM w0.102: UV25.J2 v2(242.52,65.71) ; UV18.A15 222.19,69.55 223.24,69.55 223.84,70.15 v2(223.79,70.2)
FBC_WCK0: length 24.8
  IN6 w0.097: v2(218.41,63.42) 218.67,63.42 218.77,63.52 218.77,63.78 218.98,63.98 219.47,63.98 220.97,62.48 221.05,62.41 222.15,62.41 222.15,62.4 222.2,62.4 222.2,62.4 222.22,62.4 222.4,62.22 224.05,62.22 225.16,61.1 237.61,61.1 238.79,62.28 238.79,63.04 v2(238.52,63.3)
  BOTTOM w0.102: UV25.D4 v2(238.52,63.3)
  BOTTOM w0.114: UV18.F8 217.99,63.84 v2(218.41,63.42)
FBC_WCK0_N: length 24.7
  IN6 w0.097: v2(239.32,63.3) 238.96,62.95 238.96,62.21 237.68,60.93 225.09,60.93 223.98,62.05 222.33,62.05 222.15,62.23 220.97,62.23 220.9,62.3 219.4,63.8 219.05,63.8 218.95,63.7 218.95,63.52 219.05,63.42 v2(219.22,63.42)
  BOTTOM w0.102: UV25.D5 v2(239.32,63.3)
  BOTTOM w0.114: UV18.E8 218.84,63.82 219.22,63.44 219.22,63.43 v2(219.22,63.42)
FBC_WCK1: length 30
  IN1 w0.097: v2(221.62,61.79) 221.85,61.79 222.01,61.96 222.01,62.17 222.21,62.37 222.68,62.37 222.7,62.35 233.46,62.35 235.16,60.65 245.78,60.65 246.7,61.57 246.7,62.78 246.98,63.06 247.19,63.06 247.29,63.17 v2(247.29,63.36)
  BOTTOM w0.102: v2(247.29,63.36) 247.17,63.36 246.92,63.62 UV25.P4 ; v2(221.62,61.79) 221.94,61.79 222.06,61.67 222.06,61.42 UV18.A5
FBC_WCK1_N: length 30.1
  IN1 w0.097: v2(247.36,62.5) 247.36,62.78 247.26,62.89 247.05,62.89 246.87,62.71 246.87,61.5 245.86,60.48 235.09,60.48 233.39,62.18 222.63,62.18 222.61,62.2 222.28,62.2 222.18,62.1 222.18,61.83 222.21,61.79 222.44,61.79 v2(222.6,61.64)
  BOTTOM w0.102: UV18.A6 v2(222.6,61.64) ; v2(247.36,62.5) 247.32,62.5 UV25.P5
FBC_WCK2: length 24.8
  IN6 w0.097: v2(219.27,77.62) 219.27,77.93 219.49,78.15 221.67,78.15 221.81,78.01 221.81,78.01 221.97,77.86 223.97,77.86 224.71,78.6 224.71,78.6 224.92,78.82 230.77,78.82 235.79,83.84 235.8,83.84 235.85,83.89 238.34,83.89 238.86,83.37 238.86,82.97 v2(238.52,82.63)
  BOTTOM w0.102: UV26.P4 v2(238.52,82.63)
  BOTTOM w0.114: v2(219.27,77.62) 219.64,77.26 UV18.D24
FBC_WCK2_N: length 24.8
  IN6 w0.097: v2(239.32,82.63) 239.03,82.92 239.03,83.44 238.41,84.07 235.77,84.07 230.7,78.99 224.85,78.99 223.89,78.03 222.08,78.03 221.89,78.22 221.89,78.22 221.79,78.32 219.39,78.32 v2(219.25,78.46)
  BOTTOM w0.102: UV26.P5 v2(239.32,82.63)
  BOTTOM w0.114: v2(219.25,78.46) 219.64,78.07 UV18.D25
FBC_WCK3: length 31
  IN1 w0.097: v2(246.55,82.6) 246.33,82.82 246.33,83.94 246.18,84.1 245.13,84.1 245.06,84.02 237.49,84.02 236.75,83.28 235.81,83.28 231.35,78.81 224.69,78.81 223.92,79.57 222.11,79.57 221.78,79.9 221.39,79.9 221.29,79.8 221.29,79.59 v2(221.62,79.26)
  BOTTOM w0.102: v2(221.62,79.26) 221.62,79.32 UV18.B27 ; v2(246.55,82.6) UV26.D4
FBC_WCK3_N: length 31
  IN1 w0.097: v2(220.04,80.08) 220.05,80.08 221.85,80.08 222.18,79.75 224,79.75 224.76,78.99 231.27,78.99 235.74,83.45 236.68,83.45 237.42,84.19 244.98,84.19 245.06,84.27 246.25,84.27 246.5,84.01 246.5,83.62 246.61,83.51 v2(246.76,83.51)
  BOTTOM w0.102: UV18.C27 220.05,80.08 v2(220.04,80.08) ; v2(246.76,83.51) 246.76,83.19 UV26.D5
FBC_WE#_H: length 32.6
  TOP w0.102: v2(220.83,72.59) 222.29,74.05 223.3,74.05 224.17,74.92 224.17,75.01 226.39,77.22
  TOP w0.147: 236.42,85.42 v1(242.55,85.42) 243.47,85.42 244.59,86.54 244.59,87.64 244.12,88.11 v2(244.12,88.24)
  TOP w0.221: 226.39,77.22 234.41,85.25 236.1,85.25 236.27,85.42 236.42,85.42
  BOTTOM w0.102: v2(220.83,72.59) UV18.C18 ; UV26.G12 v2(244.12,88.24)
FBC_WE#_L: length 30.6
  BOTTOM w0.102: 224.99,67.38 223.69,67.38 222.74,68.33 221.52,68.33 221.47,68.38 220.96,68.38 UV18.C14
  BOTTOM w0.221: 224.99,67.38 227.72,67.38 v1(232.38,62.73) 235.31,59.79 244.36,59.79 244.92,59.23 244.92,57.71 UV25.L12
FBVDD_EN: length 199.2
  TOP w0.14: v2(210.14,46.47) 209.34,45.67 DV13.1 208.55,45.67 RV550.1 ; v1(250.08,53.11) 250.78,53.81 v2(251.49,53.81) 251.97,54.29 QZ6.5
  TOP w0.254: PR706.1 194.88,120.09 194.63,120.34 185.58,120.34 v2(184.37,119.13)
  IN2 w0.099: v2(251.49,53.81) 252.01,53.29 252.01,50.44 254.61,47.83 254.61,40.81 253.37,39.57 244.82,39.57 242.27,42.12 234.43,42.12 233.36,43.19 231.94,43.19 231.35,43.78 228.12,43.78 227.97,43.63 221.68,43.63 221.04,44.27 218.89,44.27 218.59,43.96 216.2,43.96 215.92,44.25 213.29,44.25 212.8,44.74 211.87,44.74 v2(210.14,46.47)
  IN2 w0.203: v2(210.14,46.47) 210.01,46.61 210.01,49.95 208.07,51.89 205.87,51.89 205.6,52.16 205.6,53.02 198.72,59.9 198.72,61.15 198.5,61.37 197.88,61.99 197.23,61.99 196.28,62.94 196.28,63.38 195.89,63.78 195.07,63.78 189.34,69.51 189.34,72.81 187.89,74.25 184.84,74.25 184.41,74.68 184.41,80.63 180.93,84.12 180.93,85.68 180,86.6 179.3,86.6 178.94,86.24 177.23,86.24 176.4,85.42 176,85.42 175.11,86.31 171.71,86.31 170.69,87.32 170.69,90.44 169.89,91.25 166.07,91.25 164.9,92.41 164.9,98.63 166.67,100.4 166.67,103.32 166.04,103.95 166.04,105.86 166.96,106.77 166.96,110.15 168.2,111.4 168.2,112.6 169.79,114.19 169.79,115.3 170.65,116.16 171.88,116.16 173.83,118.11 174.84,118.11 175.35,118.62 175.77,118.62 176.12,118.97 182.28,118.97 182.63,118.63 183.87,118.63 v2(184.37,119.13)
FBVDDQ_SENSE: length 87.9
  TOP w0.14: PR730.1 194.07,118.04 194.66,117.45 195.26,117.45 195.28,117.47 195.64,117.47 195.69,117.42 v2(195.8,117.42)
  IN3 w0.091: v2(195.8,117.42) 195.67,117.29 195.67,117.24 195.56,117.14 195.56,111.03 196.15,110.44 198.82,110.44 203.16,106.1 203.16,87.98 203.01,87.83 203.01,86.05 204.55,84.51 204.55,83.72 205.41,82.86 205.41,82.53 205.18,82.29 204.9,82.29 204.89,82.27 204.85,82.27 204.61,82.04 204.61,82 204.58,81.97 204.58,81.59 204.09,81.1 203.2,81.1 202.65,80.55 202.34,80.55 202.1,80.31 202.1,79.09 202.57,78.62 203.65,78.62 203.96,78.3 214.31,78.3 214.82,77.8 214.82,71.64 214.6,71.41 214.6,70.02 214.82,69.8 214.82,69.41 214.6,69.19 214.6,65.51 213.77,64.68 213.77,59.17 214.82,58.11 216.6,58.11 v2(217.81,56.9)
  BOTTOM w0.102: UV18.F1 217.94,57.73 217.81,57.6 217.81,57.03
  BOTTOM w0.14: 217.81,57.03 v2(217.81,56.9)
FCCM_GT: length 43.4
  TOP w0.14: v1(112.61,102.14) 112.61,102.25 v2(112.94,102.58)
  TOP w0.203: v2(112.94,102.58) 112.94,103.33 113.7,104.09 PU1100.11
  IN1 w0.254: v2(104.59,80.46) 103.51,79.38 103.51,77.29 104.12,76.68 104.12,73.2 v2(103.7,72.78)
  IN4 w0.254: v2(112.94,102.58) 112.87,102.66 106.53,102.66 105.51,101.64 105.51,92.05 103.68,90.22 103.68,81.37 v2(104.59,80.46)
  BOTTOM w0.254: v2(104.59,80.46) 104.7,80.58 PU1300.2 ; PU1301.2 103.88,72.96 v2(103.7,72.78)
FCCM_SA: length 19.8
  TOP w0.203: PU1100.34 120.95,107.29 v2(121.06,107.39)
  IN4 w0.254: v2(121.06,107.39) 120.44,106.77 120.44,104.29 119.2,103.06 116.36,103.06 115.18,101.88 115.18,97.94 114.56,97.32 114.56,95.75 113.79,94.99 v2(112.76,94.99)
  BOTTOM w0.254: PU1302.7 112.81,94.95 v2(112.76,94.99)
FCCM_VCORE: length 53.1
  TOP w0.14: v2(138.49,113.28) 138.43,113.34 v1(137.68,113.34)
  TOP w0.203: v2(120.78,102.37) 120.65,102.24 119.64,102.24 119.4,102.48 PU1100.24
  IN2 w0.254: v2(156.44,118.15) 156.44,117.9 155.41,116.88 152.49,116.88 152.05,116.43 145.47,116.43 143.33,114.28 142.33,114.28 141.39,113.34 138.55,113.34 v2(138.49,113.28) 137.73,112.53 137.73,110.82 138.1,110.45 v2(138.1,108.47) 138.1,107.83 136.92,106.65 134.33,106.65 130.49,102.82 123.91,102.82 123.03,101.94 121.19,101.94 120.78,102.35 v2(120.78,102.37)
  BOTTOM w0.254: PU1202.2 156.66,117.93 v2(156.44,118.15) ; v2(138.1,108.47) 138.1,108.9 138.49,109.28 PU1200.2 ; PU1201.2 138.51,114.9 138.2,114.59 138.2,114.38 138.15,114.33 138.15,113.63 v2(138.49,113.28)
FFS_INT1: length 234.9
  TOP w0.14: v2(237.73,45.02) 237.43,45.32 RF4.2 237.39,45.76 UF1.11 ; v2(263.78,11.18) 264.48,11.88 v3(264.48,12.2) 264.61,12.33 264.61,13.03 265.3,13.72 265.3,18.02 263.59,19.73 263.59,20.73 262.48,21.84 262.48,22.96 260.65,24.79 260.65,28.01 260.2,28.46 260.2,31.09 250.43,40.86 242.42,40.86 v2(241.85,41.44)
  IN5 w0.089: v2(92.08,7.4) 92.05,7.4 91.56,7.89 91.56,9.4 92.14,9.98 94.43,9.98 95.58,11.13 97.54,11.13 97.9,10.77 101.4,10.77 101.98,11.36
  IN5 w0.099: v2(263.78,11.18) 263.52,10.92 250.39,10.92 250.29,10.82 220.57,10.82 219.32,12.07 211.04,12.07 210.11,11.15 203.06,11.15 201.46,12.75 185.79,12.75 184.3,11.25 176.18,11.25 176.02,11.1 164.05,11.1 163.15,10.19 154.86,10.19 153.57,8.9 150.85,8.9 149.39,10.36 147.81,10.36 147.24,10.93 123.05,10.93 122.6,10.49 116.27,10.49 115.3,11.46 114.62,11.46 114.09,10.92 108.22,10.92 107.62,11.53 105.83,11.53 105.64,11.71 102.34,11.71 101.98,11.36
  BOTTOM w0.089: UH2.AW17 91.47,6.8 v2(92.08,7.4)
  BOTTOM w0.14: v2(237.73,45.02) 238.29,44.46 238.82,44.46 v2(241.85,41.44)
FFS_INT2: length 195.1
  TOP w0.14: RF5.2 240.26,42.57 v3(240.26,42.15) 240.26,41.79 239.9,41.43 v2(239.54,41.43) ; QF1.2 234.47,43.06 236.68,45.27 v2(236.68,45.55) 236.39,45.84 UF1.9
  IN5 w0.089: 101.98,12.87 101.87,12.87 100.84,11.84 99.31,11.84 98.94,12.21 91.98,12.21 91.1,11.32 84.9,11.32 83.82,10.25 82.59,10.25 82.4,10.06 80.42,10.06 v2(80.07,10.41)
  IN5 w0.099: v2(183.83,23.06) 183.77,23 183.77,21.81 183.11,21.15 182.63,21.15 181.53,20.05 181.53,18.95 175.48,12.9 161.24,12.9 160.96,12.63 149.5,12.63 149.15,12.28 145.83,12.28 145.65,12.46 123.16,12.46 122.27,11.58 116.6,11.58 115.72,12.46 114.2,12.46 113.67,11.93 108.66,11.93 108.02,12.56 106.26,12.56 105.95,12.87 101.98,12.87
  IN6 w0.099: v2(183.83,23.06) 183.83,24.46 184.65,25.28 184.65,32.09 193.65,41.09 239.21,41.09 v2(239.54,41.43)
  BOTTOM w0.089: v2(80.07,10.41) 79.76,10.1 UH2.AN41
  BOTTOM w0.14: v2(239.54,41.43) 239.54,41.95 236.68,44.81 v2(236.68,45.55)
