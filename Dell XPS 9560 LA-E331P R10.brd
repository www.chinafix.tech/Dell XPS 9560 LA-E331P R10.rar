# Allegro board Dell XPS 9560 LA-E331P R10.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N09131: length 3.3
  BOTTOM w0.14: CA29.1 2.8,36.92 2.83,36.95 CA28.1 3.24,37.6 v1(3.68,38.04) 3.86,38.22 4.49,38.22 4.59,38.12 UA1.21
N09183: length 5
  BOTTOM w0.203: CA30.1 13.97,43.47 v1(13.84,43.33) 13.67,43.33 12.85,42.51 12.85,41.85 12.98,41.73 12.98,40.91 12.6,40.52 UA1.44
N09195: length 1.6
  BOTTOM w0.14: CA31.1 11.47,42.97 10.84,42.33 UA1.41
N09225: length 3.2
  BOTTOM w0.203: CA15.2 2.96,40.42 4.29,40.42 4.59,40.12 UA1.26
N09237: length 3.6
  BOTTOM w0.203: UA1.28 4.7,40.92 4.47,41.16 4.47,41.39 4.13,41.73 4.13,41.73 4.09,41.77 2.96,41.77 CA18.2
N09395: length 1.2
  BOTTOM w0.14: v1(16.08,40.01) 15.49,39.42 LA3.1
N09461: length 2.9
  TOP w0.14: v1(10.17,35.2) 11.63,35.2 12.34,35.91 LA1.1
  vias: v2(13.34,37.73)
N16357: length 3.8
  BOTTOM w0.203: UA1.29 6.04,42.16 5.83,42.36 5.55,42.36 5.26,42.07 3.06,42.07 CA20.1
N16361: length 3.8
  BOTTOM w0.14: v1(5.97,44.69) 5.59,44.31 CA21.1
  BOTTOM w0.152: CA21.1 6.11,43.38 6.62,42.86 6.62,42.5 6.84,42.28 UA1.31
N16389: length 1.5
  BOTTOM w0.203: UA1.25 4.56,39.72 4.37,39.91 3.85,39.91 CA15.1
N16393: length 1.6
  BOTTOM w0.203: CA18.1 4.07,41.09 4.63,40.52 UA1.27
N35186: length 1.5
  TOP w0.14: DA14.1 12.27,43.27 RA29.1
N35194: length 1.3
  TOP w0.14: RA28.1 13.91,44.6 DA7.1
N48197: length 3.6
  TOP w0.203: PC1103.2 v2(112.71,109.04) v1(113.08,108.68) 113.25,108.5 113.25,108.17 113.74,107.69 PU1100.2
  BOTTOM w0.254: PR1104.2 v2(112.71,109.04)
N48329: length 3.3
  TOP w0.203: PU1100.4 113.16,106.89 v2(113.03,107.02) 112.92,107.13 PC1104.2
  BOTTOM w0.254: PR1111.2 112.92,107.13 v2(113.03,107.02)
N48371: length 4.9
  BOTTOM w0.14: PC1105.2 109.64,106.24 109.06,105.67 v3(106.82,105.67)
  BOTTOM w0.254: PC1105.2 110.08,106.64 110.55,106.64 111.05,107.13 PR1111.1
N48789: length 3.7
  TOP w0.203: PR1129.1 PC1114.1 121.9,104.58 v1(121.64,104.58) 121.52,104.58 121.31,104.79 120.75,104.79 120.66,104.89 PU1100.28
N48933: length 2.8
  BOTTOM w0.14: PC1117.1 v1(121.53,103.31)
  BOTTOM w0.254: PC1117.1 122.56,104.38 PR1126.2
N48941: length 4.7
  TOP w0.203: PC1115.1 122.04,105.66 122.04,105.47 v2(121.67,105.1) 120.88,105.1 120.74,105.24 120.72,105.24 120.67,105.29 PU1100.29
  BOTTOM w0.14: v1(120.89,105.09) 120.91,105.1 v2(121.67,105.1)
  BOTTOM w0.254: PR1126.1 121.86,105.29 v2(121.67,105.1)
N48965: length 3.3
  TOP w0.14: PC1116.1 125.34,106.63 126.52,106.63 v1(126.91,107.02)
  TOP w0.254: PC1116.1 PR1124.2
N48979: length 8.7
  TOP w0.203: PR1124.1 v2(122.43,107.13) 121.98,106.69 121.98,106.04 121.55,105.61 120.78,105.61 120.7,105.69 PU1100.30
  BOTTOM w0.254: PR1125.1 125.1,106.08 124,107.17 v1(123.04,107.17) 122.47,107.17 v2(122.43,107.13) 122.43,106.37 PR1128.1
N49205: length 3.4
  TOP w0.203: PU1100.8 113.18,105.29 v2(112.78,104.89)
  BOTTOM w0.254: PC1113.2 PR1130.2 112.38,105.29 v2(112.78,104.89)
N49217: length 3
  BOTTOM w0.14: PR1127.2 109.49,105.13 v1(108.55,105.13)
  BOTTOM w0.254: PR1127.2 110.15,105.79 110.67,105.79 PC1113.1
N49289: length 5.4
  TOP w0.203: v2(112.78,108.09) PR1105.2 112.55,107.58 113.17,107.58 113.46,107.29 PU1100.3
  BOTTOM w0.14: v2(112.78,108.09) v3(114.2,108.09)
  BOTTOM w0.254: PR1105.2 v2(112.78,108.09)
N49471: length 2.7
  TOP w0.14: v1(126.19,109.8) 126.18,109.81 PR1117.2
  TOP w0.254: PC1108.1 124.83,109.8 PR1117.2
N49551: length 4.9
  TOP w0.203: PU1100.33 121.28,106.89 121.53,107.14 v1(121.53,107.61) 121.37,107.77 121.37,108.24 122.05,108.91 PR1115.1 PC1108.2
N49667: length 2.9
  TOP w0.14: PU1100.46 115.8,109.64 v2(115.67,109.76)
  BOTTOM w0.14: PR1103.2 115.89,109.55 v2(115.67,109.76) 114.81,109.76 v1(114.73,109.69)
N49815: length 7.1
  TOP w0.14: PR1116.1 123.8,110.32 124.69,110.32 v1(125.3,110.93)
  TOP w0.203: PU1100.36 120.57,108.09 120.7,108.21 120.7,108.99 122.21,110.5 122.99,110.5 PR1116.1
N50153: length 3.7
  TOP w0.203: PC1101.1 v2(117.54,110.56) 117.4,110.42 PU1100.42
  BOTTOM w0.14: v2(117.54,110.56) v1(118.05,110.05)
  BOTTOM w0.254: PR1101.2 v2(117.54,110.56)
N50385: length 5.4
  TOP w0.14: v1(111.61,100.17) 111.9,100.47 PR1137.1
  TOP w0.203: PU1100.14 115.4,102.26 113.86,100.72 PC1129.1 PR1137.1
N50425: length 44.6
  TOP w0.14: v2(144.1,102.05) v3(144.1,101.42)
  TOP w0.254: PR1144.1 114.58,99.39 PR1138.2 v2(114.58,98.03)
  IN3 w0.254: v2(144.1,102.05) 144.1,96.57 143.68,96.15 133.83,96.15 132.98,95.3 130.79,95.3 130.38,94.89 129.45,94.89 126.83,97.51 125.04,97.51 124.37,96.84 123.27,96.84 121.94,98.17 120.49,98.17 120.17,98.5 120.17,99.02 119.76,99.42 115.98,99.42 v2(114.58,98.03)
  BOTTOM w0.254: PH1104.2 145.47,101.14 144.55,102.05 v2(144.1,102.05)
N50433: length 2.8
  TOP w0.203: PU1100.15 115.8,102.1 v1(115.15,101.45) 114.75,101.05 PR1144.2
N50477: length 3.1
  TOP w0.203: PR1110.1 119.7,110.89 119.3,110.5 118.97,110.5 v1(118.49,110.02) 118.2,109.72 PU1100.40
N50505: length 5.7
  TOP w0.14: v1(121.07,113.2) 121.07,111.68 PR1109.1
  TOP w0.203: PR1109.1 120.59,110.82 119.95,110.18 119.27,110.18 118.6,109.51 PU1100.39
N50517: length 3.9
  TOP w0.203: PU1100.38 119,108.91 119,109.36 119.48,109.84 120.35,109.84 v1(120.59,110.09) 121.55,111.04 PR1108.1
N50567: length 5.6
  TOP w0.14: PR1107.1 122.54,111.2 v1(123.45,112.1)
  TOP w0.203: PR1107.1 120.73,109.48 119.6,109.48 119.4,109.29 PU1100.37
N50631: length 2.1
  BOTTOM w0.14: v1(114.47,99.6) 114.52,99.55 PR1141.2
  BOTTOM w0.254: PR1141.2 115.7,98.78 PC1134.2
N50639: length 4
  TOP w0.203: PC1131.1 v2(115.7,101.1) 115.7,101.55 116.2,102.05 PU1100.16
  BOTTOM w0.14: v2(115.7,101.1) v1(115.7,101.84)
  BOTTOM w0.254: PC1131.1 v2(115.7,101.1)
N50651: length 2.5
  TOP w0.14: PC1132.1 115.85,97.95 115.85,97.65 v1(115.63,97.43)
  TOP w0.254: PR1139.2 PC1132.1
N50739: length 4
  TOP w0.203: PU1100.17 116.6,101.77 v1(116.48,101.66) 116.48,101.14 v2(116.52,101.1) 116.59,101.04 PR1139.1
  BOTTOM w0.254: v2(116.52,101.1) 116.59,101.04 PR1139.1 117.46,100.47 PR1140.1
N51003: length 3.8
  TOP w0.203: PU1100.20 117.8,101.96 117.92,101.84 v1(117.92,101.67) 117.92,101.29 v2(117.8,101.16)
  BOTTOM w0.254: PC1128.1 PR1133.1 118.37,100.47 117.8,101.03 v2(117.8,101.16)
N51011: length 4.9
  TOP w0.14: v1(117.48,96.45) 117.6,96.58 v2(118.19,96.58)
  IN2 w0.254: v2(118.19,96.58) 118.19,97.68 v2(119.44,98.94)
  BOTTOM w0.254: PR1135.1 118.11,96.66 v2(118.19,96.58) ; PC1128.2 v2(119.44,98.94)
N57527: length 38.7
  TOP w0.14: v3(157.67,106.73) 157.93,106.47 v2(157.93,105.99)
  IN1 w0.254: v2(129.77,96.21) 130.27,96.71 144.97,96.71 148.36,100.1 156.29,100.1 157.43,101.24 157.43,105.5 v2(157.93,105.99)
  BOTTOM w0.254: PR1209.1 128.25,97.74 PR1210.1 129.77,96.21 v2(129.77,96.21) ; v2(157.93,105.99) 158.18,106.24 PR1222.2
N3514407: length 3
  TOP w0.203: PU400.5 346.29,21.1 346.51,21.32 346.51,22.09 v1(346.97,22.55) PR405.2
N3514423: length 4.9
  TOP w0.203: PU400.3 346.6,20.3 346.85,20.56
  TOP w0.254: v2(347.31,21.61) 347.31,21.51 347.9,20.91 PC400.1 347.6,20.56 346.85,20.56
  BOTTOM w0.14: v1(347.65,20.94) 347.31,21.28 v2(347.31,21.61)
  BOTTOM w0.254: PR400.2 347.68,21.98 v2(347.31,21.61)
N3514453: length 4.5
  TOP w0.14: PC419.1 339.62,18.64 v1(339.18,18.64)
  TOP w0.203: PU400.13 342.18,20.3 342.04,20.44 341.43,20.44 PC419.1
N13272409: length 4.7
  TOP w0.14: v2(109.41,63.83) v3(110.1,63.14)
  TOP w0.254: PC800.1 109.03,64.21 v2(109.41,63.83)
  BOTTOM w0.254: PR800.1 PC800.1 109.03,64.14 109.35,63.83 v2(109.41,63.83) PU800.1
N13272413: length 6.3
  TOP w0.14: v3(104.43,63.36) 104.43,63.65 PR806.1
  TOP w0.254: v2(107.67,63.84) 106.85,63.84 PC807.2 PR806.1
  BOTTOM w0.254: PU800.4 108.06,63.3 107.67,63.69 v2(107.67,63.84) 107.67,63.97 PR804.1
N13272497: length 3.3
  BOTTOM w0.254: PC813.1 105.49,63.62 v1(106.31,63.62) 107.01,63.62 107.61,63.02 PU800.5
N13272521: length 1.3
  TOP w0.14: PC805.1 v1(108.4,62.32)
N13347359: length 6
  TOP w0.14: PR1119.2 112.91,111.17 112.47,111.61 112.47,113.06 v1(112.52,113.12)
  TOP w0.203: PU1100.47 115.4,109.36 113.92,110.84 PR1114.2 PR1119.2
N13351923: length 5.2
  TOP w0.203: v2(119.06,111.77) 118.62,111.32 PC1102.1 118.62,110.82 117.8,110 PU1100.41
  BOTTOM w0.14: v2(119.06,111.77) 119.23,111.77 v1(119.64,111.36)
  BOTTOM w0.254: PR1102.2 118.85,111.17 119.06,111.39 v2(119.06,111.77)
N13352071: length 5.4
  TOP w0.14: 112.02,111.17 PR1118.2 111.46,111.17 v1(110.96,111.67)
  TOP w0.203: PU1100.48 115,109.27 113.6,110.66 112.52,110.66 112.02,111.17
N13353452: length 12.5
  TOP w0.14: v3(105.8,107.97) 105.8,107.16 108.04,104.92 109.51,104.92 109.73,105.14 PR1113.2
  TOP w0.203: PR1112.2 110.33,106.24 110.64,106.56 112.8,106.56 112.88,106.49 PU1100.5
  TOP w0.254: PR1113.2 109.74,105.39 PR1112.2 109.55,106.43 PR1143.1
N17034077: length 2.9
  TOP w0.203: PR406.1 347.38,18.04 v1(347.06,18.36) 346.48,18.94 346.48,19.31 346.29,19.5 PU400.1
N17034092: length 1.1
  TOP w0.14: PR415.1 340.58,22.46 v1(340.16,22.88)
N19473413: length 4.5
  TOP w0.14: v1(177.94,15.78) 178.27,16.11 PR1804.1
  TOP w0.254: PU1800.4 180.53,14.53 PR1803.2 179.83,16.09 PC1802.2 178.96,16.1 PR1804.1
N19473637:
  vias: v1(182.47,15.79)
N19912586:
  vias: v1(176.96,104.57) v2(176.66,104.97) v2(177.29,104.97)
N22956922: length 2.2
  BOTTOM w0.254: v2(195.81,80.99) 195.96,80.99 196.24,80.72 UV18.AM28 196.09,80.41 195.58,80.41 UV18.AN28 195.44,80.6 v2(195.08,80.96)
  vias: v1(200.65,80.16) v2(199.94,78.47) v2(200.77,77.62) v2(201.01,77.06) v2(201.03,70.4) v2(201.03,69.77) v2(200.98,68.53) v2(201.65,77.06) v2(201.59,73.51) v2(201.59,72.17) v2(201.74,69.6)
N26813293: length 17.6
  TOP w0.14: v2(225.43,48.4) 225.43,48.4 RV639.2 RV640.2 ; RV641.2 RV1080.2 RV1081.2 233.72,52.22 v1(233.85,52.09) 233.99,51.95 233.99,51.16 233.52,50.69 233.52,47.93 v2(233.53,47.91)
  IN6 w0.099: v2(233.53,47.91) 233.2,47.58 228.98,47.58 228.52,48.05 225.77,48.05 v2(225.43,48.4)
N35924928: length 3.3
  TOP w0.102: RV600.2 214.97,82.55 215.35,82.17 215.35,82.04 215.36,82.03 v1(215.36,81.56) 215.36,80.67 v2(215.84,80.2)
  BOTTOM w0.102: UV18.J27 215.44,79.8 v2(215.84,80.2)
N35928308: length 6.4
  TOP w0.102: v2(216.74,80.2) 216.23,80.71 216.23,82.67 215.95,82.94 v1(215.88,82.94) 215.75,82.94 215.41,83.28 215.41,83.85 215.31,83.96 214.77,83.96 214.67,84.06 RV601.2
  BOTTOM w0.102: UV18.H27 216.34,79.8 v2(216.74,80.2)
N35950826: length 5.1
  TOP w0.102: RV602.2 218.89,75.67 218.89,76.32 v1(218.8,76.41) 217.96,77.24 217.3,77.24 217.16,77.38 217.16,78.08 v2(216.76,78.48)
  BOTTOM w0.102: v2(216.76,78.48) 216.34,78.05 UV18.H25
N48708347: length 1.8
  BOTTOM w0.14: v1(283.48,25.75) 283.15,26.08 PC600.2
N48708367: length 5
  TOP w0.14: v2(291.09,30.23) v3(289.84,30.23)
  TOP w0.254: PR610.1 v2(291.09,30.23)
  BOTTOM w0.203: PR608.2 PR610.1 v2(291.09,30.23) 290.89,30.04 PU600.7
N48708425: length 3.5
  BOTTOM w0.203: PR605.2 291.44,27.19 291.02,27.61 291.02,28.52 v1(290.91,28.63) 290.91,28.71 290.38,29.24 PU600.9
N49570867: length 4.7
  TOP w0.14: v1(132.08,4.33) 131.36,4.33 131.03,4 v2(131.03,4)
  TOP w0.254: v2(131.03,4) 130.68,3.66 PR501.1 PC500.1
  BOTTOM w0.254: PU500.1 131.53,4.32 131.21,4 v2(131.03,4) 131.03,4 PR500.1
N49570895: length 6
  TOP w0.14: PR508.1 136.59,3.06 v3(136.95,2.7)
  TOP w0.254: PR508.1 134.77,3.06 PR504.2 134.34,3.07 v2(133.92,3.49)
  BOTTOM w0.254: PC507.2 134.44,3.49 v2(133.92,3.49) 133.53,3.49 132.88,4.14 PU500.4
N49571010: length 4.3
  BOTTOM w0.14: PC512.1 136.04,3.79 v3(136.04,2.85)
  BOTTOM w0.203: PU500.5 133.33,4.24 133.61,3.96 135.4,3.96 PC512.1
N49571039:
  vias: v1(132.78,6.1)
N50817763: length 5.2
  TOP w0.203: PC333.2 56.08,21.04 55.97,21.04 55.51,20.58 55.51,19.96 PU300.17
  TOP w0.254: v2(56.26,21.92) PC333.2
  BOTTOM w0.14: PC333.2 55.17,21.22 v1(54.95,21)
  BOTTOM w0.254: v2(56.26,21.92) PC333.2
N50817876: length 4.3
  TOP w0.203: PU300.5 55.51,14.39
  TOP w0.254: PR316.1 55.19,12.71 55.19,13.32 v2(55.23,13.36) 55.23,14.1 55.51,14.39
  BOTTOM w0.254: v2(55.23,13.36) 54.9,13.03 PR311.2 PR312.2
N50817886: length 4.7
  TOP w0.14: v1(58.23,13.64) 57.79,13.19 PC327.1
  TOP w0.203: PU300.7 56.31,14.61
  TOP w0.254: 56.31,14.61 56.66,14.26 56.66,12.91 PR314.2 56.92,12.65 57.72,12.65 PC327.1
N50817889: length 4.9
  TOP w0.127: PR317.2 59.36,14.27 v1(59.87,13.76)
  TOP w0.203: PU300.8 57.51,15.91 58.31,15.11 v2(58.56,15.11)
  TOP w0.254: v2(58.56,15.11) 58.56,15.05 58.87,14.74 PR317.2
  BOTTOM w0.254: v2(58.56,15.11) 58.32,15.11 PC328.1
N50817917: length 2.4
  TOP w0.203: PR315.2 59.24,16.41 v1(58.31,16.41) 57.97,16.41 57.67,16.71 PU300.10
N50817928: length 6.9
  TOP w0.14: v1(50.61,12.2) 50.8,12.01 PR302.2
  TOP w0.203: PU300.1 53.91,14.69
  TOP w0.254: PR302.2 51.69,12.2 52.17,12.68 PC313.2 52.43,13.15 52.43,13.55 v2(52.55,13.67) 52.55,13.95 53.04,14.44 53.66,14.44 53.91,14.69
  BOTTOM w0.254: PC314.1 52.87,14.54 52.55,14.22 v2(52.55,13.67)
N50817929: length 4.3
  TOP w0.203: 56.34,20 55.91,19.57 PU300.16
  TOP w0.254: 56.34,20 56.61,20.27 v2(56.64,20.27) 57.27,20.27 v1(57.49,20.49) 57.49,21.36 PR321.2
  BOTTOM w0.254: PR323.1 56.83,20.07 v2(56.64,20.27)
N50817930: length 6
  TOP w0.203: PU300.2 54.31,14.52
  TOP w0.254: 54.31,14.52 53.73,13.94 53.26,13.94 v2(53.15,13.83) 53.15,12.96 PC313.1 52.57,12.38 PR301.2
  BOTTOM w0.254: v2(53.15,13.83) 53.39,13.59 v1(53.62,13.59) 54.34,13.59 PC311.2
N50817943: length 26.4
  TOP w0.203: 54.31,19.74 PU300.20
  TOP w0.254: PC330.2 53.28,21.54 v2(53.39,21.47) PC331.1 53.39,20.66 54.31,19.74
  IN1 w0.254: v2(36.39,21.54) 36.39,21.66 37.09,22.36 40.12,22.36 40.76,21.72 48.31,21.72 48.58,21.98 52.88,21.98 v2(53.39,21.47)
  BOTTOM w0.254: PR310.2 37.06,24.9 36.7,24.55 36.7,21.92 36.39,21.6 v2(36.39,21.54)
N50817947: length 25.4
  TOP w0.14: v2(36.13,22.11) v1(36.13,22.88)
  TOP w0.203: PU300.19 54.71,20.02
  TOP w0.254: 54.71,20.02 54.31,20.43 PC331.2 54.06,21.01 v2(54.06,21.48) 54.06,21.99 PC332.1
  IN1 w0.254: v2(36.13,22.11) 36.87,22.84 40.14,22.84 40.91,22.07 48.17,22.07 48.43,22.34 53.21,22.34 v2(54.06,21.48)
  BOTTOM w0.254: v2(36.13,22.11) 35.74,22.5 PR310.3
N50817961: length 4.6
  TOP w0.203: PU300.15 56.31,19.48 56.45,19.62
  TOP w0.254: 56.45,19.62 58.41,19.62 v1(58.56,19.77) 58.56,21.18 PR322.2
N50817990: length 2.1
  TOP w0.203: 55.11,19.9 PU300.18
  TOP w0.254: 55.11,19.9 55.11,20.47 55.11,20.47 55.11,21.14 PR319.1
N52699143:
  vias: v3(31.88,2.42)
N52997531: length 3
  TOP w0.14: PR102.2 v1(16.78,74.85)
  TOP w0.254: PR102.2 PL104.1 PD100.1
N52999986: length 61.8
  TOP w0.254: PR100.1 43.75,33.68 43.44,33.98 PQ100.1 42.62,33.98 v2(41.87,33.23) 41.77,33.33 41.77,33.64 40.96,34.45 PR103.1 ; v2(25.78,74.94) v3(24.19,74.94) 24.07,75.07 20.03,75.07 19.33,75.76 PL104.2
  IN5 w0.099: v2(25.78,74.94) 26.22,74.5 26.22,68.85 28.29,66.78 28.29,57.68 29.33,56.64 29.33,52.67 33.1,48.9 33.1,47.35 33.52,46.93 33.52,46.37 34.11,45.77 34.11,44.53 35.67,42.97 35.67,40.71 38.73,37.65 38.73,36.38 v2(41.87,33.23)
N55155823: length 5.6
  BOTTOM w0.14: v3(48.39,19.38) 48.59,19.58 RV119.2 48.59,21.61 CV168.2 48.9,21.92 RV120.1 49.58,22.25 49.33,22.5 49.33,22.93 49.6,23.2 QV11.3
N55155843: length 3.7
  BOTTOM w0.14: QV12.1 50.69,22.11 RV120.2 50.5,21.26 v1(49.76,20.52)
N80922351: length 1.7
  BOTTOM w0.14: 249.51,110.45 249.51,109.17 v1(249.82,108.85)
  vias: v2(246.83,110.05) v2(247.46,110.05)
N80922387: length 1
  BOTTOM w0.14: PC1407.1 v1(249.85,106.05)
N100297089: length 2.4
  BOTTOM w0.254: PU1400.2 245.67,107.55 244.97,108.26 v1(244.92,108.26) 244.92,109.11 PR1400.2
N101473498: length 21.1
  IN1 w0.508: v2(234.41,109.98) 234.05,109.98 233.62,109.55 233.62,108.53 233.24,108.15 233.24,106.38 233.5,106.12 233.5,99.39 v2(234.2,98.69)
  BOTTOM w0.14: TV3.1 230.06,111.26 233.93,111.26 UV23.U10 v2(234.41,109.98)
  BOTTOM w0.254: UV23.A10 234.3,98.09 234.3,98.59 v2(234.2,98.69)
N101473516: length 6.9
  TOP w0.508: RV617.1 224.95,106.49 v2(223.86,105.4)
  IN5 w0.508: v2(223.86,105.4) 226.19,105.4 v2(227.21,104.38)
  BOTTOM w0.254: UV23.J1 v2(227.21,104.38)
N101473793: length 2.4
  TOP w0.102: RV619.1 238.31,103.01 238.13,103.2 237.77,103.2 237.46,103.2 237.45,103.2 v1(237.21,103.2) 237.11,103.2 236.81,103.49 v2(236.81,103.58)
  BOTTOM w0.107: UV23.J13 v2(236.81,103.58)
N101484102: length 17.2
  IN4 w0.508: v2(208.38,110.64) 208.32,110.58 208.32,109.38 209.36,108.34 209.36,98.56 208.78,97.98 v2(208.35,97.98)
  BOTTOM w0.254: UV24.U10 v2(208.35,97.98) ; TV4.1 207.96,111.06 v2(208.38,110.64) 208.11,110.38 UV24.A10
N101484120: length 2.8
  TOP w0.102: v1(214.36,105.58) 215.05,105.58 215.6,105.04 RV618.1
  TOP w0.254: v2(215.65,104.4) 215.6,104.45 RV618.1
  BOTTOM w0.254: UV24.J1 215.58,104.4 v2(215.65,104.4)
N101484397: length 5.9
  TOP w0.102: v2(205.95,104.38) v1(205.46,104.38)
  TOP w0.14: v2(208.39,103.44) 207.63,104.2 RV620.1
  IN4 w0.091: v2(205.95,104.38) 206.32,104.74 207.69,104.74 208.39,104.04 v2(208.39,103.44)
  BOTTOM w0.14: UV24.J13 v2(205.95,104.38)
N101908883: length 15.8
  TOP w0.102: v2(248.92,86.63) 249.26,86.98 250.02,86.98
  TOP w0.14: TV5.1 250.02,86.98
  IN4 w0.508: v2(236.92,86.63) 236.92,86.37 237.97,85.31 245.81,85.31 246.46,85.96 247.04,85.96 248.25,85.96 v2(248.92,86.63)
  BOTTOM w0.254: UV26.A10 v2(248.92,86.63) ; UV26.U10 v2(236.92,86.63)
N101908901: length 3.6
  BOTTOM w0.102: 242.92,79.77 UV26.J1
  BOTTOM w0.14: v1(243.05,76.31) 243.07,76.32 RV630.1 242.92,77.63 242.92,79.77
N101909174: length 3.9
  TOP w0.102: RV632.1 244.51,88.62 243.74,88.62 v2(243.32,89.04) 243,89.35 v1(242.18,89.35)
  BOTTOM w0.102: UV26.J13 v2(243.32,89.04)
N101910014: length 15.3
  TOP w0.102: v2(248.92,59.3) 248.53,58.91 TV6.1
  IN4 w0.099: v2(236.19,58.52) 236.19,58.72 237.31,59.84 248.39,59.84 v2(248.92,59.3)
  BOTTOM w0.254: UV25.U10 v2(248.92,59.3) ; UV25.A10 236.52,58.85 v2(236.19,58.52)
N101910032: length 3.8
  TOP w0.14: v1(241.72,68.37) 242.18,67.92 242.18,67.7 RV631.1
  TOP w0.254: v2(241.94,66.75) 242.37,66.75 242.7,67.07 RV631.1
  BOTTOM w0.254: v2(241.94,66.75) 242.28,66.75 UV25.J1
N101910312: length 2.5
  TOP w0.102: v2(242.46,56.9) 242.13,56.56 v1(242.13,56.46) 242.13,55.39 RV633.1
  BOTTOM w0.102: UV25.J13 242.52,56.9 v2(242.46,56.9)
N108873638: length 4.1
  TOP w0.203: PU400.20 345.2,18.41 345.31,18.3 345.7,18.3 v2(345.95,18.55)
  BOTTOM w0.254: v2(345.95,18.55) 346.57,18.55 v1(346.84,18.28) 347.36,17.76 347.36,17.42 347.64,17.14 PR409.1
N109970739: length 5.5
  TOP w0.14: v1(348.53,15.95) 348.03,16.44 PR410.1
  TOP w0.203: PR410.1 347.85,17.27 347.56,17.27 346.85,17.98 345.15,17.98 344.8,18.33 PU400.19
N110703687: length 1.7
  TOP w0.14: PR1009.2 v1(174.31,96.96)
N110833423:
  vias: v1(176.72,97.07) v2(176.09,97.85) v2(176.09,97.27)
N111796536:
  vias: v1(311.35,32.43)
N111796622: length 0.5
  TOP w0.102: 313.06,36.9 v1(313.56,36.9)
N111798152: length 2.3
  TOP w0.14: CZ4.1 310.91,33.66 v1(311.25,34.01) 311.51,34.01 311.71,34.21 UZ1.12
N111798158: length 5
  TOP w0.14: UZ1.10 311.43,35.01 311.38,35.06 CZ6.1 309.44,35.82 v1(307.6,35.82)
N116140097: length 12.3
  TOP w0.14: RV110.2 62.67,28.9 60.9,28.9 60.15,28.15 57.79,28.15 57.1,28.83 56.76,28.83 53.89,31.71 v2(53.89,31.71)
  BOTTOM w0.127: v2(53.89,31.71) 54.05,31.87 54.05,31.95 JEDP1.36
N116496514: length 1.3
  TOP w0.14: PC1056.1 v1(175.45,103.32)
N118983880: length 2.9
  TOP w0.203: 52.77,20.52 53.57,19.72 53.7,19.72 53.91,19.5 PU300.21
  TOP w0.254: 52.77,20.52 52.39,20.9 PR318.1
N119186848: length 3.6
  BOTTOM w0.14: v1(319.15,36.62) 318.28,36.62 317.78,36.13 RI23.1 317.76,35.76 318.41,35.1 UI3.7
N119186852: length 7
  TOP w0.14: v2(314.3,32.91) 314.45,32.76 v1(315.39,32.76) 316.15,32.76 316.92,33.52 RI36.1
  BOTTOM w0.14: UI3.5 314.53,33.14 v2(314.3,32.91)
N119942216:
  vias: v2(24.88,76.65)
N119944306: length 2.6
  TOP w0.203: PU300.3 54.71,14.25
  TOP w0.254: 54.71,14.25 54.71,14.19 v1(54.4,13.88) 54.17,13.65 PR303.2
N119944438: length 3.2
  TOP w0.14: v3(49.15,13.09) 49.35,12.89 50.41,12.89 v2(50.93,13.41)
  BOTTOM w0.508: PR304.2 51.12,13.22 v2(50.93,13.41)
N119944456: length 6.8
  TOP w0.203: PU300.6 55.91,14.4
  TOP w0.254: PC322.2 55.81,12.87 v2(55.81,13.37) 56.05,13.6 v1(56.05,13.84) 56.05,14.27 55.91,14.4
  BOTTOM w0.254: PQ304.1 57.42,11.52 57.24,11.69 56.8,11.69 56.03,12.45 55.98,12.45 PR305.1 55.77,13.33 v2(55.81,13.37) 55.88,13.44 PR308.1
N120139517: length 4.7
  BOTTOM w0.089: UH2.E1 99.33,23.91 100.66,25.23 101.92,25.23 101.98,25.17
  BOTTOM w0.14: 101.98,25.17 v1(102.22,24.93) 102.68,24.47 RH71.2
N120174690: length 1.3
  TOP w0.089: T20.1 92.72,7.85 v2(93.16,7.85)
  BOTTOM w0.089: UH2.AV15 92.92,7.85 v2(93.16,7.85)
N120176772: length 4.4
  BOTTOM w0.089: 75.06,18.07 76.63,18.07 76.78,17.93 76.93,17.93 76.97,17.88 77.07,17.88 77.12,17.84 77.19,17.84 77.39,17.64 77.93,17.64 77.98,17.59 UH2.V44
  BOTTOM w0.14: 75.06,18.07 75.04,18.07 T2.1
N120176782: length 5.1
  BOTTOM w0.089: UH2.L43 78.51,21.14 78.27,20.91 77.98,20.91 77.85,21.03 77.85,21.28 77.41,21.72 77.41,22.04 77.04,22.41
  BOTTOM w0.14: T4.1 77.01,22.44 77.04,22.41
N120176822: length 2.1
  TOP w0.089: T8.1 v2(81.09,3.56)
  BOTTOM w0.089: v2(81.09,3.56) 81.09,3.9 81.8,4.6 UH2.BD36
N120177456: length 3.2
  BOTTOM w0.089: UH2.BD17 91.35,4.48 91.35,3.06 91.12,2.83 91.02,2.83 90.87,2.68 90.87,1.76 T17.1
N120264964: length 1.1
  TOP w0.381: RT1.1 28.03,38.4 v2(27.36,38.4)
  BOTTOM w0.089: v2(27.36,38.4) UT1.N16
N120290495: length 2.2
  TOP w0.089: v2(28.01,42.94) 28.39,43.33 28.98,43.33 RT2.1
  BOTTOM w0.102: UT1.N6 v2(28.01,42.94)
N120293690: length 5.1
  TOP w0.14: QV13.2 20.03,77.77 v3(20.03,75.87)
  TOP w0.508: RV121.2 19.76,78.94 20.07,78.64 QV13.2
N120361079: length 3
  TOP w0.127: RD9.1 269.25,6.36 v2(269.27,6.35)
  TOP w0.14: v2(269.27,6.35) 269.55,6.35 v3(269.83,6.63)
  BOTTOM w0.127: JNGFF2.60 268.73,5.79 269.27,6.33 v2(269.27,6.35)
N120361841: length 1.4
  TOP w0.14: v1(59.45,2.21) 59.18,2.21 58.71,2.68 RZ18.1
N120361881: length 3.5
  TOP w0.14: v1(58.23,1.55) 58.23,1.63 57.9,1.96 57.53,1.96 57.23,1.66 CZ20.1
  TOP w0.254: CZ20.1 57.07,1.98 56.83,2.22 56.28,2.22 56.08,2.42 UZ4.6
N120533729: length 2.2
  TOP w0.14: RZ1134.2 275.97,6.8 v1(274.58,5.41)
N120533764: length 4.2
  TOP w0.14: v1(281.76,18.57) 281.76,17.77 RE76.2 281.78,16.06 UE4.14
N120533798: length 7.1
  TOP w0.14: UE4.13 282.28,15.41 RE75.2 282.63,15.93 282.99,16.29 283.77,16.29 284.23,16.75 284.23,17.39 284.37,17.53 284.37,19.13 v3(283.93,19.57)
N120533808: length 1.8
  TOP w0.14: UE4.12 282.61,14.76 RE74.2
N120533818: length 4.2
  TOP w0.14: v1(283.62,11.82) 283.62,12.29 282.63,13.28 RE73.2 282.25,14.11 UE4.11
N120553340: length 9
  TOP w0.14: v2(289.59,15.63) 289.1,15.63 RE44.1 RE43.1 287.91,15.87 288.43,16.39 288.43,17.61 v1(288.58,17.76) ; v2(291.95,13.84) 292.39,14.28 293.04,14.28 293.2,14.13 UE3.A59
  BOTTOM w0.14: v2(291.95,13.84) 291.38,13.84 v2(289.59,15.63)
N120553378: length 2
  TOP w0.14: v1(311.01,22.88) 310.73,22.6 309.11,22.6
N120553518: length 7
  TOP w0.14: v1(291.11,23.45) 292.05,23.45 RE111.1 292.18,22.97 292.38,22.77 293.14,22.77 293.43,22.48 293.43,21.66 293.37,21.6 293.37,19.57 293.48,19.46 293.93,19.46 294.01,19.38 UE3.B52
N120553639: length 13.2
  TOP w0.14: v2(287.73,19.01) 287.61,18.88 RE55.1 ; v2(295.92,14.5) 295.48,14.94 294.82,14.94 294.76,14.88 UE3.B61
  BOTTOM w0.14: v2(287.73,19.01) 288.61,18.13 289.25,18.13 291.42,15.96 292.07,15.96 292.56,16.46 292.63,16.46 292.64,16.46 292.99,16.46 292.99,16.46 293.43,16.46 294.96,14.93 295.49,14.93 v2(295.92,14.5)
N120554151: length 2.2
  TOP w0.14: v1(312.71,19) 312.7,18.98 RE69.2 310.9,18.98 310.7,18.79 QE10.2
N120554627: length 8.1
  TOP w0.14: v3(313.57,20.35) 313.57,19.32 312.71,18.46 311.53,18.46 311.3,18.23 308.51,18.23 308.15,17.87 CE48.1 RE62.2
N120918225: length 13
  TOP w0.254: PR303.1 54.17,11.25 v1(54.63,10.78) 54.82,10.59 55.03,10.59 v2(55.33,10.3) 55.36,10.27 55.36,10.09 55.66,9.79 55.71,9.79 55.85,9.65 56.48,9.65 56.93,9.2 PD303.1
  BOTTOM w0.254: PD304.1 57.34,9.7 56.14,10.91 56.14,11.39 PR305.2 55.61,11.6 55.61,10.89 55.33,10.6 v2(55.33,10.3) 55.26,10.37 54.31,10.37 54.23,10.3 53.6,10.3 52.77,11.12 PR399.1
N120970730: length 2.2
  TOP w0.14: v3(145.8,100.21) 146.31,100.72 PR1200.2
N120971346: length 3.4
  BOTTOM w0.14: v1(152.01,116.59) 151.72,116.3 149.7,116.3 149.1,116.9 PC1234.1
N120971480: length 1.9
  TOP w0.14: v3(158.89,109.91) 158.97,109.99 PR1208.2
N120977227:
  vias: v2(159.41,106.38) v2(159.77,105.88) v2(160.05,106.41) v2(160.38,105.88) v2(160.61,108.26) v2(160.71,106.38) v2(160.94,108.77) v2(161.21,108.24) v3(158.87,108.04)
N120977691: length 0.7
  TOP w0.14: v3(147.65,115.86) 147.4,115.6 v2(147.4,115.25)
  vias: v2(146.85,114.69) v2(147.47,114.64) v2(147.98,115.25) v2(148.08,114.64) v2(148.59,115.22) v2(148.67,114.61)
N121029055: length 3.9
  BOTTOM w0.089: 91.47,26.58 91.24,26.35 91.24,25.56 91.18,25.5 UH2.B18
  BOTTOM w0.305: RH108.1 90.78,28.29 v1(91.25,27.82) 91.47,27.61 91.47,26.58
N121029061: length 4.6
  BOTTOM w0.089: 90.93,26.83 91.03,26.73 91.03,25.61 90.95,25.53 90.95,25.21 91.28,24.88 UH2.C17
  BOTTOM w0.305: RH108.2 89.87,27.9 v1(89.97,27.8) 90.93,26.83
N121033373: length 2.2
  TOP w0.203: PR408.2 346.08,22.81 v2(345.77,22.5) 345.67,22.4 345.39,22.4 345.2,22.21 PU400.6
N121033408: length 4
  TOP w0.203: PU400.7 344.8,22.42 345.12,22.74 v2(345.12,22.87) PR407.2
  BOTTOM w0.14: v1(346.38,24.32) 345.56,23.49 PR407.2
  BOTTOM w0.254: PR407.2 v2(345.12,22.87)
N121070696: length 4.6
  BOTTOM w0.102: 99.37,13.33 99.06,13.03 98.62,13.03 98.34,12.75 UH2.AG3
  BOTTOM w0.305: 99.37,13.33 100.3,13.33 100.92,13.95 v1(100.92,14.39) 100.94,14.41 RH109.1
N121163993: length 6.5
  TOP w0.089: v2(173.41,58.05) 173.15,57.8 v1(173.15,57.34)
  BOTTOM w0.254: v2(173.41,58.05) 173.53,58.18 173.53,58.65 173.06,59.14 173.06,60.11 UH1.J2
  BOTTOM w0.381: v2(173.41,58.05) 173.21,57.86 173.21,56.04 172.68,55.51 RH150.2
N121163994: length 4.3
  TOP w0.089: v2(174.28,57.22) 174.3,57.24 174.34,57.24 174.36,57.22 174.58,57.22 v1(174.87,56.93)
  BOTTOM w0.254: UH1.H1 173.64,59.06 174.08,58.62 174.08,58.11
  BOTTOM w0.381: RH149.2 174.7,56.79 v2(174.28,57.22) 174.37,57.31 174.37,57.79 174.25,57.92 174.25,57.94 174.08,58.11
N121163995: length 5.4
  TOP w0.089: v2(175.25,56.22) v1(175.25,55.37)
  BOTTOM w0.254: UH1.G1 174.5,58.44 174.58,58.37
  BOTTOM w0.381: RH148.2 174.79,55.76 v2(175.25,56.22) 175.25,57.3 174.88,57.67 174.88,58.05 174.78,58.15 174.78,58.16 174.58,58.37
N121388945: length 8
  BOTTOM w0.089: 101.98,13.03 101.64,13.03 101.39,12.77 101.39,12.34 100.69,11.64 99.66,11.64 99.46,11.85 99.05,11.85 98.95,11.94 98.15,11.94 UH2.AJ4
  BOTTOM w0.127: 101.98,13.03 103.75,13.03 v1(103.82,13.1)
  BOTTOM w0.14: v1(103.82,13.1) 104.2,13.48 RH189.1
N121479122: length 8.9
  BOTTOM w0.254: RH465.1 RH466.1 157.12,92.15 158.01,92.15 158.24,91.92 158.24,91.09 v3(158.99,90.34) 159.08,90.26 159.08,88.34 158.94,88.2 158.94,87.97 UH1.AG38
N121480352: length 14
  TOP w0.14: v2(176.9,91.09) 176.54,91.09 v3(176.19,90.74)
  IN4 w0.254: v2(169.15,87.26) 172.86,90.97 176.77,90.97 v2(176.9,91.09)
  BOTTOM w0.254: v2(169.15,87.26) 169.2,87.26 169.29,87.17 169.78,87.17 170.36,86.6 170.36,86.11 UH1.M37 ; RH470.1 176.86,91.13 v2(176.9,91.09) 176.86,91.06 RH469.1
N121480355: length 16.1
  TOP w0.14: v3(178.18,90.7) 177.78,91.1 v2(177.51,91.1)
  IN4 w0.254: v2(177.51,91.1) 177.51,91.31 177.22,91.6 176.53,91.6 176.29,91.36 172.43,91.36 168.89,87.82 v2(168.89,87.82)
  BOTTOM w0.254: v2(168.89,87.82) 169.67,87.82 170.75,86.73 UH1.M38 ; RH201.1 177.92,90.48 177.51,90.89 v2(177.51,91.1) 177.51,91.37 177.85,91.72 RH202.1
N121480375: length 2.2
  TOP w0.127: v2(164.91,66.61) 164.55,66.25 v1(164.47,66.25)
  TOP w0.305: RH473.2 164.27,67.24 v2(164.91,66.61)
  BOTTOM w0.305: UH1.Y12 164.62,66.9 v2(164.91,66.61)
N121507165: length 6
  BOTTOM w0.254: UH1.BR25 138.1,77.14 137.78,76.82 137.23,76.82 136.8,76.39 v1(134.84,76.39) 133.33,76.39 132.86,75.92 RH57.2
N121507167: length 6.4
  BOTTOM w0.254: RH58.2 133,77.41 v1(135.65,77.41) 136.67,77.41 136.86,77.59 138.37,77.59 UH1.BP25
N121507169: length 4.7
  BOTTOM w0.203: RH166.2 133.4,79.47 134.01,80.08 v1(134.78,80.08) 137.18,80.08 UH1.BT29
N121616264: length 1.5
  TOP w0.14: RE93.1 192.59,9.91 v1(192.8,9.91)
N121616283: length 3.5
  TOP w0.127: CE65.1 192.79,8.37 192.61,8.19 UE6.6
  TOP w0.14: CE65.1 193.27,8.38 v1(194.68,8.38)
N121617744: length 2.5
  TOP w0.14: CZ37.1 240.6,6.74 240.79,6.55 241.36,6.55 241.5,6.41 241.5,6.16 241.19,5.86 UZ7.12
N121617748: length 5.6
  TOP w0.127: CZ39.1 242.25,6.87 242.25,6.17 241.99,5.9 UZ7.10
  TOP w0.14: v1(242.89,10.47) 242.6,10.18 242.6,7.84 CZ39.1
N121617759:
  vias: v3(238.84,5.47)
N121617766:
  vias: v3(243.98,5.57)
N121673930: length 1.9
  TOP w0.14: v1(107.82,106.18) 107.89,106.24 PR1112.1
  TOP w0.254: PR1112.1 108.83,105.43 PC1106.2
N121674134: length 3.6
  BOTTOM w0.14: v1(116.78,96.77) 116.59,96.96 PC1130.1
  BOTTOM w0.254: PR1140.2 117.73,99.28 117.73,98.7 116.83,97.8 PC1130.1
N121674335: length 3.1
  TOP w0.14: PC1118.1 124.89,104.39 v1(124.8,104.3)
  TOP w0.254: PC1118.1 124.88,105.34 v2(124.22,105.34)
  BOTTOM w0.254: PR1125.2 124.89,104.45 124.22,105.13 v2(124.22,105.34)
N121710332: length 10.5
  BOTTOM w0.254: UH1.AG37 159.1,85.71 159.32,85.94 159.32,87.99 159.47,88.15 159.47,90.53 158.67,91.33 v3(158.67,92.08) 158.67,92.11 158.27,92.51 157.13,92.51 RH197.2 RH198.1
N121712022: length 6.4
  BOTTOM w0.254: v2(155.64,88.05) 155.65,88.05 RH204.1 RH203.2 157.1,89.34 157.86,89.34 158.13,89.07 158.13,88.39 158.23,88.29 158.23,86.43 158.17,86.36 UH1.AH38
N121718437: length 5.5
  TOP w0.127: v2(97.28,37.18) 97.79,37.18 98.4,36.57 v3(98.4,36.25)
  TOP w0.14: v3(98.4,36.25) 98.17,36.03 RE82.2 98.79,34.97 DE7.1
  BOTTOM w0.127: v2(97.28,37.18) 97.3,37.2 JFAN1.3
N121718548: length 9.2
  TOP w0.14: v2(324.17,41.66) 323.72,41.22 323.61,41.22 323.36,40.97 323.09,40.97 DE8.1 322.21,40.09 322.21,39.89 RE84.2 321.1,38.77 319.41,38.77 v1(319.04,39.14)
  BOTTOM w0.14: v2(324.17,41.66) 325.5,40.33 JFAN2.3
N121775507: length 5
  TOP w0.203: v2(58.55,15.76) 58.18,15.76 57.63,16.31 PU300.9
  TOP w0.254: v2(58.55,15.76) 58.68,15.63 PR324.2
  BOTTOM w0.14: v1(58.78,17.15) 58.43,17.15 PR325.1
  BOTTOM w0.254: v2(58.55,15.76) 58.55,16.13 58.15,16.52 PR325.1
N121795600:
  vias: v2(145.24,102.93) v2(145.21,102.24) v2(145.82,102.93) v2(145.8,102.32) v2(145.85,101.74) v2(146.5,102.93) v2(146.5,102.33) v2(146.51,101.71) v3(145.26,103.6)
N121981266: length 31.7
  TOP w0.14: v2(110.36,107.96) 110.36,108.09 109.6,108.85 v1(109.6,109.1)
  TOP w0.254: PR1105.1 110.49,108.09 v2(110.36,107.96)
  IN2 w0.254: v2(110.36,107.96) 108.89,106.49 108.89,103.59 108.01,102.71 107,102.71 105.22,100.94 105.22,95.76 103.72,94.26 103.72,92.29 103.59,92.17 103.59,84.92 v2(104.52,83.99)
  BOTTOM w0.254: PR1106.2 109.69,107.29 v2(110.36,107.96) ; PH1100.2 v2(104.52,83.99)
N121981305: length 2.7
  BOTTOM w0.14: PR1122.2 121.37,86.58 121.37,87.47 v1(120.97,87.88)
  BOTTOM w0.254: PR1122.2 PH1102.1
N121981509: length 2.9
  BOTTOM w0.14: v1(115.93,91.65) 114.59,91.65 PH1101.2
  BOTTOM w0.254: PR1121.1 PH1101.2
N121981539: length 3.9
  BOTTOM w0.14: PR1136.1 150.11,99.87 149.62,99.37 149.62,97.9 v1(149.05,97.33)
  BOTTOM w0.254: PH1103.2 150.11,100.82 PR1136.1
N122282431: length 4.2
  BOTTOM w0.14: RR9.1 344.51,35.23 v1(344.51,35.99) 344.51,36.18 343.6,37.09 342.73,37.09 342.53,37.29 UR1.28
N122314333: length 7.2
  BOTTOM w0.254: 158.66,88.63 v3(158.65,88.63) ; 158.66,88.63 158.57,88.54 158.57,86.02 158.27,85.71 UH1.AH37 ; 158.66,88.63 158.66,89.05 158,89.71 157.11,89.71 156.58,90.25 RH472.1 RH471.1
N122397475: length 8.6
  BOTTOM w0.076: 179.9,80.87 174.46,80.87 UH1.G29
  BOTTOM w0.14: v1(180,78.7) 180,78.84 180.65,79.5 RH145.1 180,80.87 179.9,80.87
N122409296: length 5.9
  TOP w0.127: RE13.1 RE14.2 158.29,6.93 UE1.4
  TOP w0.14: v1(161.02,8.06) 160.52,8.57 158.64,8.57 158.29,8.23 RE13.1
N122409328: length 2.2
  TOP w0.14: RE77.2 155.14,3.2 154.78,3.56 154.61,3.56 153.93,4.24 UE1.28
N122409465: length 4.4
  TOP w0.14: v3(147.73,6.57) 148.15,6.16 149.68,6.16 150.18,6.65 RE114.2 150.72,6.65 151.01,6.93 UE1.21
N122409468: length 5.7
  TOP w0.127: RE113.2 151.19,4.66 151.13,4.72 151.13,5.2 151.36,5.43
  TOP w0.14: v3(148.5,3.11) 148.98,2.63 150.46,2.63 151.17,3.34 RE113.2 ; 151.36,5.43 UE1.24
N122409512: length 6
  TOP w0.127: UE1.27 153.43,4.2 153.06,3.83 153.06,3.3 RE85.2
  TOP w0.14: v1(149.79,1.73) 151.42,1.73 152.19,2.5 152.87,2.5 RE85.2
N122409618: length 0.9
  TOP w0.14: CE8.1 150.22,8.64 RE11.2
N122463812: length 3.9
  TOP w0.14: v1(130.09,85.15) 129.73,84.79 v2(129.54,84.79) 129.54,85.26 129.28,85.51 JXDP.1
  BOTTOM w0.14: RH475.1 v2(129.54,84.79) 130.1,84.79 RH474.1
N122476680: length 29
  TOP w0.14: v2(129.91,100.1) 129.91,100.58 v3(130.15,100.82)
  IN1 w0.254: v2(149.16,104.78) 149.16,103.91 147.09,101.84 147.09,101.34 143.26,97.51 131.57,97.51 129.91,99.17 v2(129.91,100.1)
  BOTTOM w0.254: PR1218.2 148.91,105.04 v2(149.16,104.78) ; PR1201.1 128.79,99.25 PR1202.1 129.68,99.25 129.96,99.53 129.96,100.05 v2(129.91,100.1)
N122477585: length 33.7
  TOP w0.14: v2(149.16,112.59) v3(148.46,112.59)
  IN1 w0.254: v2(128.95,101.6) 129.52,101.02 131.53,101.02 133.05,99.51 140.75,99.51 143.05,101.81 143.05,105.48 143.68,106.11 143.68,108.19 144.26,108.76 145.96,108.76 149.16,111.97 v2(149.16,112.59)
  BOTTOM w0.254: PR1206.1 129.2,101.18 128.95,101.43 v2(128.95,101.6) 128.6,101.6 PR1205.1 ; PR1220.2 v2(149.16,112.59)
N122517438: length 2.9
  TOP w0.14: v1(112.42,5.1) 112.61,5.29 113.37,5.29 113.54,5.46 RH536.2 113.98,4.28 SW4.1
N122528028:
  vias: v3(238.48,42.21)
N122563835: length 8.2
  BOTTOM w0.076: 134.62,82.45 135.99,82.45 136.07,82.37 137.75,82.37 UH1.BR33
  BOTTOM w0.14: 134.62,82.45 134.49,82.45 134.38,82.56 133.77,82.56 133.66,82.45 132.46,82.45 131.98,82.93 v1(131.98,83.31) 131.33,83.96 RH519.2
N122630698: length 3.2
  TOP w0.14: v1(348.22,83.55) 348.22,83.7 RH67.1 348.45,85.4 D122.1
N122631012: length 2.6
  TOP w0.14: v1(346.15,89.52) RH590.1 346.37,88.3 D122.2
N122687725: length 15.5
  TOP w0.14: RZ85.1 181.53,3.18 181.98,3.64 181.98,4.95 182.17,5.14 UZ20.4 183.2,5.14 183.33,5.01 v2(183.33,4.59) ; UZ11.1 177.71,4.47 177.42,4.76 177.42,5.47 177.31,5.58 RZ58.1 176.96,4.66 v2(176.79,4.48)
  IN2 w0.099: v2(183.33,4.59) 182.11,3.37 178.18,3.37 177.08,4.48 v2(176.79,4.48)
N122698769: length 2
  TOP w0.089: T49.1 140.81,84.5 v2(141.23,84.08)
  BOTTOM w0.076: v2(141.23,84.08) 140.9,83.76 UH1.BL34
N122698770: length 2.2
  TOP w0.089: v2(176.51,58.63) 176.84,58.3 T39.1
  BOTTOM w0.076: v2(176.51,58.63) 176.51,59.31 UH1.D1
N122698771: length 1.4
  TOP w0.089: v2(136.94,59.91) 137.42,60.39 T44.1
  BOTTOM w0.076: UH1.BT2 137.34,60.31 v2(136.94,59.91)
N122698772: length 2.1
  TOP w0.089: T42.1 176.39,59.41 v2(176.02,59.04)
  BOTTOM w0.076: v2(176.02,59.04) 175.71,59.34 175.71,60.28 UH1.E2
N122698773: length 1.2
  TOP w0.089: T51.1 167.98,68.21 v2(167.66,67.89)
  BOTTOM w0.076: v2(167.66,67.89) 167.97,68.2 UH1.R14
N122698774: length 1.7
  TOP w0.089: v2(173.86,77.05) 174.25,76.65 T47.1
  BOTTOM w0.076: v2(173.86,77.05) 173.48,76.67 UH1.H24
N122698775: length 1.1
  TOP w0.089: T45.1 138.72,84.29 v2(139.08,83.93)
  BOTTOM w0.076: UH1.BN35 139.08,83.97 v2(139.08,83.93)
N122698776: length 2.1
  TOP w0.089: v2(169.59,81.48) 169.59,81.18 T50.1
  BOTTOM w0.076: UH1.N29 169.59,80.83 v2(169.59,81.48)
N122698777: length 1.2
  TOP w0.089: v2(163.09,68.55) 162.75,68.21 T53.1
  BOTTOM w0.076: UH1.AA14 163.44,68.2 v2(163.09,68.55)
N122698778: length 1.3
  TOP w0.089: T40.1 175.1,58.98 v2(175.33,59.22)
  BOTTOM w0.076: UH1.E1 175.3,59.25 v2(175.33,59.22)
N122698779: length 2.4
  TOP w0.089: v2(136.65,59.14) 136.79,59 T43.1
  BOTTOM w0.076: UH1.BR1 137.71,59.74 137.12,59.14 v2(136.65,59.14)
N122698780: length 1.6
  TOP w0.089: v2(176.16,60.36) 175.66,60.85 T41.1
  BOTTOM w0.076: UH1.E3 175.61,60.97 176.16,60.42 v2(176.16,60.36)
N122698781: length 1.7
  TOP w0.089: T48.1 139.09,82.33 v2(139.73,82.33)
  BOTTOM w0.076: UH1.BN33 139.4,82.65 v2(139.73,82.33)
N122698782: length 1.7
  TOP w0.089: T52.1 160.91,81.5 v2(160.92,81.5)
  BOTTOM w0.076: v2(160.92,81.5) 160.92,80.86 UH1.AE29
N122698783: length 2.2
  TOP w0.089: T46.1 172.41,75.35 v2(172.41,75.48)
  BOTTOM w0.076: v2(172.41,75.48) 172.41,76.24 UH1.J24
N122698814: length 5.2
  BOTTOM w0.076: 179.9,81.29 179.39,81.29 179.13,81.03 175.62,81.03 175.48,81.17 UH1.E30
  BOTTOM w0.14: 179.9,81.29 T58.1
N122698815: length 4.1
  BOTTOM w0.076: UH1.BR35 137.75,84.63 136.65,84.63 136.43,84.85 134.62,84.85
  BOTTOM w0.14: 134.62,84.85 T63.1
N122698816: length 1.2
  TOP w0.089: v2(142.8,81.49) 143.22,81.07 T65.1
  BOTTOM w0.076: v2(142.8,81.49) 142.42,81.11 UH1.BH30
N122698817: length 1.1
  TOP w0.089: T62.1 173.35,61.05 v2(173.72,61.41)
  BOTTOM w0.076: UH1.J3 173.34,61.04 v2(173.72,61.41)
N122698818: length 3.8
  TOP w0.089: T59.1 178.41,82.73 v2(178.74,82.41)
  BOTTOM w0.076: v2(178.74,82.41) 179.07,82.07 179.07,81.67 178.66,81.26 177.54,81.26 UH1.B30
N122698819: length 1.8
  TOP w0.089: T64.1 138.81,81.28 v2(139.09,81.56)
  BOTTOM w0.076: UH1.BR31 138.48,81.56 v2(139.09,81.56)
N122698820: length 1.5
  TOP w0.089: v2(173.76,60.73) 174.21,60.28 T61.1
  BOTTOM w0.076: UH1.G3 174.07,61.04 v2(173.76,60.73)
N122698821: length 1.2
  TOP w0.089: T57.1 174.42,81.67 v2(174.54,81.79)
  BOTTOM w0.076: UH1.F30 174.83,81.5 v2(174.54,81.79)
N122698822: length 1
  TOP w0.089: v2(177.09,81.76) 176.77,81.44 T60.1
  BOTTOM w0.076: v2(177.09,81.76) 176.78,81.45 UH1.C30
N122698841: length 1.1
  TOP w0.089: T82.1 142.29,83.16 v2(142.01,83.43)
  BOTTOM w0.076: UH1.BJ33 141.69,83.11 v2(142.01,83.43)
N122698842: length 5.2
  BOTTOM w0.14: T90.1 179.45,88.18 178.93,87.65 178.04,87.65 UH1.C38
N122698843: length 4
  BOTTOM w0.127: UH1.B2 177.17,60.14 177.17,59.89 177.17,59.88 177.17,59.59 177.17,59.58 177.17,59.18 177.13,59.14 177.13,58.34 176.98,58.19 176.72,57.93 T85.1
N122698844: length 4.9
  TOP w0.089: T83.1 177.89,68.79 174.22,68.79 v2(173.83,68.41)
  BOTTOM w0.076: UH1.G13 174.18,68.07 v2(173.83,68.41)
N122698845: length 4.3
  TOP w0.089: T88.1 136.32,58.58 v2(136.21,58.69)
  BOTTOM w0.076: v2(136.21,58.69) 137.28,58.69 137.85,59.25 138.1,59.25 138.39,59.54 138.39,60.21 UH1.BR2
N122698846: length 1.1
  TOP w0.089: v2(142.01,84.08) 142.29,84.36 T81.1
  BOTTOM w0.076: v2(142.01,84.08) 141.69,83.76 UH1.BJ34
N122698847: length 5.3
  BOTTOM w0.14: UH1.B38 178.37,87.21 178.99,87.21 180.04,88.25 180.04,89.18 T86.1
N122698848: length 3.8
  BOTTOM w0.127: UH1.C1 176.91,59.64 176.91,58.43 176.21,57.73 T89.1
N122698849: length 2.7
  TOP w0.089: T84.1 156.38,62.07 156.74,62.44 v2(156.74,63.97)
  BOTTOM w0.076: v2(156.74,63.97) 157.07,64.3 UH1.AJ8
N122698850: length 5.1
  TOP w0.089: v2(135.75,58.27) 135.75,57.68 135.3,57.22 T87.1
  BOTTOM w0.076: v2(135.75,58.27) 137.1,58.27 137.78,58.95 137.86,58.95 138.07,58.95 138.74,59.62 UH1.BP1
N122698871: length 1.1
  TOP w0.089: T77.1 141.38,74.04 v2(141.01,73.67)
  BOTTOM w0.076: UH1.BK21 141.35,74.02 v2(141.01,73.67)
N122698872: length 1.1
  TOP w0.089: T73.1 142.5,69.91 v2(142.46,69.87)
  BOTTOM w0.076: v2(142.46,69.87) 142.26,69.87 142,70.12 UH1.BJ16
N122698873: length 1.1
  TOP w0.089: v2(141.01,70.52) 140.98,70.49 T74.1
  BOTTOM w0.076: v2(141.01,70.52) 141.35,70.17 UH1.BK16
N122698874: length 3.4
  BOTTOM w0.076: UH1.BR17 137.82,71.19 137.28,71.19 137.02,70.94 T80.1
N122698875: length 1.1
  TOP w0.089: T75.1 141.36,76.4 v2(140.98,76.02)
  BOTTOM w0.076: v2(140.98,76.02) 141.35,76.39 UH1.BK24
N122698876: length 1.3
  TOP w0.089: T78.1 142.48,74.35 v2(142.45,74.32)
  BOTTOM w0.076: v2(142.45,74.32) 142.19,74.06 UH1.BJ21
N122698877: length 1.3
  TOP w0.089: v2(142.54,76.16) 142.91,76.53 T76.1
  BOTTOM w0.076: UH1.BJ24 142.28,76.42 v2(142.54,76.16)
N122698878: length 1
  TOP w0.089: v2(137.72,70.51) 138.09,70.14 T79.1
  BOTTOM w0.076: UH1.BT17 137.45,70.78 v2(137.72,70.51)
N122698895: length 1.1
  TOP w0.089: T66.1 140.12,82.73 v2(139.73,83.12)
  BOTTOM w0.076: UH1.BM33 140.05,82.79 v2(139.73,83.12)
N122698896: length 1.5
  TOP w0.089: T68.1 142.17,69.26 v2(142.52,68.92)
  BOTTOM w0.076: UH1.BJ14 142.15,68.59 142.48,68.92 v2(142.52,68.92)
N122698897: length 1.5
  TOP w0.089: v2(142.49,79.12) 142.71,78.9 T71.1
  BOTTOM w0.076: UH1.BJ28 142.04,79.57 v2(142.49,79.12)
N122698898: length 2.2
  TOP w0.089: v2(143.09,68.97) 143.41,69.29 T69.1
  BOTTOM w0.076: UH1.BJ13 141.96,68.07 142.45,68.56 142.68,68.56 v2(143.09,68.97)
N122698899: length 1.5
  TOP w0.089: v2(141.23,83.43) 141.04,83.43 T67.1
  BOTTOM w0.076: UH1.BL33 140.9,83.11 v2(141.23,83.43)
N122698900: length 1.6
  TOP w0.089: T70.1 140.76,80.3 v2(140.42,79.96)
  BOTTOM w0.076: v2(140.42,79.96) 140.84,79.96 141.22,79.57 UH1.BK28
N122706757: length 80.9
  TOP w0.254: v2(170.01,71.23) 170.33,71.55 PR810.2 PR809.1 ; v2(110.55,66.56) 110.86,66.56 111.16,66.25 115.58,66.25 119.12,62.72 123.15,62.72 125.39,64.96 v2(128.7,64.96) ; v2(104.52,64.78) 104.52,64.91 105.04,65.43 PR806.2
  IN1 w0.254: v2(110.55,66.56) 110.05,66.56 109.86,66.75 107.38,66.75 107,66.37 107,65.87 106.25,65.12 104.86,65.12 v2(104.52,64.78)
  IN6 w0.254: v2(170.01,71.23) 169.19,70.4 166.02,70.4 165.45,70.98 165.45,72.55 164.5,73.5 160.44,73.5 158.55,71.61 151.86,71.61 151.54,71.29 151.17,71.29 149.01,73.45 145.29,73.45 142.9,71.07 142.02,71.07 141.34,71.75 138.33,71.75 137.14,70.56 133.62,70.56 131.45,68.39 131.45,67.66 128.77,64.98 128.68,64.98 v2(128.7,64.96)
N122739033: length 5.2
  TOP w0.14: v3(182.25,2.6) 179.05,2.6 178.77,2.88 RZ59.2 178.67,3.28 UZ11.2
N122739099: length 9
  TOP w0.14: v3(167.23,2.9) 167.5,2.62 169.99,2.62 170.37,3 UZ21.4 170.77,3.68 171.01,3.44 RZ86.1 171.93,3.87 171.93,4.36 171.49,4.8 RZ60.1 172.06,4.92 172.28,4.71 172.91,4.71 UZ12.1
N122739340: length 3.9
  TOP w0.14: v1(175.85,3.44) 175.57,3.72 174.16,3.72 RZ61.2 173.62,3.92 173.78,4.08 UZ12.2
N122754331: length 2
  TOP w0.14: RZ67.1 129.97,66.99 v3(128.02,66.99)
N122754354: length 3.7
  TOP w0.14: v3(130.57,70.5) 131.15,69.92 CZ57.1 131.15,68.69 130.84,68.37 130.84,68.36 130.75,68.27 130.75,68.02 131.07,67.7 UZ16.6
N122755391: length 6.3
  BOTTOM w0.14: RZ48.2 v1(183.56,81.04) 185.06,82.54 UZ9.6 185.06,83.78 185.29,84.02 185.79,84.02 CZ82.1
N122774125: length 81
  TOP w0.254: v2(172.31,71.15) 171.84,70.68 PR808.1 PR813.2 ; v2(110.55,67.19) 110.85,67.19 111.41,66.63 115.71,66.63 119.25,63.09 122.97,63.09 125.37,65.49 v3(126.14,65.49) 128.94,65.49 129.49,64.95 v2(129.49,64.83)
  IN1 w0.254: v2(110.55,67.19) 107.19,67.19 106.62,66.62 106.62,66.18 v2(106.49,66.05)
  IN6 w0.254: v2(172.31,71.15) 171.22,70.06 165.88,70.06 165.11,70.83 165.11,72.41 164.36,73.16 160.58,73.16 158.69,71.27 152,71.27 151.68,70.95 151.02,70.95 148.86,73.11 145.43,73.11 143.04,70.72 141.84,70.72 140.97,69.86 137.25,69.86 136.99,70.12 133.82,70.12 131.87,68.17 131.87,67.2 v2(129.49,64.83)
  BOTTOM w0.254: PR804.2 107.13,65.71 106.78,66.05 v2(106.49,66.05)
N122912247: length 1.5
  TOP w0.14: v1(182.08,78.41) 182.08,79.29 RZ66.1
N123346527: length 9.9
  TOP w0.14: QV13.1 v1(24.04,77.99)
  TOP w0.508: QV13.1 22.79,80 RV514.2 RV515.2 RV516.2 RV517.2 RV512.2 RV513.2 RV518.2 RV519.2
N123360127: length 3.5
  TOP w0.089: v2(25.41,37.09) 25.05,36.74 25.05,36.13 RT12.1 24.99,35.56 v1(24.99,34.44)
  BOTTOM w0.102: UT1.H19 v2(25.41,37.09)
N123360144: length 4.3
  TOP w0.089: RT5.1 31.51,35.81 v3(30.09,35.81) 30.09,36.1 30.31,36.33 30.31,36.65 30.21,36.75 30.21,37.19 30.61,37.59 v2(30.61,37.73)
  BOTTOM w0.076: UT1.Y18 30.93,38.06 30.61,37.74 v2(30.61,37.73)
N123628000: length 321.8
  TOP w0.14: v2(59.28,28.57) 58.7,28.57 58.24,29.03 57.61,29.03 v3(57.11,29.54)
  IN2 w0.099: v2(336.17,51.61) 335.5,50.94 332.5,50.94 325.55,43.99 325.55,36.92 316.18,27.54 302.59,27.54 301.6,26.55 299.51,26.55 298.4,25.45 297.74,25.45 296.71,24.42 293.87,24.42 292.26,22.81 292.05,22.81 291.63,22.38 290.94,22.38 290.16,21.6 281.65,21.6 280.25,20.2 279.11,20.2 278.5,19.58 274.11,19.58 273.56,20.14 268.5,20.14 267.44,19.08 264.61,19.08 264.39,18.86 261.18,18.86 259.65,17.33 254.05,17.33 253.86,17.52 175.93,17.52 175.48,17.97 173.13,17.97 172.88,18.22 158.77,18.22 157.18,19.82 157.18,24.53 156.84,24.86 155.55,24.86 154.05,26.36 146.29,26.36 144.95,27.7 144.69,27.7 140.9,31.49 116.16,31.49 112.34,35.31 104.94,35.31 104.61,35.64 100.09,35.64 97.69,33.25 88.8,33.25 84.91,29.36 81.26,29.36 79.58,27.68 73.9,27.68 71.36,25.14 66.72,25.14 63.09,28.77 59.48,28.77 v2(59.28,28.57)
  BOTTOM w0.127: DI1.2 57.21,26.23 57.21,26.51 v2(59.28,28.57)
  BOTTOM w0.14: v2(336.17,51.61) 335.99,51.43 JTS.2
N123983992:
  vias: v2(111.63,68.08) v2(111.66,67.43) v2(112.33,68.08) v2(112.35,67.46) v2(112.95,68.09) v2(112.98,67.51) v2(113.56,68.09) v2(113.62,67.51) v3(111.05,67.85)
N123984002: length 49.7
  TOP w0.14: v3(107.48,100.38) 107.13,100.73 v2(107.13,101.16)
  TOP w0.254: PR1305.1 107.19,101.23 v2(107.13,101.16)
  IN1 w0.254: v2(107.13,101.16) 106.55,101.74 105.92,101.74 105.35,101.16 105.35,95.51 103.65,93.82 103.65,82.99 105.54,81.1 105.54,79.9 105.86,79.59 109.68,79.59 109.79,79.7 112.21,79.7 112.51,80.01 115.27,80.01 116.01,79.26 116.01,70.69 115.56,70.24 v2(115.47,70.24)
  BOTTOM w0.254: PR1306.1 107.19,101.23 v2(107.13,101.16) ; PR1314.2 v2(115.47,70.24)
N123984012:
  vias: v2(106.49,94.31) v2(106.49,93.67) v2(106.92,97.06) v2(107.56,97.06) v3(105.73,95.68)
N123984055: length 3.6
  TOP w0.254: PR1311.1 116.23,94.74 v2(116.9,94.74)
  BOTTOM w0.14: v1(117.4,94.95) 117.18,94.74 v2(116.9,94.74)
  BOTTOM w0.254: PU1302.2 116.69,94.95 v2(116.9,94.74)
N123984061: length 10
  TOP w0.14: v2(108.46,91.13) 107.96,91.13 v3(107.86,91.03)
  IN6 w0.762: 109.09,91.96 108.9,92.15 108.9,96.66 109.73,97.48 111.71,97.48 112.41,96.78 112.84,96.78
  vias: v2(109.09,91.13) v2(112.87,96.48) v2(112.87,95.84)
N123984063: length 11.9
  TOP w0.14: v2(106.55,91.32) 105.91,91.32 v3(105.7,91.12)
  IN6 w0.762: 106.87,90.37 107.51,89.73 109.22,89.73 110.81,91.32 112.71,91.32 115.7,94.31
  vias: v2(107.15,91.32) v2(116.5,95.45) v2(117.1,95.45)
N123984071: length 3.1
  TOP w0.14: v1(112.85,97.34) 113.67,97.34 114.39,96.62 PC1313.2
  TOP w0.254: PR1311.2 115.44,96.41 PC1313.2
N123984081: length 31
  TOP w0.14: v3(105.65,100.26) 106.36,100.97 v2(106.36,101.1)
  TOP w0.254: PR1301.1 105.92,101.35 106.17,101.1 v2(106.36,101.1)
  IN1 w0.254: v2(106.36,101.1) 105.86,100.59 105.86,95.01 105.28,94.44 105.28,88.21 106.62,86.88 111.95,86.88 114.36,84.46 114.75,84.46 115.7,83.51 v2(115.7,82.56)
  BOTTOM w0.254: v2(115.7,82.56) 115.62,82.48 PR1312.2 ; PR1303.1 105.98,101.48 v2(106.36,101.1)
N123984161: length 1.6
  BOTTOM w0.14: PC1365.1 104.31,91.58 v1(104.09,91.79)
N123984213: length 49.1
  TOP w0.14: v2(115.47,70.87) 115.44,70.9 v3(115.44,71.66)
  TOP w0.254: PR1304.1 v2(108.27,101.1)
  IN1 w0.254: v2(108.27,101.1) 107.19,102.18 105.73,102.18 104.97,101.42 104.97,95.78 103.3,94.1 103.3,82.84 105.18,80.95 105.18,79.76 105.71,79.23 109.83,79.23 109.91,79.32 112.4,79.32 112.64,79.56 115.01,79.56 115.57,79 115.57,70.98 v2(115.47,70.87)
  BOTTOM w0.254: PR1315.2 116.27,70.3 115.7,70.87 v2(115.47,70.87)
N123984281: length 29.3
  TOP w0.14: v2(111.09,89.48) 111.05,89.44 110.64,89.44 110.49,89.29 v3(109.94,89.29)
  TOP w0.254: PR1309.1 126.62,103.79 v2(126.37,103.54)
  IN1 w0.254: v2(126.37,103.54) 126.35,103.54 126.33,103.51 126.19,103.51 125.5,102.83 123.94,102.83 121.64,100.53 121.64,93.98 121.1,93.43 120.35,93.43 119.7,92.78 119.7,92.45 118.57,91.32 114.78,91.32 113.95,90.5 111.75,90.5 111.09,89.84 v2(111.09,89.48)
  BOTTOM w0.254: PL1306.2 110.83,88.77 111.09,89.02 v2(111.09,89.48)
N123984351:
  vias: v3(111.98,92.58)
N123984423: length 1.7
  TOP w0.14: PC1347.1 110.73,73.48 v3(110.36,73.85)
N123984459: length 0.7
  TOP w0.14: v3(110.41,77.07) 110.68,77.34 110.96,77.34
N123984461:
  vias: v2(111.25,80.25) v2(111.91,80.25) v2(114.63,80.55) v2(114.66,81.75) v2(114.66,81.14) v2(115.24,80.53) v2(115.27,81.77) v2(115.29,81.14) v3(112.1,82.88)
N123985122: length 31.2
  TOP w0.14: v2(109.22,101.1) 109.22,100.52 v3(109.3,100.44)
  TOP w0.254: PR1302.2 v2(109.22,101.1)
  IN1 w0.254: v2(116.33,82.56) 116.33,83.51 115,84.84 114.56,84.84 112.14,87.26 106.81,87.26 105.73,88.34 105.73,94.31 106.3,94.88 106.3,99.96 106.81,100.47 108.59,100.47 v2(109.22,101.1)
  BOTTOM w0.254: v2(116.33,82.56) 116.41,82.48 PR1313.2
N124211085: length 2.7
  TOP w0.089: v2(24.76,37.09) 24.64,36.98 RT164.2 24.5,35.78 v1(23.69,35.78)
  BOTTOM w0.102: UT1.F19 v2(24.76,37.09)
N124494273: length 4.6
  BOTTOM w0.081: 25.75,55.47 25.75,55.56 25.87,55.68 25.87,56.03 25.62,56.28 25.62,57 25.62,57 25.62,57.15 UT4.C10
  BOTTOM w0.14: RT181.1 25.41,53.54 26,54.12 v1(26,54.59) 26,54.7 25.75,54.95 25.75,55.47
N124494447: length 8.8
  IN2 w0.508: v2(20.13,56.37) 20.56,56.8 20.74,56.8 21.04,57.11 21.04,59.93 20.69,60.28 v2(20.28,60.28)
  BOTTOM w0.254: RT1095.2 RT1094.2 19.47,55.71 v2(20.13,56.37) 20.22,56.46 20.43,56.46 UT4.B1 ; UT4.H1 20.67,59.9 v2(20.28,60.28)
N124494860: length 3.6
  TOP w0.14: v2(23.96,60.4) 24.36,60.81 24.74,60.81 24.77,60.78 24.78,60.78 25.18,60.38 CT158.1 26.59,60.38 v1(26.63,60.35)
  BOTTOM w0.081: v2(23.96,60.4) 23.87,60.32 UT4.H7
N124494892: length 3.3
  BOTTOM w0.081: RT191.1 18.85,60.13 19.41,59.57 19.75,59.57 20.17,59.15 21.12,59.15 UT4.G2
N124539694: length 1.5
  BOTTOM w0.081: 26.81,59.74 26.42,59.74 26.07,59.4 UT4.G11
  BOTTOM w0.14: 26.81,59.74 27.06,59.74 T187.1
N124539765: length 3
  TOP w0.14: v2(24.17,57.44) 24.17,57.31 24.6,56.88 v1(24.88,56.88) 25.39,56.88 25.72,57.2 RT182.1
  BOTTOM w0.081: v2(24.17,57.44) 24.17,57.6 UT4.D7
N124607348: length 3.6
  TOP w0.14: RT195.1 26.53,56.79 QV89.1 28,55.38 v1(28.87,54.52)
N124730498: length 5.7
  BOTTOM w0.081: 19.92,56.76 20.07,56.9 20.51,56.9 20.76,57.15 21.11,57.15 21.36,57.4 UT4.C2
  BOTTOM w0.14: 19.92,56.76 19.37,56.21 18.22,56.21 17.7,56.73 17.43,56.73 v1(17.34,56.64) RT178.1
N124730527: length 4.6
  BOTTOM w0.081: 20.78,55.47 20.78,55.52 21.12,55.86 21.12,56.65 UT4.B2
  BOTTOM w0.14: 20.78,55.47 20.78,55.4 20.35,54.97 20.35,53.7 20.17,53.51 T185.1
N124730838: length 165
  TOP w0.14: v3(114.43,48.78) 114.4,48.78 v2(114.4,49.44) ; v2(120.97,100.01) 120.97,100.01 JXDP.60 ; RH573.1 70,6.1 v2(70.13,6.23)
  IN4 w0.091: v2(120.97,100.01) 120.4,99.44 120.4,94.95 120.36,94.92 120.36,94.2 120.41,94.16 120.41,93.63 120.03,93.25 118.44,93.25 118.21,93.02 118.21,92.64 118.59,92.26 118.59,92.21 120.75,92.21 120.8,92.16 121.16,92.16 121.21,92.21 121.39,92.21 122.07,91.53 122.15,91.53 122.43,91.25 122.43,86.93 124.07,85.29 124.07,71.42 121.25,68.6 121.25,67.47 117.04,63.27 117.04,52.92 114.4,50.28 v2(114.4,49.44)
  IN5 w0.089: 77.2,18.5 76.66,19.05 75.06,19.05
  IN5 w0.099: 75.06,19.05 72.28,19.05 71.51,19.81 67.31,19.81 66.96,20.16 64.96,20.16 64.75,20.37 63.46,20.37 62.29,21.54 60.45,21.54 59.5,20.58 58.74,20.58 57.57,19.41 57.57,15.48 56.57,14.47 56.57,12.1 57.21,11.45 57.21,9.41 57.65,8.98 57.65,8.46 58.04,8.07 58.36,8.07 58.89,8.61 59.67,8.61 61.2,7.07 65.03,7.07 65.83,6.27 70.09,6.27 v2(70.13,6.23) ; 77.2,18.5 78.18,18.5 79.38,19.69 79.71,19.69 82.4,22.39 82.4,23.35 84.33,25.28 86.77,25.28 88.8,27.31 92.58,27.31 103.07,37.8 108.26,37.8 114.4,43.95 v2(114.4,49.44)
