# Allegro board Dell XPS 9560 LA-E331P R10.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_D3: length 28.7
  IN6 w0.102: v2(228.83,97.98) 228.58,97.74 ; v2(212.51,80.2) 213.39,81.08 213.39,83.03 214.62,84.26 214.62,85.47 215.09,85.94 215.09,87.34 215.14,87.39
  IN6 w0.117: 228.58,97.74 228.58,96.06 228.21,95.69 223.14,95.69 215.14,87.68 215.14,87.39
  BOTTOM w0.102: UV18.M28 212.91,80.6 v2(212.51,80.2) ; v2(228.83,97.98) 228.58,98.24 228.55,98.24 UV23.B2
FBA_D4: length 28.6
  IN6 w0.098: 227.85,99.96 227.71,99.96 227.61,100.06 226.77,100.06
  IN6 w0.102: 227.85,99.96 229.19,99.96 v2(229.61,100.38) ; v2(211.66,83.5) 212,83.83 212,85.45 212.41,85.87 212.41,87.02 212.3,87.14
  IN6 w0.117: 212.3,87.14 212.3,88.05 224.3,100.06 226.77,100.06
  BOTTOM w0.102: UV18.N31 212.06,83.1 v2(211.66,83.5) ; UV23.E4 v2(229.61,100.38)
FBA_D5: length 30.4
  IN6 w0.102: 226.79,100.76 228.43,100.76 v2(228.81,100.38) ; v2(211.66,81.87) 211.66,82.11 211.23,82.54 211.23,83.7 211.21,83.73 211.21,86.31 211.54,86.64
  IN6 w0.117: 226.79,100.76 224.26,100.76 211.77,88.27 211.77,86.88 211.54,86.64
  BOTTOM w0.102: UV23.E2 v2(228.81,100.38) ; UV18.P29 v2(211.66,81.87)
FBA_D6: length 34.8
  IN6 w0.102: v2(210.84,81.02) 210.44,81.42 210.44,82.11 209.61,82.94 209.61,84.74 209.31,85.05 209.31,85.37 210.72,86.78 210.72,88.7 210.81,88.79 ; v2(229.61,101.98) 229.26,102.33 228.26,102.33 228.23,102.36 226.77,102.36
  IN6 w0.117: 210.81,88.79 224.38,102.36 226.77,102.36
  BOTTOM w0.102: v2(210.84,81.02) 210.44,81.42 UV18.R29 ; v2(229.61,101.98) 229.61,101.98 UV23.F4
FBA_D7: length 32.8
  IN6 w0.102: 210.43,83.79 210.43,85.98 211.28,86.83 211.28,88.52 ; 210.43,82.49 210.6,82.32 210.98,82.32 211.28,82.02 211.28,81.4 v2(211.66,81.02) ; v2(228.81,101.94) 228.43,101.56 227.67,101.56
  IN6 w0.117: 211.28,88.52 224.33,101.56 227.67,101.56
  IN6 w0.119: 210.43,82.49 210.43,83.79
  BOTTOM w0.102: UV23.F2 228.78,101.94 v2(228.81,101.94) ; UV18.P28 v2(211.66,81.02)
FBA_D8: length 31
  IN6 w0.102: 233.33,97.18 235.12,97.18 v2(235.21,97.26) ; v2(215.03,80.2) 215.06,80.24 215.06,81.39 215.44,81.77 215.44,83.66
  IN6 w0.117: 233.33,97.18 232.91,97.18 226.66,90.93 221.56,90.93 217.67,87.04 217.67,87.04 217.36,86.72 216.97,86.72 216.09,85.84 216.09,85.52 215.67,85.1 215.67,83.89 215.44,83.66
  BOTTOM w0.102: UV18.J28 215.42,80.6 v2(215.03,80.2) ; v2(235.21,97.26) 235.3,97.26 UV23.A11
FBA_D9: length 29.9
  IN6 w0.102: v2(236.81,97.98) 236.81,97.31 236.42,96.92 ; v2(216.63,81.87) 216.63,83.73 217.94,85.05 217.94,85.82 218.06,85.94
  IN6 w0.117: 218.06,85.94 218.82,86.7 218.82,86.71 220.8,88.69 226.33,88.69 233.87,96.22 235.72,96.22 236.42,96.92
  BOTTOM w0.102: v2(216.63,81.87) 216.63,81.84 UV18.H29
  BOTTOM w0.107: UV23.A13 v2(236.81,97.98)
FBA_D10: length 31
  IN6 w0.102: v2(236.01,97.98) 235.62,97.58 235.62,96.92 ; v2(215.79,81.02) 216.25,81.49 216.25,85.35 216.6,85.69 217.03,85.69 217.43,86.1
  IN6 w0.117: 235.62,96.92 235.44,96.74 233.22,96.74 226.88,90.4 221.78,90.4 218.3,86.93 218.3,86.92 217.47,86.1 217.43,86.1
  BOTTOM w0.102: UV18.J29 215.44,81.38 v2(215.79,81.02)
  BOTTOM w0.107: UV23.B11 v2(236.01,97.98)
FBA_D11: length 34.4
  IN6 w0.102: v2(216.66,81.02) 216.66,81.36 217.01,81.71 217.01,82.37 216.93,82.46 216.93,83.74 217.68,84.49 218.24,84.49 219.35,85.59 219.35,85.62 ; v2(237.61,98.78) 237.4,98.78 237.02,99.16 236.66,99.16 236.43,98.93 236.43,98.62 236.66,98.4 237.02,98.4 237.36,98.05 237.36,97.12
  IN6 w0.117: 237.36,97.12 235.94,95.7 234.08,95.7 226.55,88.16 221.02,88.16 219.35,86.49 219.35,85.62
  BOTTOM w0.102: UV18.H28 v2(216.66,81.02)
  BOTTOM w0.107: UV23.B13 v2(237.61,98.78)
FBA_D12: length 36.9
  IN6 w0.102: v2(235.21,100.38) 235.63,99.96 238,99.96 ; v2(217.66,81.86) 217.96,82.16 217.96,83.66 218.18,83.88 218.58,83.88 219.68,84.98 220.12,84.98 220.66,85.52 221.26,85.52 221.49,85.29 222.07,85.29 222.17,85.38
  IN6 w0.117: 238,99.96 238.32,99.64 238.37,99.64 239.23,98.79 239.23,96.7 236.66,94.13 234.73,94.13 227.05,86.45 223.06,86.45 222.26,85.64 222.26,85.48 222.17,85.38
  BOTTOM w0.102: UV18.G29 217.09,81.45 217.5,81.86 v2(217.66,81.86)
  BOTTOM w0.107: UV23.E11 v2(235.21,100.38)
FBA_D13: length 33.7
  IN6 w0.098: 222.55,84.76 222.29,84.76
  IN6 w0.102: 222.67,84.88 222.55,84.76 ; 222.29,84.76 220.19,84.76 220.17,84.78 219.77,84.78 218.49,83.5 v2(218.34,83.5) ; 238.84,100.16 238.7,100.02 238.23,100.02 237.88,100.38 v2(237.61,100.38)
  IN6 w0.117: 222.67,84.88 222.95,84.88 223.99,85.92 227.27,85.92 234.95,93.61 236.87,93.61 239.75,96.48 239.75,99.74 239.33,100.16 238.84,100.16
  BOTTOM w0.102: v2(218.34,83.5) UV18.E31
  BOTTOM w0.107: UV23.E13 v2(237.61,100.38)
FBA_D14: length 39.8
  IN6 w0.102: v2(236.01,101.18) 236.41,101.57 238.75,101.57 ; 223.9,84.36 223.31,83.77 222.22,83.77 221.47,83.01 220.69,83.01 220.44,83.26 220.44,83.56 220.22,83.79 219.6,83.79 v2(219.2,83.38)
  IN6 w0.117: 223.9,84.36 224.42,84.88 227.7,84.88 235.38,92.56 238.09,92.56 241.62,96.08 241.62,99.47 239.52,101.57 238.75,101.57
  BOTTOM w0.102: v2(219.2,83.38) 219.2,83.46 218.76,83.9 UV18.E32
  BOTTOM w0.107: UV23.F11 v2(236.01,101.18)
FBA_D15: length 37.9
  IN6 w0.102: v2(236.81,101.18) 237.19,100.8 238.64,100.8 238.71,100.87 ; 223.27,84.46 222.77,83.97 222.14,83.97 222.08,83.92 220.37,83.92 220.3,83.99 219.27,83.99 218.82,83.54 218.82,83.18 v2(218.34,82.7)
  IN6 w0.117: 223.27,84.46 224.2,85.4 227.48,85.4 235.17,93.08 237.88,93.08 241.1,96.3 241.1,99.25 239.48,100.87 238.71,100.87
  BOTTOM w0.102: UV18.F30 v2(218.34,82.7)
  BOTTOM w0.107: UV23.F13 v2(236.81,101.18)
FBA_D16: length 43.4
  IN1 w0.102: 225.43,86.94 223.28,86.94 222.01,85.67 v2(221.81,85.67) ; v2(235.88,110.8) 235.57,110.8 234.83,110.06 234.83,109.02 235.06,108.8 238.44,108.8 238.84,108.4
  IN1 w0.117: 238.84,108.4 240.05,107.19 240.05,97.39 237.92,95.27 235.49,95.27 227.16,86.94 225.43,86.94
  BOTTOM w0.102: v2(235.88,110.8) 235.88,110.65 UV23.U11 ; v2(221.81,85.67) 221.62,85.86 221.04,85.86 220.68,85.5 UV18.C34
FBA_D17: length 43.8
  IN1 w0.102: v2(220.01,84.39) 220.36,84.74 221.8,84.74 222,84.95 224.1,84.95 225.04,85.89 225.43,85.89
  IN1 w0.117: 225.43,85.89 227.64,85.89 235.97,94.22 238.36,94.22 238.85,94.72 239.51,94.72 240.85,96.06 241.1,96.43 241.1,96.83 241.09,96.83 241.09,102.65 241.96,103.52 241.96,106.76 239.02,109.7 239.02,109.76 238.8,109.97 v2(237.65,109.97)
  BOTTOM w0.102: v2(220.01,84.39) 220.01,84.39 219.59,83.96 UV18.D32 ; v2(237.65,109.97) 237.24,110.38 UV23.U13
FBA_D18: length 46.7
  IN1 w0.102: 225.43,85.37 224.81,85.37 224.17,84.73 222.07,84.73 v2(221.64,84.3) ; 236.45,110.37 236.4,110.42 235.73,110.42 v2(235.24,109.93)
  IN1 w0.117: 236.45,110.37 237.42,110.37 237.43,110.36 238.53,110.36 238.62,110.46 239.06,110.46 239.14,110.37 239.76,110.37 239.76,110.37 240.11,110.37 240.35,110.13 240.35,109.11 242.49,106.97 242.49,103.3 241.62,102.43 241.62,97.05 241.62,97.04 241.62,96.27 241.26,95.72 239.73,94.19 239.07,94.19 238.57,93.7 236.18,93.7 227.85,85.37 225.43,85.37
  BOTTOM w0.102: UV18.B33 v2(221.64,84.3) ; UV23.T11 235.59,109.58 v2(235.24,109.93)
FBA_D19: length 41.7
  IN1 w0.098: 224.29,86.41 223.04,85.16 221.93,85.16
  IN1 w0.102: 224.29,86.41 225.43,86.41 ; 221.93,85.16 221.74,84.97 221.36,84.97 221.19,85.14 v2(220.81,85.14) ; 238.84,109.14 238.78,109.2 237.59,109.2 v2(236.85,109.93)
  IN1 w0.117: 238.84,109.14 241.44,106.54 241.44,103.74 240.57,102.87 240.57,97.17 238.14,94.74 235.71,94.74 227.38,86.41 225.43,86.41
  BOTTOM w0.102: UV23.T13 236.86,109.93 v2(236.85,109.93) ; UV18.C33 220.44,84.76 v2(220.81,85.14)
FBA_D20: length 42.2
  IN1 w0.102: 232.5,96.92 233.13,97.54 233.74,97.54 234.63,98.43 234.63,99.96 233.91,100.69 233.91,107.17 v2(234.38,107.64) ; 221.83,89.04 220.48,87.69 217.04,87.69 216.28,86.94 216.28,85.02 216.52,84.78 216.88,84.78 218.31,86.21 v2(218.92,86.21)
  IN1 w0.117: 221.83,89.04 224.31,91.53 227.31,91.53 232.17,96.39 232.17,96.59 232.5,96.92
  BOTTOM w0.102: v2(234.38,107.64) 235.15,107.64 UV23.N11 ; v2(218.92,86.21) 218.62,86.21 218.24,85.83 217.8,85.83 217.61,85.64 217.61,85.36 217.94,85.03 UV18.F33
FBA_D21: length 36.7
  IN1 w0.102: v2(236.86,106.75) 236.41,106.31 236.41,98.62 236.16,98.37 235.14,98.37 234.83,98.06 234.83,97.57 234.18,96.92 ; 223.53,88.82 221.65,86.94 221.33,86.94 221.11,87.16 221.11,87.19 221.01,87.29 218.09,87.29 217.05,86.25 v2(217.04,86.25)
  IN1 w0.117: 234.18,96.92 226.42,89.16 223.87,89.16 223.53,88.82
  BOTTOM w0.102: v2(236.86,106.75) 237.21,107.11 UV23.N13 ; UV18.F32 217.94,83.95 217.61,84.28 217.61,84.92 217.37,85.15 217.37,85.47 217.04,85.8 v2(217.04,86.25)
FBA_D22: length 34.5
  IN1 w0.102: 233.18,96.92 233.43,97.17 233.81,97.17 234.63,97.99 234.63,98.14 234.84,98.35 234.84,98.61 234.83,98.62 234.83,104.04 235.64,104.85 235.64,105.64 v2(235.26,106.02) ; 221.48,87.88 221.09,87.49 217.12,87.49 216.49,86.86 216.49,85.58 v2(216.75,85.31)
  IN1 w0.117: 221.48,87.88 224.49,90.89 227.41,90.89 232.98,96.46 232.98,96.72 233.18,96.92
  BOTTOM w0.102: UV18.H33 216.73,85.19 216.73,85.28 v2(216.75,85.31) ; v2(235.26,106.02) UV23.M11
FBA_D23: length 38.5
  IN1 w0.102: v2(237.62,106.75) 237.21,106.35 237.21,97.7 236.43,96.92 ; v2(215.84,83.45) 216.47,83.45 217.11,84.08 217.11,84.43 218.33,85.66 218.92,85.66 219.38,86.11 219.38,86.73 219.73,87.08 220.9,87.08 221.25,86.74 221.81,86.74 223.66,88.59 225.43,88.59
  IN1 w0.117: 236.43,96.92 236.35,96.84 234.84,96.84 226.59,88.59 225.43,88.59
  BOTTOM w0.102: UV23.M13 237.59,106.75 v2(237.62,106.75) ; v2(215.84,83.45) 216.24,83.85 UV18.H32
FBA_D24: length 39
  IN1 w0.097: 211.53,89.04 210.63,88.14 210.63,86.85
  IN1 w0.102: v2(210.82,85.1) 210.63,85.29 210.63,86.85
  IN1 w0.117: 211.53,89.04 214.31,91.82 215.74,91.82 221.62,97.7 221.62,106.53 226.42,111.32 228.79,111.32 229.36,110.76 v2(230.38,110.76)
  BOTTOM w0.102: v2(210.82,85.1) 211.22,85.5 UV18.P34
  BOTTOM w0.221: UV23.U4 230.01,110.39 v2(230.38,110.76)
FBA_D25: length 36.1
  IN1 w0.102: 213.75,89.04 213.68,89.04 211.39,86.75 211.39,85.73 211.63,85.49 211.63,84.33 v2(211.59,84.28) ; 226.77,109.32 226.81,109.32 226.91,109.23 228.41,109.23 228.76,109.58 v2(228.76,110.02)
  IN1 w0.117: 213.75,89.04 214.96,90.25 216.39,90.25 224.46,98.31 224.46,107.14 226.64,109.32 226.77,109.32
  BOTTOM w0.102: v2(228.76,110.02) 228.76,110.03 UV23.U2 ; v2(211.59,84.28) 211.24,83.93 UV18.P32
FBA_D26: length 39.9
  IN1 w0.098: 213.01,89.04 211.19,87.22 211.19,86.84
  IN1 w0.102: v2(230.37,109.93) 229.94,110.36 228.97,110.36 228.92,110.4 228.61,110.4 228.35,110.14 228.35,109.77 228.13,109.55 228.1,109.55 228.04,109.5 227.77,109.5 227.27,109.99 226.77,109.99 ; 211.19,86.84 211.19,85.68 211.19,85.68 211.19,85.65 211.43,85.41 211.43,84.76 211.2,84.53 211.2,83.89 v2(210.85,83.54)
  IN1 w0.117: 226.77,109.99 226.57,109.99 223.71,107.13 223.71,107.11 223.47,106.87 223.47,106.38 223.45,106.36 223.45,98.04 216.18,90.77 214.74,90.77 213.01,89.04
  BOTTOM w0.102: UV18.P31 211.24,83.16 v2(210.85,83.54)
  BOTTOM w0.221: UV23.T4 230.02,109.58 v2(230.37,109.93)
FBA_D27: length 37
  IN1 w0.097: 210.99,86.92 210.99,87.76 212.27,89.04
  IN1 w0.102: 210.99,86.92 210.99,85.6 210.99,85.6 210.99,85.56 211.23,85.32 211.23,84.84 210.81,84.43 v2(210.81,84.29) ; 226.77,110.67 226.9,110.79 227.24,110.79 227.48,110.55 227.48,110.42 v2(227.97,109.93)
  IN1 w0.117: 226.77,110.67 226.51,110.67 222.94,107.1 222.94,106.6 222.15,105.8 222.15,97.48 215.96,91.29 214.52,91.29 212.27,89.04
  BOTTOM w0.102: v2(210.81,84.29) 210.83,84.29 UV18.P33 ; v2(227.97,109.93) 228.06,109.93 UV23.T2
FBA_D28: length 38
  IN1 w0.098: 217.41,89.04 217.36,88.99
  IN1 w0.102: 226.77,106.87 226.84,106.87 226.89,106.81 227.24,106.81 227.63,107.2 229.73,107.2 229.99,106.94 229.99,106.93 230.1,106.83 v2(230.37,106.83) ; 217.36,88.99 215.48,88.99 214.11,87.62 213.31,87.62 212.58,86.9 212.58,86.59 212.45,86.46 212.45,85.44 212.71,85.17 212.71,84.89 212.97,84.63 212.97,83.19 v2(212.54,82.75)
  IN1 w0.117: 217.41,89.04 226.02,97.66 226.02,106.4 226.49,106.87 226.77,106.87
  BOTTOM w0.102: UV18.L31 213.65,83.1 213.3,82.75 v2(212.54,82.75) ; v2(230.37,106.83) 230.36,106.83 UV23.N4
FBA_D29: length 37.9
  IN1 w0.102: v2(213.23,86.13) 213.23,86.69 213.55,87 214.41,87 215.74,88.34 218.93,88.34 219.63,89.04 ; v2(228.81,108.29) 229.64,107.45 230,107.45 230.19,107.26 231.05,107.26 231.84,106.47 231.84,104.97 230.95,104.09 230.95,97.69 230.17,96.92
  IN1 w0.117: 230.17,96.92 229.1,95.84 226.43,95.84 219.63,89.04
  BOTTOM w0.102: v2(228.81,108.29) 228.79,108.28 228.79,107.77 228.41,107.39 UV23.N2 ; v2(213.23,86.13) 213.28,86.13 213.74,85.68 UV18.L34
FBA_D30: length 37.1
  IN1 w0.098: 218.14,89.04 217.88,88.79
  IN1 w0.102: 217.88,88.79 215.56,88.79 214.19,87.42 213.39,87.42 212.78,86.81 212.78,86.51 212.65,86.37 212.65,85.52 212.92,85.26 212.92,84.97 213.35,84.53 v2(213.35,84.27) ; v2(231.29,105.8) 230.69,106.4 229.77,106.4 229.77,106.4 229.45,106.4 229.42,106.43 228.7,106.43 228.55,106.58 226.91,106.58 226.8,106.48 226.8,106.37 226.77,106.34
  IN1 w0.117: 218.14,89.04 218.15,89.04 226.55,97.44 226.55,106.12 226.77,106.34
  BOTTOM w0.102: v2(231.29,105.8) 231.27,105.8 231.08,105.99 230.4,105.99 UV23.M4 ; UV18.L32 213.36,84.27 v2(213.35,84.27)
FBA_D31: length 32.7
  IN1 w0.098: 226.77,96.93 226.83,96.98
  IN1 w0.102: v2(227.14,106.18) 227.59,105.74 227.59,105.01 227.48,104.91 226.99,104.91 226.83,104.75 226.83,96.98 ; v2(213.31,85.13) 213.31,85.15 212.85,85.61 212.85,86.29 212.99,86.42 212.99,86.73 213.47,87.21 214.27,87.21 215.65,88.58 218.43,88.58 218.89,89.04
  IN1 w0.117: 218.89,89.04 226.77,96.93
  BOTTOM w0.102: v2(213.31,85.13) UV18.L33 ; UV23.M2 228.41,106.69 228.22,106.88 227.84,106.88 227.71,106.75 227.39,106.75 227.08,106.43 227.08,106.24 v2(227.14,106.18)
FBA_D32: length 24
  IN6 w0.102: 203.1,88.79 202.86,88.55 202.86,85.46 200.9,83.5 v2(200.9,81.86) ; 210.8,96.92 211.48,97.59 212.51,97.59 212.89,97.98 v2(213.15,97.98)
  IN6 w0.117: 203.1,88.79 203.1,89.22 210.8,96.92
  BOTTOM w0.102: UV24.U4 v2(213.15,97.98) ; UV18.AG28 200.87,81.03 200.87,81.81 200.9,81.85 v2(200.9,81.86)
FBA_D33: length 22.4
  IN6 w0.102: 204.09,88.59 203.26,87.77 203.26,85.1 202.06,83.9 202.06,82.28 v2(201.66,81.87)
  IN6 w0.117: 204.09,88.59 204.09,88.73 212.02,96.66 213.43,96.66 v2(213.95,97.18)
  BOTTOM w0.102: UV24.U2 v2(213.95,97.18) ; UV18.AF29 v2(201.66,81.87)
FBA_D34: length 24.1
  IN6 w0.102: v2(199.94,81.02) 200.39,81.47 200.39,83.27 202.57,85.46 202.57,88.79 ; 210.99,97.85 211.12,97.98 v2(212.35,97.98)
  IN6 w0.117: 210.99,97.85 202.57,89.43 202.57,88.79
  BOTTOM w0.102: v2(199.94,81.02) 200.37,81.45 UV18.AG29 ; UV24.T4 v2(212.35,97.98)
FBA_D35: length 24.4
  IN6 w0.102: 211.59,96.97 212.41,96.97 212.96,97.52 213.5,97.52 v2(213.95,97.98) ; 203.42,88.57 203.06,88.21 203.06,85.37 201.2,83.51 201.2,82.4 201.28,82.32 201.28,81.4 v2(201.66,81.02)
  IN6 w0.117: 211.59,96.97 203.62,89 203.62,88.77 203.42,88.57
  BOTTOM w0.102: UV24.T2 v2(213.95,97.98) ; UV18.AF28 v2(201.66,81.02)
FBA_D36: length 29
  IN6 w0.102: 207.4,88.79 207.4,87.2 204.9,84.7 204.04,84.7 203.51,84.16 203.51,83.62 202.83,82.94 202.83,82.21 v2(202.51,81.89) ; v2(213.15,101.18) 213.15,101.05 213.57,100.64 213.57,100.22 213.8,100 215.09,100 215.66,99.43 215.66,96.92
  IN6 w0.117: 215.66,96.92 215.66,96.66 214.08,95.09 212.67,95.09 207.4,89.82 207.4,88.79
  BOTTOM w0.102: UV24.N4 v2(213.15,101.18) ; v2(202.51,81.89) 202.53,81.89 UV18.AD30
FBA_D37: length 31
  IN6 w0.102: 208.45,88.79 208.45,87.56 208.09,87.21 208.09,86.28 206.52,84.71 206.49,84.71 204.6,82.82 204.6,82.54 204.29,82.24 203.95,82.24 203.72,82.01 203.72,81.75 203.02,81.05 202.62,81.05 v2(202.38,81.29) ; 215.98,100.49 214.89,101.58 214.35,101.58 v2(213.95,101.18)
  IN6 w0.117: 215.98,100.49 216.7,99.76 216.7,96.23 214.52,94.04 213.1,94.04 208.45,89.39 208.45,88.79
  BOTTOM w0.102: UV18.AD29 202.91,81.45 202.75,81.29 v2(202.38,81.29) ; UV24.N2 v2(213.95,101.18)
FBA_D38: length 30.1
  IN6 w0.102: v2(213.15,101.98) 213.55,101.58 213.55,101.04 213.8,100.8 214.88,100.8 ; v2(203.32,81.88) 203.32,81.89 203.71,82.29 203.71,83.58 204.02,83.89 205.3,83.89 206.45,85.05 206.57,85.05 207.82,86.31 207.82,87.46 207.92,87.56
  IN6 w0.117: 207.92,87.56 207.92,89.6 212.88,94.56 214.3,94.56 216.18,96.44 216.18,99.5 214.88,100.8
  BOTTOM w0.102: UV24.M4 v2(213.15,101.98)
  BOTTOM w0.127: v2(203.32,81.88) 203.74,81.46 UV18.AC29
FBA_D39: length 31.9
  IN6 w0.102: 209.7,88.45 209.7,86.62 208.31,85.23 207.88,85.23 206.41,83.76 206.41,83.53 205.19,82.31 204.91,82.31 204.6,82 204.6,81.81 202.94,80.15 202.51,80.15 ; v2(214.75,101.98) 215.23,101.98
  IN6 w0.117: 215.23,101.98 217.23,99.98 217.23,96.01 214.73,93.52 213.32,93.52 209.7,89.9 209.7,88.45 ; 202.51,80.15 v2(202.5,80.15)
  BOTTOM w0.102: UV24.M2 v2(214.75,101.98) ; v2(202.5,80.15) 202.5,80.19 202.91,80.6 UV18.AD28
FBA_D40: length 21.3
  IN6 w0.102: v2(207.55,97.98) 207.44,97.98 206.38,96.92 ; v2(198.21,81.82) 198.62,82.22 198.62,82.95 199.25,83.59 199.25,87.85 200.05,88.65
  IN6 w0.117: 206.38,96.92 206.38,96.79 200.05,90.45 200.05,88.65
  BOTTOM w0.102: UV18.AJ29 198.59,81.45 v2(198.21,81.82) ; UV24.U11 v2(207.55,97.98)
FBA_D41: length 21.1
  IN6 w0.102: v2(197.44,81.8) 197.44,82.14 198.21,82.91 198.21,83.12 198.72,83.63 198.72,85.89 198.63,85.98 198.63,88.53 198.88,88.79 ; v2(205.95,97.98) 205.95,97.59 205.71,97.35 205.44,97.35
  IN6 w0.117: 205.44,97.35 204.81,96.72 204.81,96.7 198.89,90.78 198.89,88.8 198.88,88.79
  BOTTOM w0.102: UV24.U13 v2(205.95,97.98) ; UV18.AK29 v2(197.44,81.8)
FBA_D42: length 22.3
  IN6 w0.102: v2(207.55,98.78) 207.93,98.4 207.93,97.52 207.33,96.92 ; v2(199.16,81.87) 198.82,82.22 198.82,82.87 199.54,83.59 199.54,85.93 199.45,86.02 199.45,87.46 200.47,88.48
  IN6 w0.117: 200.47,88.48 200.57,88.58 200.57,90.24 207.25,96.92 207.33,96.92
  BOTTOM w0.102: UV18.AJ30 v2(199.16,81.87) ; UV24.T11 v2(207.55,98.78)
FBA_D43: length 22.9
  IN6 w0.102: v2(198.26,80.97) 197.83,81.41 197.83,82.09 198.41,82.68 198.41,83.04 199.05,83.67 199.05,88.1 199.45,88.49 ; 205.75,96.92 206.36,97.53 206.36,98.37 v2(205.95,98.78)
  IN6 w0.117: 205.75,96.92 205.75,96.89 199.45,90.6 199.45,88.49
  BOTTOM w0.102: UV18.AK28 v2(198.26,80.97) ; UV24.T13 v2(205.95,98.78)
FBA_D44: length 26.5
  IN6 w0.102: 203.91,98.88 204.99,99.96 205.31,99.96 205.57,100.21 205.57,100.53 205.79,100.76 207.13,100.76 v2(207.55,101.18) ; v2(196.62,81.8) 196.26,82.17 196.26,82.85 196.49,83.09 196.83,83.09 197.05,83.31 197.05,88.54 197.01,88.58
  IN6 w0.117: 203.91,98.88 203.91,98.02 197.01,91.12 197.01,88.58
  BOTTOM w0.102: v2(196.62,81.8) 196.24,81.41 UV18.AM29 ; UV24.N11 v2(207.55,101.18)
FBA_D45: length 24.2
  IN6 w0.102: 203.91,99.68 205.02,100.78 205.53,100.78 205.93,101.18 v2(205.95,101.18) ; v2(195.84,82.65) 195.84,82.81 196.22,83.19 196.22,84.72 196.28,84.78 196.28,88.15 196.49,88.35
  IN6 w0.117: 203.91,99.68 203.17,98.93 203.17,98.02 196.49,91.34 196.49,88.35
  BOTTOM w0.102: UV24.N13 v2(205.95,101.18) ; UV18.AM31 196.24,83.05 v2(195.84,82.65)
FBA_D46: length 29.3
  IN6 w0.098: 194.41,86.27 194.41,83.56
  IN6 w0.102: v2(207.57,101.97) 207.18,102.36 204.71,102.36 204.6,102.24 ; v2(195.04,81.8) 194.41,82.43 194.41,83.56
  IN6 w0.117: 194.41,86.27 194.5,86.37 194.5,87.12 194.48,87.14 194.48,92.12 204.6,102.24
  BOTTOM w0.102: v2(195.04,81.8) 195.04,81.8 195.44,81.4 UV18.AN29 ; v2(207.57,101.97) 207.57,101.94 207.21,101.58 UV24.M11
FBA_D47: length 27.4
  IN6 w0.102: v2(195.84,81.77) 195.37,82.24 194.88,82.24 194.62,82.5 194.62,83.88 196.03,85.29 196.03,87.89 ; 203.91,100.82 204.65,101.56 205.53,101.56 v2(205.95,101.98)
  IN6 w0.117: 203.91,100.82 195.96,92.87 195.96,87.95 196.03,87.89
  BOTTOM w0.102: v2(195.84,81.77) 196.24,82.17 UV18.AM30 ; UV24.M13 v2(205.95,101.98)
FBA_D48: length 37.3
  IN1 w0.102: 203.91,110.72 204.21,111.01 ; 205.5,111.01 205.58,110.92 205.82,110.92 v2(206.76,109.99)
  IN1 w0.117: 203.91,110.72 200.62,107.42 200.62,104.65 200.61,104.65 200.61,102.94 199.22,101.54 199.22,97.51 193.04,91.34 193.04,85.28 v2(195,83.33) ; 205.5,111.01 205.37,111.14 204.34,111.14 204.21,111.01
  BOTTOM w0.102: v2(206.76,109.99) 207.14,110.38 UV24.A11 ; UV18.AN31 195.16,83.33 v2(195,83.33)
FBA_D49: length 34.1
  IN1 w0.102: v2(205.11,110.75) 205.1,110.75 204.69,110.75 203.91,109.98
  IN1 w0.117: v2(195.78,84.29) 194.78,84.29 193.57,85.5 193.57,91.12 199.74,97.29 199.74,101.33 201.14,102.72 201.14,104.43 201.14,104.43 201.14,107.2 203.91,109.98
  BOTTOM w0.102: UV18.AN32 195.77,84.23 195.77,84.27 v2(195.78,84.29) ; v2(205.11,110.75) 205.17,110.75 205.54,110.38 UV24.A13
FBA_D50: length 40.2
  IN1 w0.102: v2(207.57,110) 207.33,110.24 207.33,110.73 207.05,111.01
  IN1 w0.117: 207.05,111.01 206.35,111.71 204.16,111.71 200.09,107.64 200.09,104.87 200.09,104.87 200.09,103.15 198.7,101.76 198.7,97.73 192.52,91.55 192.52,84.99 193.99,83.51 v2(193.99,83.5)
  BOTTOM w0.102: v2(207.57,110) UV24.B11 ; v2(193.99,83.5) 194.64,82.85 UV18.AP30
FBA_D51: length 31.6
  IN1 w0.102: 203.91,109.19 v2(205.17,109.19)
  IN1 w0.117: v2(194.09,86.81) 194.09,90.9 200.26,97.08 200.26,101.11 201.66,102.5 201.66,104.21 201.66,104.22 201.66,106.98 203.87,109.19 203.91,109.19
  BOTTOM w0.102: UV18.AP32 194.62,83.9 193.93,84.59 193.93,86.65 v2(194.09,86.81) ; v2(205.17,109.19) UV24.B13
FBA_D52: length 30.1
  IN1 w0.098: 204.11,105.56 204.99,105.56 204.99,105.56
  IN1 w0.102: 204.99,105.56 205.5,105.56 v2(205.93,105.99)
  IN1 w0.117: 204.11,105.56 203.69,105.15 203.69,104.03 203.23,103.56 203.23,101.28 202.26,100.31 202.26,95.86 199.93,93.53 198.93,93.53 196.49,91.08 196.49,88.2 197.29,87.39 197.29,84.97 v2(196.63,84.31)
  BOTTOM w0.102: v2(196.63,84.31) 196.24,84.7 UV18.AM33 ; v2(205.93,105.99) 205.93,106.4 206.22,106.69 206.3,106.69 206.79,107.18 UV24.E11
FBA_D53: length 32.2
  IN1 w0.102: 203.91,103.51 205.2,104.8 205.31,104.8 205.57,105.06 205.57,105.33 205.85,105.61 206.15,105.61 206.31,105.77 206.31,106.15 205.96,106.5 205.45,106.5 205.33,106.37 205.01,106.37 204.79,106.59 204.79,107.21 v2(205.15,107.58)
  IN1 w0.117: v2(196.67,83.47) 196.67,83.58 197.81,84.73 197.81,87.61 197.01,88.41 197.01,90.86 199.15,93 200.15,93 202.79,95.64 202.79,100.1 203.75,101.06 203.75,103.35 203.91,103.51
  BOTTOM w0.102: UV18.AL31 v2(196.67,83.47) ; v2(205.15,107.58) UV24.E13
FBA_D54: length 26.9
  IN1 w0.102: 204.19,103.15 205.83,104.8 206.11,104.8 206.33,105.02 206.33,105.3 206.76,105.72 v2(206.76,105.99)
  IN1 w0.117: 204.19,103.15 204.19,100.31 203.33,99.45 203.33,95.45 200.36,92.48 199.37,92.48 197.53,90.65 197.53,88.63 198.34,87.82 v2(198.34,85.1)
  BOTTOM w0.102: v2(198.34,85.1) UV18.AK33 ; UV24.F11 206.77,105.99 v2(206.76,105.99)
FBA_D55: length 31
  IN1 w0.102: v2(205.17,106.75) 205.49,107.07 206.31,107.07 207.17,106.21 207.17,104.94 207.02,104.8 206.59,104.8 206.33,104.53 206.33,104.22 206.11,104 205.71,104 204.77,103.05 204.77,97.82 204.79,97.8 204.79,96.92
  IN1 w0.117: 204.79,96.92 204.79,96.17 200.58,91.96 199.58,91.96 198.06,90.43 198.06,88.85 198.95,87.96 198.95,84.91 v2(198.31,84.27)
  BOTTOM w0.102: v2(205.17,106.75) 205.54,106.38 UV24.F13 ; UV18.AK32 v2(198.31,84.27)
FBA_D56: length 36.6
  IN1 w0.098: 212.55,109.99 v2(212.35,109.99)
  IN1 w0.102: 212.55,109.99 212.94,109.6 214.2,109.6 214.24,109.56 215.71,109.56 215.98,109.29 ; 206.54,89.42 205.17,88.05 205.17,87.07 204.65,86.56 v2(204.48,86.56)
  IN1 w0.117: 215.98,109.29 217.59,107.69 217.59,102.16 216.78,101.36 216.78,97.6 214.79,95.61 212.73,95.61 206.54,89.42
  BOTTOM w0.102: v2(204.48,86.56) 204.28,86.56 203.22,85.5 UV18.AD34 ; v2(212.35,109.99) 212.37,109.99 UV24.A4
FBA_D57: length 41.9
  IN1 w0.098: 215.98,110.61 215.35,109.98 v2(214.75,109.98)
  IN1 w0.102: 207.28,89.42 207.02,89.16 206.57,89.16 205.49,88.08 205.49,87.03 204.64,86.18 204.22,86.18 203.46,86.94 203.46,87.38 203.77,87.7 v2(203.77,87.72)
  IN1 w0.117: 207.28,89.42 212.95,95.09 215.01,95.09 217.31,97.39 217.31,101.14 218.11,101.94 218.11,108.89 216.39,110.61 215.98,110.61
  BOTTOM w0.102: v2(203.77,87.72) 203.77,87.7 203.46,87.38 203.46,86.53 202.96,86.03 202.72,86.03 202.4,85.72 202.4,85.32 202.31,85.23 202.31,84.94 202.42,84.84 202.42,84.56 202.41,84.55 202.41,84.42 UV18.AD32 ; UV24.A2 v2(214.75,109.98)
FBA_D58: length 46
  IN1 w0.102: 203.33,83.02 203.33,85.29 204.01,85.98 204.84,85.98 205.92,87.06 205.92,88.22 206.61,88.91 207.51,88.91 207.68,89.08 ; 215.58,111.01 215.19,110.63 212.41,110.63 211.96,110.18 211.96,109.74 212.09,109.61 212.46,109.61 212.9,109.17 v2(213.17,109.17)
  IN1 w0.117: 215.58,111.01 215.82,111.26 216.48,111.26 218.63,109.11 218.63,101.72 217.83,100.92 217.83,97.17 215.23,94.56 213.16,94.56 207.68,89.08 ; 203.33,83.02 v2(203.33,82.69)
  BOTTOM w0.102: UV18.AC30 203.72,82.3 v2(203.33,82.69) ; UV24.B4 213.17,109.17 v2(213.17,109.17)
FBA_D59: length 34
  IN1 w0.102: 205.8,89.42 204.66,88.28 v2(204.66,87.13) ; 215.98,108.55 215.77,108.76 215.17,108.76 v2(214.76,109.17) ; 215.98,97.54 215.36,96.92
  IN1 w0.117: 215.98,108.55 217.06,107.47 217.06,102.37 216.26,101.57 216.26,97.82 215.98,97.54 ; 205.8,89.42 212.51,96.13 214.58,96.13 215.36,96.92
  BOTTOM w0.102: UV24.B2 214.35,109.57 v2(214.76,109.17) ; UV18.AD33 202.61,85.03 202.61,85.64 202.8,85.83 203.17,85.83 204.37,87.03 204.56,87.03 v2(204.66,87.13)
FBA_D60: length 32.6
  IN1 w0.102: 199.46,88.28 199.46,87.14 v2(199.84,86.76) ; 208.86,96.92 209.96,98.02 209.96,105.76 210.97,106.77 212.35,106.77 v2(212.39,106.82)
  IN1 w0.117: 199.46,88.28 199.46,89.14 203.02,92.7 204.64,92.7 208.2,96.26 208.2,96.26 208.86,96.92
  BOTTOM w0.102: v2(199.84,86.76) 200.28,86.32 200.28,85.92 200.05,85.69 200.05,83.81 200.43,83.43 200.91,83.43 UV18.AF31 ; v2(212.39,106.82) UV24.E4
FBA_D61: length 29.9
  IN1 w0.102: v2(213.95,107.58) 213.53,107.16 213.53,106.62 213.31,106.4 213.03,106.4 212.77,106.13 212.77,105.82 212.51,105.56 211.91,105.56 210.69,104.34 210.69,97.27 210.34,96.92
  IN1 w0.117: 210.34,96.92 205.08,91.65 203.45,91.65 200.51,88.71 200.51,87.41 200.78,87.14 v2(200.78,86.18)
  BOTTOM w0.102: UV18.AG34 200.78,85.84 v2(200.78,86.18) ; v2(213.95,107.58) UV24.E2
FBA_D62: length 29.5
  IN1 w0.102: v2(212.36,105.98) 211.95,105.98 210.38,104.4 210.38,97.7 209.6,96.92
  IN1 w0.117: v2(200.85,84.34) 200.81,84.34 200.28,84.87 200.28,87.13 199.98,87.43 199.98,88.92 203.24,92.18 204.86,92.18 209.6,96.92
  BOTTOM w0.102: UV18.AG32 200.85,84.31 v2(200.85,84.34) ; UV24.F4 v2(212.36,105.98)
FBA_D63: length 29.6
  IN1 w0.102: 200.89,85.07 200.95,85.07 201.36,85.48 201.36,87.19 201.03,87.52 201.03,87.85 ; v2(214.76,106.05) 214.69,106.05 214.2,105.56 213.8,105.56 213.57,105.33 213.57,104.93 213.4,104.76 213,104.76 212.77,104.53 212.77,103.73 211,101.96 211,96.92
  IN1 w0.117: 211,96.92 211,96.84 205.29,91.13 203.67,91.13 201.03,88.49 201.03,87.85 ; 200.89,85.07 v2(200.81,85.07)
  BOTTOM w0.102: UV24.F2 214.43,106.38 v2(214.76,106.05) ; v2(200.81,85.07) UV18.AG33
FBA_DBI0#: length 26.8
  IN6 w0.102: 212.82,87.14 212.61,86.93 212.61,84.89 212.2,84.48 212.2,83.73 212.13,83.66 212.13,83.17 v2(211.66,82.7)
  IN6 w0.117: v2(228.01,99.58) 227.51,99.07 224.05,99.07 212.82,87.84 212.82,87.14
  BOTTOM w0.102: UV23.D2 v2(228.01,99.58) ; v2(211.66,82.7) 211.26,82.3 UV18.P30
FBA_DBI1#: length 32.2
  IN6 w0.102: v2(217.51,83.5) 217.51,83.5 218.09,84.08 218.5,84.08 219.6,85.18 219.95,85.18 219.98,85.22 ; 238.84,98.86 238.51,99.2 237.36,99.2 236.98,99.58 v2(236.81,99.58)
  IN6 w0.117: 238.84,98.86 238.84,97.05 236.44,94.65 234.52,94.65 226.87,87 222.83,87 221.89,86.06 221.03,86.06 220.7,85.73 220.5,85.73 219.98,85.22
  BOTTOM w0.102: v2(217.51,83.5) 217.91,83.1 UV18.F31
  BOTTOM w0.107: UV23.D13 v2(236.81,99.58)
FBA_DBI2#: length 36.9
  IN1 w0.098: 222.04,86.29 219.81,86.29 v2(219.76,86.24)
  IN1 w0.102: 225.43,88.05 223.8,88.05 222.04,86.29 ; 238.84,106.37 238.71,106.5 238.69,106.5 v2(237.61,107.58)
  IN1 w0.117: 225.43,88.05 226.79,88.05 235.05,96.31 236.74,96.31 239,98.57 239,106.19 238.95,106.24 238.95,106.26 238.84,106.37
  BOTTOM w0.102: v2(219.76,86.24) 219.71,86.19 219.71,86.07 219.28,85.64 219.07,85.64 218.87,85.83 218.6,85.83 218.35,85.57 218.35,85.57 218.27,85.5 UV18.F34
  BOTTOM w0.107: UV23.P13 v2(237.61,107.58)
FBA_DBI3#: length 34.5
  IN1 w0.098: 214.49,89.04 213.78,88.32
  IN1 w0.102: v2(212.58,84.32) 211.84,85.06 211.84,85.58 211.6,85.82 211.6,86.67 213.25,88.32 213.78,88.32 ; v2(227.97,108.4) 227.94,108.38 226.77,108.38
  IN1 w0.117: 226.77,108.38 226.44,108.38 224.98,106.92 224.98,98.09 216.61,89.72 215.17,89.72 214.49,89.04
  BOTTOM w0.102: v2(212.58,84.32) 212.6,84.3 212.6,84.24 UV18.M32 ; UV23.P2 228.39,107.98 v2(227.97,108.4)
FBA_DBI4#: length 25.1
  IN6 w0.102: v2(202.45,82.68) 202.45,82.85 203.3,83.71 203.3,84.56 203.67,84.93 203.67,85.01 204.4,85.73 204.57,85.73 205.75,86.91 205.75,88.79 ; v2(213.95,99.58) 214.36,99.17 214.9,99.17 215.13,98.93 215.13,96.92
  IN6 w0.117: 205.75,88.79 205.75,88.9 212.45,95.61 213.87,95.61 215.13,96.88 215.13,96.92
  BOTTOM w0.102: UV24.P2 v2(213.95,99.58) ; UV18.AD31 202.92,83.1 202.5,82.68 v2(202.45,82.68)
FBA_DBI5#: length 24.6
  IN6 w0.102: 204.24,97.28 204.77,97.81 204.77,98.66 205.57,99.46 205.57,99.73 205.95,100.12 v2(205.95,100.38) ; 197.53,88.7 197.53,83.37 197.06,82.89 197.06,81.39 v2(196.64,80.97)
  IN6 w0.117: 197.53,88.7 197.53,90.9 203.91,97.28 204.24,97.28
  BOTTOM w0.102: UV18.AL29 197.04,81.37 v2(196.64,80.97) ; UV24.P13 v2(205.95,100.38)
FBA_DBI6#: length 31.9
  IN1 w0.102: 203.91,107.21 204.09,107.39 204.13,107.39 204.7,107.96 205.53,107.96 v2(205.95,108.38)
  IN1 w0.117: v2(195.84,83.51) 196.21,83.89 196.21,85.24 196.77,85.79 196.77,87.17 195.96,87.98 195.96,91.3 198.72,94.05 199.71,94.05 201.31,95.65 201.31,100.24 202.71,101.64 202.71,103.78 203.17,104.25 203.17,106.43 203.85,107.11 203.85,107.14 203.91,107.21
  BOTTOM w0.102: UV18.AM32 196.22,83.9 v2(195.84,83.51)
  BOTTOM w0.107: UV24.D13 v2(205.95,108.38)
FBA_DBI7#: length 32.9
  IN1 w0.098: 202.21,87.67 203.33,88.79
  IN1 w0.102: v2(201.42,87.67) 202.21,87.67 ; v2(214.75,108.38) 215.01,108.38 215.4,107.99 215.8,107.99 215.98,107.81 ; 214.62,96.92 215.77,98.07 215.77,103.77 215.98,103.97
  IN1 w0.117: 215.98,107.81 216.16,107.63 216.16,104.15 215.98,103.97 ; 214.62,96.92 214.36,96.66 212.3,96.66 205.12,89.48 204.02,89.48 203.33,88.79
  BOTTOM w0.102: v2(201.42,87.67) 201.42,87.62 201.42,86.64 201.24,86.46 UV18.AF34
  BOTTOM w0.107: UV24.D2 v2(214.75,108.38)
FBA_EDC0: length 26.5
  IN6 w0.102: 227.85,98.39 228.18,98.39 228.41,98.62 228.41,99.17 v2(228.81,99.58) ; v2(212.51,83.5) 212.96,83.95 212.96,84.93 212.85,85.04 212.85,86.56 212.91,86.61
  IN6 w0.117: 227.85,98.39 224.11,98.39 213.34,87.62 213.34,87.05 212.91,86.61
  BOTTOM w0.102: UV23.C2 v2(228.81,99.58) ; v2(212.51,83.5) 212.91,83.1 UV18.M31
FBA_EDC1: length 37.1
  IN6 w0.102: 219.97,85.74 219.87,85.74 218.41,84.29 217.76,84.29 217.13,83.66 217.13,82.54 217.22,82.46 217.22,81.29 217.04,81.12 217.04,80.87 216.82,80.64 215.53,80.64 215.27,80.91 215.27,81.31 v2(215.82,81.86) ; v2(236.81,98.78) 236.93,98.78 237.68,98.02 237.68,96.92
  IN6 w0.117: 237.68,96.92 237.68,96.7 236.16,95.18 234.3,95.18 226.76,87.64 222.63,87.64 221.58,86.58 220.81,86.58 219.97,85.74
  BOTTOM w0.102: v2(215.82,81.86) 215.82,82.35 216.1,82.63 216.62,82.63 UV18.G31
  BOTTOM w0.107: UV23.C13 v2(236.81,98.78)
FBA_EDC2: length 40.1
  IN1 w0.102: 238.83,96.92 238.84,96.92 ; 225.43,87.46 223.5,87.46 222.09,86.05 220.46,86.05 219.52,85.11 v2(218.33,85.11) ; 238.84,107.63 238.52,107.96 237.29,107.96 v2(236.84,108.4)
  IN1 w0.117: 225.43,87.46 226.94,87.46 235.27,95.79 237.7,95.79 238.83,96.92 ; 238.84,96.92 239.52,97.61 239.52,106.95 238.84,107.63
  BOTTOM w0.102: v2(236.84,108.4) UV23.R13 ; v2(218.33,85.11) UV18.E33
FBA_EDC3: length 34.4
  IN1 w0.102: v2(228.81,109.08) 228.35,108.62 228.35,108.25 227.7,107.6 226.79,107.6 ; v2(212.03,86.56) 212.03,86.64 212.9,87.51
  IN1 w0.117: 212.9,87.51 213.22,87.83 214.02,87.83 215.39,89.2 216.83,89.2 225.5,97.87 225.5,106.7 226.4,107.6 226.79,107.6
  BOTTOM w0.102: UV18.M33 212.81,84.7 212.47,85.04 212.47,86.11 v2(212.03,86.56) ; v2(228.81,109.08) 228.5,108.78 UV23.R2
FBA_EDC4: length 22.8
  IN6 w0.102: 214.33,96.92 214.33,98.4 v2(213.95,98.78) ; 205.22,88.79 205.22,86.68 204.6,86.05 203.79,86.05 203.47,85.73 203.47,85.01 202.51,84.06 v2(202.51,83.45)
  IN6 w0.117: 205.22,88.79 205.22,89.12 212.23,96.13 213.65,96.13 214.33,96.82 214.33,96.92
  BOTTOM w0.102: v2(202.51,83.45) 202.15,83.1 UV18.AE31 ; UV24.R2 v2(213.95,98.78)
FBA_EDC5: length 21.7
  IN6 w0.102: v2(205.95,99.58) 205.95,99.32 205.53,98.9 205.53,97.82 205.15,97.44 ; v2(197.48,82.78) 197.92,83.22
  IN6 w0.117: 197.92,83.22 197.92,85.23 198.06,85.37 198.06,90.68 204.81,97.44 205.15,97.44
  BOTTOM w0.102: UV18.AK30 197.84,82.43 v2(197.48,82.78) ; UV24.R13 v2(205.95,99.58)
FBA_EDC6: length 31.8
  IN1 w0.102: 203.91,108.09 204.32,108.09 204.99,108.76 205.33,108.76 205.35,108.78 205.55,108.78 v2(205.95,109.18)
  IN1 w0.117: 203.91,108.09 203.5,108.09 202.19,106.77 202.19,104 202.18,104 202.18,102.29 200.79,100.89 200.79,95.87 199.5,94.57 198.5,94.57 195.44,91.51 195.44,87.62 196.24,86.81 196.24,86.31 v2(195,85.07)
  BOTTOM w0.107: UV24.C13 v2(205.95,109.18) ; UV18.AN33 195.07,85.07 v2(195,85.07)
FBA_EDC7: length 34.2
  IN1 w0.117: v2(201.44,88.25) 201.99,88.25 203.74,90 204.9,90 212.47,97.56 214.97,97.56 215.43,98.03 215.43,103.37 215.19,103.62 215.19,104.54 215.43,104.78 215.43,106.97 215.21,107.19 215.21,107.67 214.89,107.99 214.59,107.99 214.59,107.99 214.34,107.99 v2(213.95,108.38)
  BOTTOM w0.102: UV18.AF33 201.25,84.7 201.58,85.03 201.58,85.68 201.44,85.82 201.44,86.2 201.85,86.61 201.85,87.82 201.44,88.23 v2(201.44,88.25)
  BOTTOM w0.107: UV24.C2 v2(213.95,108.38)
FBA_MA0_MA10_H: length 28.2
  TOP w0.102: v2(205.84,81.89) 206.02,82.07 206.02,82.91 206.22,83.11 206.22,84.93 205.04,86.11 205.04,87.29 204.22,88.11 204.22,89.54
  TOP w0.221: v2(211.27,102.93) v1(210.56,102.22) 209.7,101.37 209.7,98.56 204.22,93.08 204.22,89.54
  BOTTOM w0.102: UV24.K4 212.75,103.48 212.65,103.58 211.39,103.58 211.27,103.45 v2(211.27,102.93) ; v2(205.84,81.89) 206.21,81.89 206.31,81.99 206.31,82.22 UV18.Y30
FBA_MA0_MA10_L: length 40
  TOP w0.102: 210.09,89.54 210.09,89.45 207.89,87.25 207.89,86.57 207.92,86.54 207.92,83.35 207.56,82.99 v2(207.56,82.69) ; v2(229.58,103.59) 229.99,104 229.99,104.53 229.77,104.76 228.46,104.76 228.25,104.96 227.19,104.96 226.77,104.54
  TOP w0.221: 226.77,104.54 226.71,104.48 225.87,104.48 221.25,99.86 221.25,94.56 220.36,93.68 216.1,93.68 214.76,92.34 212.5,92.34 210.09,89.93 210.09,89.54
  BOTTOM w0.102: UV18.V30 207.94,82.31 v2(207.56,82.69) ; v2(229.58,103.59) 229.63,103.55 229.64,103.55 UV23.H4
FBA_MA1_MA9_H: length 21.3
  TOP w0.102: 204.95,89.54 204.95,88.02 205.25,87.73 205.25,86.44 v2(205.64,86.05)
  TOP w0.221: 204.95,89.54 204.95,92.72 210.44,98.21 v1(210.44,99.64) 210.44,100.8 v2(211.38,101.75)
  BOTTOM w0.102: v2(211.38,101.75) 211.07,102.05 211.07,102.2 211.95,103.08 UV24.K5
  BOTTOM w0.127: v2(205.64,86.05) 205.64,86.01 205.71,85.95 205.71,85.71 205.49,85.5 UV18.AA34
FBA_MA1_MA9_L: length 35.4
  BOTTOM w0.102: UV18.U34 209.42,86.19 209.42,88.34 210.26,89.17 ; UV23.H5 231.22,102.77
  BOTTOM w0.221: 210.26,89.17 212.59,91.51 v1(218.21,91.51) 226.5,91.51 231.33,96.34 231.33,102.66 231.22,102.77
FBA_MA2_BA0_H: length 28.7
  TOP w0.102: 203.91,101.33 204.17,101.59 206.1,101.59 206.36,101.85 206.36,102.07 206.6,102.31 207.09,102.31 v2(207.55,102.78) ; v2(205.02,81.04) 204.6,81.46 204.6,82.05 204.83,82.29 205.14,82.29 205.39,82.54 205.39,82.85 203.58,84.66 203.58,86.11 202.44,87.26 202.44,88.69 202.03,89.09 202.03,89.54
  TOP w0.221: 202.03,89.54 v1(202.03,94.83) 202.03,96.85 202.25,97.07 202.25,99.67 203.91,101.33
  BOTTOM w0.102: UV24.K11 v2(207.55,102.78) ; v2(205.02,81.04) 205.02,81.02 UV18.AA28
FBA_MA2_BA0_L: length 44.7
  TOP w0.102: 214.99,85.32 214.15,85.32 213.58,84.75 213.29,84.75 212.97,84.43 212.97,82.61 212.68,82.32 211.57,82.32 211.28,82.03 211.28,81.83 210.99,81.54 210.26,81.54 209.91,81.19 v2(209.74,81.19) ; v2(236.01,103.58) 236.41,103.18 236.41,101.04 236.39,101.02 236.39,101.02 236.17,100.8 236.17,100.8 236.13,100.76 235.06,100.76 234.76,100.46 234.76,96.92
  TOP w0.221: 234.76,96.92 234.76,95.28 223.31,83.83 222.59,83.83 222.57,83.85 221.85,83.85 221.83,83.83 221.45,83.83 221.42,83.86 220.68,83.86 220.61,83.93 218.98,83.93 218.49,84.41 217.29,84.41 216.86,84.84 216.47,84.84 216,85.32 214.99,85.32
  BOTTOM w0.102: UV18.U29 209.48,81.45 v2(209.74,81.19)
  BOTTOM w0.107: UV23.H11 v2(236.01,103.58)
FBA_MA3_BA3_H: length 28.2
  TOP w0.102: v2(208.35,102.78) 207.95,102.37 207.95,101.8 207.71,101.56 207.39,101.56 207.14,101.3 207.14,101.02 206.91,100.8 204.52,100.8 203.91,100.19 ; v2(205.83,81.04) 205.42,81.45 205.42,82.07 205.68,82.33 205.68,83.1 204.04,84.74 204.04,85.99 202.79,87.23 202.79,89.01 202.76,89.05 202.76,89.54
  TOP w0.221: 203.91,100.19 202.98,99.25 v1(202.98,97.99) 202.98,96.46 202.76,96.24 202.76,89.54
  BOTTOM w0.102: UV24.K10 v2(208.35,102.78) ; UV18.AA29 205.44,81.44 v2(205.83,81.04)
FBA_MA3_BA3_L: length 38.7
  TOP w0.102: 233.02,96.92 233.02,100.58 v2(235.21,102.78) ; 215.9,87.07 212.98,87.07 212.68,86.76 212.68,85.91 211.21,84.44 211.21,84.12 211.23,84.1 211.23,83.39 210.98,83.13 210.37,83.13 v2(210.04,83.45)
  TOP w0.221: 233.02,96.92 233.02,95.59 226,88.57 218.22,88.57 216.71,87.07 215.9,87.07
  BOTTOM w0.107: UV23.H10 v2(235.21,102.78)
  BOTTOM w0.17: v2(210.04,83.45) 210.04,83.45 209.94,83.45 UV18.T31
FBA_MA4_BA2_H: length 23.9
  BOTTOM w0.102: 208.54,104.07 208.27,104.34 207.59,104.34 UV24.H11 ; 203.74,88.41 203.74,88.37 204.43,87.68 204.65,87.68 205.04,87.29 205.04,86.58 204.52,86.06 204.3,86.06 UV18.AC34
  BOTTOM w0.221: 203.74,88.41 203.74,89.41 203.74,89.42 203.74,90.67 v1(208.17,95.09) 208.94,95.87 208.94,103.67 208.54,104.07
FBA_MA4_BA2_L: length 38.7
  BOTTOM w0.102: 234.39,104.34 235.18,104.34 UV23.K11 ; 214.56,87.79 213.85,87.08 211.58,87.08 210.44,85.93 UV18.R34
  BOTTOM w0.221: 214.56,87.79 226.58,87.79 v1(230.19,91.4) 233.55,94.76 233.55,103.7 234.19,104.34 234.39,104.34
FBA_MA5_BA1_H: length 24.8
  BOTTOM w0.102: UV18.AC33 203.74,85.13 203.78,85.17 203.87,85.17 204.07,85.36 204.07,85.46 204.41,85.8 204.83,85.8 205.06,86.03 205.06,86.29 205.23,86.47 205.23,86.48 205.25,86.49 205.25,87.53 204.47,88.3 204.47,88.41
  BOTTOM w0.221: UV24.H10 208.13,104.78 208.17,104.74 208.79,104.74 209.88,103.64 209.88,95.74 v1(207,92.86) 204.47,90.33 204.47,88.41
FBA_MA5_BA1_L: length 39.5
  BOTTOM w0.102: UV23.K10 234.33,104.78 234.09,105.01 233.83,105.01 233.81,104.99 ; UV18.R33 210.44,85.04 210.31,85.17 210.3,85.17 210.11,85.36 210.11,85.99 212.15,88.03 213.68,88.03
  BOTTOM w0.221: 213.68,88.03 214.16,88.52 v1(217.49,88.52) 226.28,88.52 232.82,95.06 232.82,104.18 233.64,104.99 233.81,104.99
FBA_MA6_MA11_H: length 28.4
  TOP w0.102: v2(206.62,81.06) 206.25,81.43 206.25,82.86 206.42,83.03 206.42,85.65 206.07,86 206.07,86.45 205.45,87.07 205.45,89.32 205.68,89.54 ; v2(211.55,104.38) 211.76,104.17 211.76,101.2 211.08,100.52
  TOP w0.221: 205.68,89.54 205.68,92.2 v1(210.53,97.05) 211.08,97.6 211.08,100.52
  BOTTOM w0.102: v2(206.62,81.06) 206.55,81.13 206.41,81.13 206.19,80.91 206.19,80.65 UV18.Y28 ; UV24.H5 211.98,104.75 211.98,104.42 211.85,104.3 211.63,104.3 v2(211.55,104.38)
FBA_MA6_MA11_L: length 42.2
  TOP w0.102: 231.68,97.03 231.97,97.32 231.97,104.53 231.73,104.76 230.86,104.76 v2(230.43,105.19) ; v2(209.16,81.02) 208.66,81.52 208.66,82.05 209.61,83 209.61,83.56 210.01,83.96 210.15,83.96 210.38,84.18 210.38,85.54 212.28,87.45 213.83,87.45 214.35,87.96
  TOP w0.221: 231.68,97.03 230.23,95.59 228.59,95.59 222.31,89.3 217.91,89.3 216.57,87.96 v1(215.66,87.96) 214.35,87.96
  BOTTOM w0.102: v2(209.16,81.02) 208.74,80.6 UV18.U28
  BOTTOM w0.13: UV23.K5 230.81,104.81 v2(230.43,105.19)
FBA_MA7_MA8_H: length 24.9
  BOTTOM w0.102: 211.46,105.16 212.37,105.16 UV24.H4 ; UV18.AA33 205.08,85.06 205.08,85.74 205.26,85.92 205.26,86.21 205.44,86.39 205.44,86.4 205.45,86.41 205.45,87.86 205.2,88.1 205.2,88.41
  BOTTOM w0.221: 211.46,105.16 210.72,104.43 210.72,95.49 v1(206.01,90.78) 205.2,89.97 205.2,88.41
FBA_MA7_MA8_L: length 39.2
  BOTTOM w0.102: UV23.K4 230.39,104.4 231.22,104.4 ; UV18.U33 208.74,84.98 209.11,85.35 209.11,85.58 209.79,86.26 209.79,87.56 211.4,89.17
  BOTTOM w0.221: 211.4,89.17 213.01,90.78 v1(221.84,90.78) 226.8,90.78 232.09,96.07 232.09,103.64 231.33,104.4 231.22,104.4
FBA_MA12_RFU_H: length 27.9
  TOP w0.102: 211.97,97.29 211.97,102.13 212.23,102.4 212.51,102.4 212.73,102.62 212.73,104 v2(212.35,104.38) ; v2(206.63,82.64) 206.63,82.64 206.63,85.73 206.45,85.91 206.45,86.7 205.77,87.39 205.77,88.9 206.41,89.54
  TOP w0.221: 211.97,97.29 v1(207.93,93.26) 206.41,91.73 206.41,89.54
  BOTTOM w0.102: UV18.W31 207.12,83.13 207.12,83.32 207.02,83.42 206.83,83.42 206.57,83.16 206.57,82.7 v2(206.63,82.64) ; v2(212.35,104.38) 212.43,104.3 212.43,103.9 212.33,103.8 212.05,103.8 211.95,103.9 UV24.J5
FBA_MA12_RFU_L: length 38.5
  TOP w0.102: v2(208.34,81.02) 208.34,82.14 208.8,82.61 208.8,84.86 209.55,85.61 ; 226.77,100.23 226.77,100.48 v1(227.06,100.76) 227.89,101.6 228.17,101.6 228.43,101.85 228.43,102.1 228.65,102.33 229.42,102.33 229.47,102.37 230.06,102.37 v2(230.44,102.75)
  TOP w0.17: 212.02,88.08 209.55,85.61 209.55,85.61
  TOP w0.221: 226.77,100.23 224.89,98.34 224.89,92.92 222.01,90.03 217.61,90.03 216.27,88.69 214.08,88.69 213.47,88.08 212.02,88.08
  BOTTOM w0.102: UV18.V29 207.94,81.42 v2(208.34,81.02) ; v2(230.44,102.75) 230.44,103.61 UV23.J5
FBA_RAS#_H: length 29.4
  BOTTOM w0.102: UV24.L3 213.99,102.82 215.85,102.82 ; 208.15,88.41 206.85,87.11 206.85,86.09 206.86,86.08 206.86,85.23 206.57,84.94 206.57,83.45 206.24,83.12 UV18.Y31
  BOTTOM w0.221: 215.85,102.82 216.59,102.82 216.9,102.5 v1(216.9,95.08) 216.9,93.92 215.29,92.31 212.05,92.31 208.15,88.41
FBA_RAS#_L: length 34.5
  TOP w0.102: 227.39,101.93 227.86,102.4 228.17,102.4 228.51,102.73 v2(228.81,102.73) ; 209.07,85.89 208.6,85.42 208.6,82.94 v2(208.34,82.69)
  TOP w0.221: 209.07,85.89 211.76,88.58 212.9,88.58 213.75,89.42 215.97,89.42 217.31,90.76 221.57,90.76 224.16,93.35 v1(224.16,97.3) 224.16,98.65 227.39,101.88 227.39,101.93
  BOTTOM w0.102: v2(208.34,82.69) 208.34,82.71 UV18.U31 ; UV23.G3 228.86,102.73 v2(228.81,102.73)
FBA_RST#_H: length 29.4
  TOP w0.102: 207.86,89.54 207.86,89.46 207.29,88.88 206.87,88.88 206.44,88.45 v2(206.44,88.15)
  TOP w0.221: v2(213.95,103.58) 215.58,101.95 215.98,101.95 216.34,101.59 216.34,96.95 215.99,96.59 213.64,96.59 207.86,90.81 207.86,89.54
  BOTTOM w0.102: 215.85,103.97 215.46,103.58 214.89,103.58 214.49,103.98 UV24.J2 v2(213.95,103.58) ; UV18.Y34 206.42,85.68 206.42,85.91 206.44,85.93 206.44,88.14 v2(206.44,88.15)
  BOTTOM w0.221: 215.85,103.97 216.08,104.2 217.23,104.2 RV613.1
FBA_RST#_L: length 34.1
  TOP w0.102: v2(228.01,103.58) 226.77,102.34 226.77,102.29 ; v2(209.04,86.5) 211.58,89.04 212.38,89.04
  TOP w0.221: 212.38,89.04 213.49,90.15 215.67,90.15 217.01,91.49 221.27,91.49 223.43,93.66 223.43,98.95 226.77,102.29
  BOTTOM w0.102: UV18.V34 208.93,86.5 v2(209.04,86.5) ; 226.65,103.58 v2(228.01,103.58) UV23.J2
  BOTTOM w0.221: RV614.1 225.6,103.58 226.65,103.58
FBA_WCK0: length 36.8
  IN6 w0.097: v2(214.18,82.7) 214.13,82.66 214.13,82.43 214.24,82.33 214.41,82.33 214.64,82.57 214.64,83.42 215.28,84.05 215.28,85.27 215.7,85.68 215.7,86.04 221.91,92.25 223.27,92.25 223.4,92.38 223.4,93.58 223.63,93.81 224.2,93.81 224.39,93.61 224.39,92.25 224.49,92.16 224.78,92.16 224.88,92.25 224.88,93.61 225.07,93.81 225.51,93.81 225.7,93.61 225.7,92.25 225.8,92.16 226.09,92.16 226.19,92.25 226.19,93.61 226.38,93.81 228.57,93.81 231.01,96.25 231.01,99.83 230.81,100.03 230.61,100.03 230.41,99.84 v2(230.41,99.58)
  BOTTOM w0.114: UV23.D4 v2(230.41,99.58) ; UV18.K31 214.58,83.1 v2(214.18,82.7)
FBA_WCK0_N: length 36.9
  IN6 w0.097: v2(230.41,100.38) 230.58,100.21 230.88,100.21 231.19,99.9 231.19,96.18 228.64,93.63 226.46,93.63 226.36,93.54 226.36,92.18 226.16,91.98 225.73,91.98 225.53,92.18 225.53,93.54 225.43,93.63 225.14,93.63 225.05,93.54 225.05,92.18 224.85,91.98 224.42,91.98 224.22,92.18 224.22,93.54 224.12,93.63 223.7,93.63 223.57,93.51 223.57,92.3 223.34,92.08 221.98,92.08 217.19,87.29 217.19,87.29 217.16,87.25 217.16,87.25 215.87,85.96 215.87,85.61 215.46,85.19 215.46,83.98 214.82,83.34 214.82,82.5 214.21,81.88 v2(214.18,81.88)
  BOTTOM w0.114: UV18.L30 213.76,82.3 v2(214.18,81.88) ; UV23.D5 v2(230.41,100.38)
FBA_WCK1: length 38.8
  IN1 w0.097: v2(213.74,86.62) 213.94,86.52 213.95,86.51 214.21,86.51 215.78,88.08 219.86,88.08 224.06,92.29 226.27,92.29 232.17,98.18 232.17,107.37 231.78,107.76 230.96,107.76 v2(230.38,108.34)
  BOTTOM w0.102: UV23.P4 230.38,108.34 v2(230.38,108.34) ; v2(213.74,86.62) 213.96,86.4 214.08,86.4 214.49,86.82 215.26,86.82 215.97,86.11 215.97,85.6 216.07,85.5 UV18.H34
FBA_WCK1_N: length 38.6
  IN1 w0.097: v2(213.93,86.02) 213.9,86.13 214.01,86.34 214.28,86.34 215.85,87.91 219.93,87.91 224.14,92.11 226.35,92.11 232.34,98.11 232.34,107.45 231.86,107.93 231.03,107.93 230.86,108.11 230.86,108.26 230.97,108.37 v2(231.16,108.37)
  BOTTOM w0.102: UV18.J34 215.6,85.5 215.71,85.6 215.71,86 215.15,86.56 214.6,86.56 214.07,86.02 v2(213.93,86.02) ; v2(231.16,108.37) 231.15,108.37 231.09,108.31 231.09,108.26 UV23.P5
FBA_WCK2: length 26.1
  IN6 w0.097: v2(212.35,100.38) 212.35,100.37 211.43,100.37 201.11,90.06 201.11,88.86 201.11,88.86 201.11,88.82 200.86,88.57 200.86,87.25 201.16,86.95 201.16,86.02 200.94,85.8 200.7,85.8 200.17,85.27 200.17,83.93 199.58,83.34 199.58,82.7 199.58,82.18 v2(199.9,81.86)
  BOTTOM w0.102: UV24.P4 v2(212.35,100.38)
  BOTTOM w0.114: v2(199.9,81.86) 199.95,81.86 200.38,82.3 UV18.AG30
FBA_WCK2_N: length 26.1
  IN6 w0.097: v2(212.35,99.61) 212.35,99.84 212,100.2 211.5,100.2 201.29,89.99 201.29,88.74 201.04,88.49 201.04,87.32 201.34,87.02 201.34,85.95 201.01,85.62 200.77,85.62 200.34,85.19 200.34,83.85 199.76,83.27 199.76,82.77 199.86,82.67 v2(200,82.67)
  BOTTOM w0.102: UV24.P5 212,100.03 212.2,100.03 212.41,99.81 212.41,99.67 v2(212.35,99.61) ; UV18.AG31 200.5,83.1 200.61,82.99 200.61,82.81 200.47,82.67 200.16,82.67
  BOTTOM w0.114: 200.16,82.67 v2(200,82.67)
FBA_WCK3: length 33.6
  IN1 w0.097: v2(212.4,107.62) 211.97,108.05 211.97,108.53 211.72,108.78 210.87,108.78 209.02,106.94 209.02,98.06 207.86,96.9 207.86,96.89 204.37,93.4 202.75,93.4 199.03,89.68 v2(198.47,89.68)
  BOTTOM w0.102: 198.5,86.63 198.5,86.6 198.47,86.57 198.47,85.6 198.57,85.5 UV18.AJ34 ; UV24.D4 v2(212.4,107.62)
  BOTTOM w0.17: 198.5,86.63 198.5,86.89 199.33,87.72 199.33,89.17 198.96,89.53 198.61,89.53 v2(198.47,89.68)
FBA_WCK3_N: length 33.4
  IN1 w0.097: v2(198.47,89.09) 198.88,89.5 199.1,89.5 202.82,93.23 204.44,93.23 207.98,96.77 207.99,96.77 209.2,97.98 209.2,106.87 210.94,108.61 211.65,108.61 211.8,108.46 211.8,107.88 211.69,107.77 211.46,107.77 211.36,107.87 v2(211.36,108.12)
  BOTTOM w0.102: UV24.D5 211.5,107.98 v2(211.36,108.12) ; UV18.AK34 198.1,85.5 198.21,85.6 198.21,86.57 198.17,86.6 198.17,86.63
  BOTTOM w0.17: v2(198.47,89.09) 198.47,89.09 198.58,89.2 198.83,89.2 199,89.03 199,87.85 198.17,87.03 198.17,86.63
FBA_WE#_H: length 30.6
  TOP w0.102: 203.91,96.92 203.91,98.88 205.03,100 206.91,100 207.13,100.22 207.13,100.5 207.39,100.76 207.67,100.76 207.93,101.02 207.93,101.33 208.2,101.6 208.51,101.6 208.98,102.06 208.98,105.42 208.66,105.74 207.31,105.74 v2(206.78,105.2) ; v2(205.84,83.5) 205.84,84.48 203.19,87.12 203.19,88.72 203.49,89.02 203.49,89.54
  TOP w0.221: 203.49,89.54 203.49,95.94 203.91,96.37 203.91,96.92
  BOTTOM w0.102: v2(206.78,105.2) 206.73,105.2 UV24.G12 ; UV18.AA32 v2(205.84,83.5)
FBA_WE#_L: length 41.5
  TOP w0.102: 232.29,96.92 232.29,101.48 236.03,105.23 v2(236.03,105.93)
  TOP w0.221: v2(226.38,89.99) 232.29,95.9 232.29,96.92
  BOTTOM w0.102: UV23.L12 236.06,105.93 v2(236.03,105.93) ; 212.53,89.17 210.16,86.81 210.16,86.34 209.31,85.49 209.31,85.27 209.23,85.19 209.23,84.46 208.74,83.97 UV18.U32
  BOTTOM w0.221: v2(226.38,89.99) 226.32,90.04 v1(215.19,90.04) 213.41,90.04 212.53,89.17
FBC_ABI#_H: length 33.2
  TOP w0.102: v2(217.56,70.97) 218.26,71.67 222.17,71.67 223.54,73.04 223.54,73.56
  TOP w0.147: 226.7,75.74 225.72,75.74 223.54,73.56 ; v2(242.52,82.63) 242.52,83.75 242.13,84.15 237.19,84.15
  TOP w0.221: 226.7,75.74 228.78,75.74 237.19,84.15
  BOTTOM w0.102: UV18.G17 v2(217.56,70.97) ; UV26.J4 v2(242.52,82.63)
FBC_ABI#_L: length 33.8
  TOP w0.102: 226.7,70.62 225.53,70.62 225.06,71.09 223.1,71.09 222.57,70.56 220.51,70.56 220.34,70.39 219.54,70.39 219.43,70.5 217.94,70.5 v2(217.56,70.12) ; v2(243.32,64.11) 243.7,64.49 243.7,65.06 243.56,65.2 243.56,66.07 243.77,66.28 243.77,66.88
  TOP w0.221: 226.7,70.62 v1(229.54,70.62) 241.97,70.62 243.77,68.83 243.77,66.88
  BOTTOM w0.102: UV25.J4 v2(243.32,64.11) ; UV18.F15 v2(217.56,70.12)
FBC_CAS#_H: length 36.5
  TOP w0.102: v2(219.24,71.02) 219.67,70.59 220.25,70.59 220.51,70.85 222.58,70.85 223.08,71.35 226.7,71.35 ; v2(244.12,81.83) 244.5,81.45 244.5,80.91 244.76,80.65 245.5,80.65 246.11,80.04 246.11,79.01
  TOP w0.221: 246.11,79.01 246.11,77.71 239.74,71.35 226.7,71.35
  BOTTOM w0.102: v2(219.24,71.02) 218.86,71.4 218.84,71.4 UV18.E17 ; UV26.G3 v2(244.12,81.83)
FBC_CAS#_L: length 28.3
  BOTTOM w0.102: UV18.C17 220.77,71.07 221.46,71.07 221.76,70.76 224.99,70.76 ; UV25.L3 244.52,64.79 244.83,65.1 244.83,65.43 244.47,65.79 244.39,65.79 244.09,66.09 244.09,66.46
  BOTTOM w0.221: 244.09,66.46 244.09,66.66 243.36,67.4 232.06,67.4 228.69,70.76 v1(226.23,70.76) 224.99,70.76
FBC_CKE_H: length 33.4
  TOP w0.102: 243.96,79.01 243.32,79.65 v2(243.32,81.03) 243.4,81.03 243.84,80.59 244.41,80.59 244.54,80.46 244.54,79.75 RV608.2
  TOP w0.221: 243.96,79.01 244.48,78.49 244.48,77.11 239.46,72.1 225.04,72.1 v2(224.98,72.16)
  BOTTOM w0.102: UV18.B17 221.41,71.4 221.8,71.01 223.84,71.01 v2(224.98,72.16) ; UV26.J3 v2(243.32,81.03)
FBC_CKE_L: length 30.9
  TOP w0.102: 241.5,66.88 241.5,66.65 241.78,66.37 242.63,66.37 243.08,65.92 243.08,65.41 242.83,65.16 242.83,64.34 242.5,64.02 v2(242.5,63.38) 242.57,63.38 242.89,63.7 243.63,63.7 RV606.2 ; 224.71,70.58 223.59,70.58 v2(223.21,70.2)
  TOP w0.221: 224.71,70.58 225.49,69.8 v1(225.86,69.8) 237.49,69.8 239.02,68.27 240.79,68.27 241.5,67.57 241.5,66.88
  BOTTOM w0.102: v2(242.5,63.38) 242.5,63.38 242.5,64.09 UV25.J3 ; v2(223.21,70.2) 222.8,69.79 222.47,69.79 222.19,70.07 221.61,70.07 UV18.B15
