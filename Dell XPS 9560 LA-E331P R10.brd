# Allegro board Dell XPS 9560 LA-E331P R10.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
ALPINE-RIDGE_BGA_337P
  round 0.254 smd: A1(0,0) A23(10.12,0) AA2(0.46,-9.2) AA22(9.66,-9.2) AB2(0.46,-9.66) AB3(0.92,-9.66) AB4(1.38,-9.66) AB5(1.84,-9.66) AB6(2.3,-9.66) AB7(2.76,-9.66) AB8(3.22,-9.66) AB9(3.68,-9.66) AB10(4.14,-9.66) AB11(4.6,-9.66) AB12(5.06,-9.66) AB13(5.52,-9.66) AB14(5.98,-9.66) AB15(6.44,-9.66) AB16(6.9,-9.66) AB17(7.36,-9.66) AB18(7.82,-9.66) AB19(8.28,-9.66) AB20(8.74,-9.66) AB21(9.2,-9.66) AB22(9.66,-9.66) AC1(0,-10.12) AC23(10.12,-10.12) B2(0.46,-0.46) B3(0.92,-0.46) B4(1.38,-0.46) B5(1.84,-0.46) B6(2.3,-0.46) B7(2.76,-0.46) B8(3.22,-0.46) B9(3.68,-0.46) B10(4.14,-0.46) B11(4.6,-0.46) B12(5.06,-0.46) B13(5.52,-0.46) B14(5.98,-0.46) B15(6.44,-0.46) B16(6.9,-0.46) B17(7.36,-0.46) B18(7.82,-0.46) B19(8.28,-0.46) B20(8.74,-0.46) B21(9.2,-0.46) B22(9.66,-0.46) C2(0.46,-0.92) C22(9.66,-0.92) D2(0.46,-1.38) D4(1.16,-1.16) D5(1.81,-1.16) D6(2.46,-1.16) D8(3.11,-1.16) D9(3.76,-1.16) D11(4.41,-1.16) D12(5.06,-1.16) D13(5.71,-1.16) D15(6.36,-1.16) D16(7.01,-1.16) D18(7.66,-1.16) D19(8.31,-1.16) D20(8.96,-1.16) D22(9.66,-1.38) E2(0.46,-1.84) E4(1.16,-1.81) E5(1.81,-1.81) E6(2.46,-1.81) E8(3.11,-1.81) E9(3.76,-1.81) E11(4.41,-1.81) E12(5.06,-1.81) E13(5.71,-1.81) E15(6.36,-1.81) E16(7.01,-1.81) E18(7.66,-1.81) E19(8.31,-1.81) E20(8.96,-1.81) E22(9.66,-1.84) F2(0.46,-2.3) F4(1.16,-2.46) F5(1.81,-2.46) F6(2.46,-2.46) F8(3.11,-2.46) F9(3.76,-2.46) F11(4.41,-2.46) F12(5.06,-2.46) F13(5.71,-2.46) F15(6.36,-2.46) F16(7.01,-2.46) F18(7.66,-2.46) F19(8.31,-2.46) F20(8.96,-2.46) F22(9.66,-2.3) G2(0.46,-2.76) G22(9.66,-2.76) H2(0.46,-3.22) H4(1.16,-3.11) H5(1.81,-3.11) H6(2.46,-3.11) H8(3.11,-3.11) H9(3.76,-3.11) H11(4.41,-3.11) H12(5.06,-3.11) H13(5.71,-3.11) H15(6.36,-3.11) H16(7.01,-3.11) H18(7.66,-3.11) H19(8.31,-3.11) H20(8.96,-3.11) H22(9.66,-3.22) J2(0.46,-3.68) J4(1.16,-3.76) J5(1.81,-3.76) J6(2.46,-3.76) J8(3.11,-3.76) J9(3.76,-3.76) J11(4.41,-3.76) J12(5.06,-3.76) J13(5.71,-3.76) J15(6.36,-3.76) J16(7.01,-3.76) J18(7.66,-3.76) J19(8.31,-3.76) J20(8.96,-3.76) J22(9.66,-3.68) K2(0.46,-4.14) K22(9.66,-4.14) L2(0.46,-4.6) L4(1.16,-4.41) L5(1.81,-4.41) L6(2.46,-4.41) L8(3.11,-4.41) L9(3.76,-4.41) L11(4.41,-4.41) L12(5.06,-4.41) L13(5.71,-4.41) L15(6.36,-4.41) L16(7.01,-4.41) L18(7.66,-4.41) L19(8.31,-4.41) L20(8.96,-4.41) L22(9.66,-4.6) M2(0.46,-5.06) M4(1.16,-5.06) M5(1.81,-5.06) M6(2.46,-5.06) M8(3.11,-5.06) M9(3.76,-5.06) M11(4.41,-5.06) M12(5.06,-5.06) M13(5.71,-5.06) M15(6.36,-5.06) M16(7.01,-5.06) M18(7.66,-5.06) M19(8.31,-5.06) M20(8.96,-5.06) M22(9.66,-5.06) N2(0.46,-5.52) N4(1.16,-5.71) N5(1.81,-5.71) N6(2.46,-5.71) N8(3.11,-5.71) N9(3.76,-5.71) N11(4.41,-5.71) N12(5.06,-5.71) N13(5.71,-5.71) N15(6.36,-5.71) N16(7.01,-5.71) N18(7.66,-5.71) N19(8.31,-5.71) N20(8.96,-5.71) N22(9.66,-5.52) P2(0.46,-5.98) P22(9.66,-5.98) R2(0.46,-6.44) R4(1.16,-6.36) R5(1.81,-6.36) R6(2.46,-6.36) R8(3.11,-6.36) R9(3.76,-6.36) R11(4.41,-6.36) R12(5.06,-6.36) R13(5.71,-6.36) R15(6.36,-6.36) R16(7.01,-6.36) R18(7.66,-6.36) R19(8.31,-6.36) R20(8.96,-6.36) R22(9.66,-6.44) T2(0.46,-6.9) T4(1.16,-7.01) T5(1.81,-7.01) T6(2.46,-7.01) T8(3.11,-7.01) T9(3.76,-7.01) T11(4.41,-7.01) T12(5.06,-7.01) T13(5.71,-7.01) T15(6.36,-7.01) T16(7.01,-7.01) T18(7.66,-7.01) T19(8.31,-7.01) T20(8.96,-7.01) T22(9.66,-6.9) U2(0.46,-7.36) U22(9.66,-7.36) V2(0.46,-7.82) V4(1.16,-7.66) V5(1.81,-7.66) V6(2.46,-7.66) V8(3.11,-7.66) V9(3.76,-7.66) V11(4.41,-7.66) V12(5.06,-7.66) V13(5.71,-7.66) V15(6.36,-7.66) V16(7.01,-7.66) V18(7.66,-7.66) V19(8.31,-7.66) V20(8.96,-7.66) V22(9.66,-7.82) W2(0.46,-8.28) W4(1.16,-8.31) W5(1.81,-8.31) W6(2.46,-8.31) W8(3.11,-8.31) W9(3.76,-8.31) W11(4.41,-8.31) W12(5.06,-8.31) W13(5.71,-8.31) W15(6.36,-8.31) W16(7.01,-8.31) W18(7.66,-8.31) W19(8.31,-8.31) W20(8.96,-8.31) W22(9.66,-8.28) Y2(0.46,-8.74) Y4(1.16,-8.96) Y5(1.81,-8.96) Y6(2.46,-8.96) Y8(3.11,-8.96) Y9(3.76,-8.96) Y11(4.41,-8.96) Y12(5.06,-8.96) Y13(5.71,-8.96) Y15(6.36,-8.96) Y16(7.01,-8.96) Y18(7.66,-8.96) Y19(8.31,-8.96) Y20(8.96,-8.96) Y22(9.66,-8.74)
  oval 0.178x0.33 smd: A2(0.46,0) A3(0.92,0) A4(1.38,0) A5(1.84,0) A6(2.3,0) A7(2.76,0) A8(3.22,0) A9(3.68,0) A10(4.14,0) A11(4.6,0) A12(5.06,0) A13(5.52,0) A14(5.98,0) A15(6.44,0) A16(6.9,0) A17(7.36,0) A18(7.82,0) A19(8.28,0) A20(8.74,0) A21(9.2,0) A22(9.66,0) AC2(0.46,-10.12) AC3(0.92,-10.12) AC4(1.38,-10.12) AC5(1.84,-10.12) AC6(2.3,-10.12) AC7(2.76,-10.12) AC8(3.22,-10.12) AC9(3.68,-10.12) AC10(4.14,-10.12) AC11(4.6,-10.12) AC12(5.06,-10.12) AC13(5.52,-10.12) AC14(5.98,-10.12) AC15(6.44,-10.12) AC16(6.9,-10.12) AC17(7.36,-10.12) AC18(7.82,-10.12) AC19(8.28,-10.12) AC20(8.74,-10.12) AC21(9.2,-10.12) AC22(9.66,-10.12)
  oval 0.33x0.178 smd: AA1(0,-9.2) AA23(10.12,-9.2) AB1(0,-9.66) AB23(10.12,-9.66) B1(0,-0.46) B23(10.12,-0.46) C1(0,-0.92) C23(10.12,-0.92) D1(0,-1.38) D23(10.12,-1.38) E1(0,-1.84) E23(10.12,-1.84) F1(0,-2.3) F23(10.12,-2.3) G1(0,-2.76) G23(10.12,-2.76) H1(0,-3.22) H23(10.12,-3.22) J1(0,-3.68) J23(10.12,-3.68) K1(0,-4.14) K23(10.12,-4.14) L1(0,-4.6) L23(10.12,-4.6) M1(0,-5.06) M23(10.12,-5.06) N1(0,-5.52) N23(10.12,-5.52) P1(0,-5.98) P23(10.12,-5.98) R1(0,-6.44) R23(10.12,-6.44) T1(0,-6.9) T23(10.12,-6.9) U1(0,-7.36) U23(10.12,-7.36) V1(0,-7.82) V23(10.12,-7.82) W1(0,-8.28) W23(10.12,-8.28) Y1(0,-8.74) Y23(10.12,-8.74)
AO3413_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
AON7406L_DFN8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
AON7409_DFN8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
AON7516_DFN8-5
  oval 0.356x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0)
  custom 0.57x0.57 smd: 5(0.975,1.4)
AON7934_DFN3X3A8-10
  oval 0.457x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,2.76) 6(1.3,2.76) 7(0.65,2.76) 8(0,2.76)
  rect 2.54x1.041 smd: 9(0.975,1.813)
  rect 2.54x0.559 smd: 10(0.975,0.708)
AOZ5029QI_QFN24_5X3P5
  oval 0.254x0.762 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0)
  rect 3.15x1.473 smd: 6(1.47,1.31)
  custom 0.588x0.588 smd: 7(1,2.425)
  rect 1.956x0.864 smd: 8(1.25,4.787)
  oval 0.762x0.254 smd: 9(-0.675,2.925) 10(-0.675,2.425) 11(-0.675,1.925) 12(-0.675,1.425) 13(-0.675,0.925) 14(-0.675,0.425)
AP2330W-7_SC59-3
  oval 0.787x0.991 smd: 1(0,0) 2(-0.95,-2.4) 3(0.95,-2.4)
APE8937GN2_DFN8_2X2
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.6x0.889 smd: 9(0.75,1.1)
AZ1045-04F_DFN2510P10E-10-9
  oval 0.254x0.686 smd: 1(0,0) 2(0.5,0) 4(1.5,0) 5(2,0) 6(2,0.875) 7(1.5,0.875) 8(0.5,0.875) 9(0,0.875)
  oval 0.381x1.549 smd: 3(1,0.437)
AZ5123-01FPR7G_DFN1006P2X2
  rect 0.559x0.61 smd: 1(0,0) 2(0.85,0)
AZ5125-01HPR7G_SOD523-2
  rect 0.61x0.787 smd: 1(0,0) 2(1.5,0)
AZ5125-02SPR7G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
AZC199-02SPR7G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
BAS40-04_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
BAT54CW-7-F_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
BELLW_SD-80886-1021_260P-T
  round 1.092 hole 1.092 unplated: (-67.775,-4.1)
  round 1.6 hole 1.6 unplated: (1.025,-4.1)
  oval 0.305x1.753 smd: 1(0,0) 2(-0.25,-8.2) 3(-0.5,0) 4(-0.75,-8.2) 5(-1,0) 6(-1.25,-8.2) 7(-1.5,0) 8(-1.75,-8.2) 9(-2,0) 10(-2.25,-8.2) 11(-2.5,0) 12(-2.75,-8.2) 13(-3,0) 14(-3.25,-8.2) 15(-3.5,0) 16(-3.75,-8.2) 17(-4,0) 18(-4.25,-8.2) 19(-4.5,0) 20(-4.75,-8.2) 21(-5,0) 22(-5.25,-8.2) 23(-5.5,0) 24(-5.75,-8.2) 25(-6,0) 26(-6.25,-8.2) 27(-6.5,0) 28(-6.75,-8.2) 29(-7,0) 30(-7.25,-8.2) 31(-7.5,0) 32(-7.75,-8.2) 33(-8,0) 34(-8.25,-8.2) 35(-8.5,0) 36(-8.75,-8.2) 37(-9,0) 38(-9.25,-8.2) 39(-9.5,0) 40(-9.75,-8.2) 41(-10,0) 42(-10.25,-8.2) 43(-10.5,0) 44(-10.75,-8.2) 45(-11,0) 46(-11.25,-8.2) 47(-11.5,0) 48(-11.75,-8.2) 49(-12,0) 50(-12.25,-8.2) 51(-12.5,0) 52(-12.75,-8.2) 53(-13,0) 54(-13.25,-8.2) 55(-13.5,0) 56(-13.75,-8.2) 57(-14,0) 58(-14.25,-8.2) 59(-14.5,0) 60(-14.75,-8.2) 61(-15,0) 62(-15.25,-8.2) 63(-15.5,0) 64(-15.75,-8.2) 65(-16,0) 66(-16.25,-8.2) 67(-16.5,0) 68(-16.75,-8.2) 69(-17,0) 70(-17.25,-8.2) 71(-17.5,0) 72(-17.75,-8.2) 73(-18,0) 74(-18.25,-8.2) 75(-18.5,0) 76(-18.75,-8.2) 77(-19,0) 78(-19.25,-8.2) 79(-19.5,0) 80(-19.75,-8.2) 81(-20,0) 82(-20.25,-8.2) 83(-20.5,0) 84(-20.75,-8.2) 85(-21,0) 86(-21.25,-8.2) 87(-21.5,0) 88(-21.75,-8.2) 89(-22,0) 90(-22.25,-8.2) 91(-22.5,0) 92(-22.75,-8.2) 93(-23,0) 94(-23.25,-8.2) 95(-23.5,0) 96(-23.75,-8.2) 97(-24,0) 98(-24.25,-8.2) 99(-24.5,0) 100(-24.75,-8.2) 101(-25,0) 102(-25.25,-8.2) 103(-25.5,0) 104(-25.75,-8.2) 105(-26,0) 106(-26.25,-8.2) 107(-26.5,0) 108(-26.75,-8.2) 109(-27,0) 110(-27.25,-8.2) 111(-27.5,0) 112(-27.75,-8.2) 113(-28,0) 114(-28.25,-8.2) 115(-28.5,0) 116(-28.75,-8.2) 117(-29,0) 118(-29.25,-8.2) 119(-29.5,0) 120(-29.75,-8.2) 121(-30,0) 122(-30.25,-8.2) 123(-30.5,0) 124(-30.75,-8.2) 125(-31,0) 126(-31.25,-8.2) 127(-31.5,0) 128(-31.75,-8.2) 129(-32,0) 130(-32.25,-8.2) 131(-32.5,0) 132(-32.75,-8.2) 133(-33,0) 134(-33.25,-8.2) 135(-33.5,0) 136(-33.75,-8.2) 137(-34,0) 138(-34.25,-8.2) 139(-34.5,0) 140(-34.75,-8.2) 141(-35,0) 142(-35.25,-8.2) 143(-35.5,0) 144(-35.75,-8.2) 145(-38,0) 146(-38.25,-8.2) 147(-38.5,0) 148(-38.75,-8.2) 149(-39,0) 150(-39.25,-8.2) 151(-39.5,0) 152(-39.75,-8.2) 153(-40,0) 154(-40.25,-8.2) 155(-40.5,0) 156(-40.75,-8.2) 157(-41,0) 158(-41.25,-8.2) 159(-41.5,0) 160(-41.75,-8.2) 161(-42,0) 162(-42.25,-8.2) 163(-42.5,0) 164(-42.75,-8.2) 165(-43,0) 166(-43.25,-8.2) 167(-43.5,0) 168(-43.75,-8.2) 169(-44,0) 170(-44.25,-8.2) 171(-44.5,0) 172(-44.75,-8.2) 173(-45,0) 174(-45.25,-8.2) 175(-45.5,0) 176(-45.75,-8.2) 177(-46,0) 178(-46.25,-8.2) 179(-46.5,0) 180(-46.75,-8.2) 181(-47,0) 182(-47.25,-8.2) 183(-47.5,0) 184(-47.75,-8.2) 185(-48,0) 186(-48.25,-8.2) 187(-48.5,0) 188(-48.75,-8.2) 189(-49,0) 190(-49.25,-8.2) 191(-49.5,0) 192(-49.75,-8.2) 193(-50,0) 194(-50.25,-8.2) 195(-50.5,0) 196(-50.75,-8.2) 197(-51,0) 198(-51.25,-8.2) 199(-51.5,0) 200(-51.75,-8.2) 201(-52,0) 202(-52.25,-8.2) 203(-52.5,0) 204(-52.75,-8.2) 205(-53,0) 206(-53.25,-8.2) 207(-53.5,0) 208(-53.75,-8.2) 209(-54,0) 210(-54.25,-8.2) 211(-54.5,0) 212(-54.75,-8.2) 213(-55,0) 214(-55.25,-8.2) 215(-55.5,0) 216(-55.75,-8.2) 217(-56,0) 218(-56.25,-8.2) 219(-56.5,0) 220(-56.75,-8.2) 221(-57,0) 222(-57.25,-8.2) 223(-57.5,0) 224(-57.75,-8.2) 225(-58,0) 226(-58.25,-8.2) 227(-58.5,0) 228(-58.75,-8.2) 229(-59,0) 230(-59.25,-8.2) 231(-59.5,0) 232(-59.75,-8.2) 233(-60,0) 234(-60.25,-8.2) 235(-60.5,0) 236(-60.75,-8.2) 237(-61,0) 238(-61.25,-8.2) 239(-61.5,0) 240(-61.75,-8.2) 241(-62,0) 242(-62.25,-8.2) 243(-62.5,0) 244(-62.75,-8.2) 245(-63,0) 246(-63.25,-8.2) 247(-63.5,0) 248(-63.75,-8.2) 249(-64,0) 250(-64.25,-8.2) 251(-64.5,0) 252(-64.75,-8.2) 253(-65,0) 254(-65.25,-8.2) 255(-65.5,0) 256(-65.75,-8.2) 257(-66,0) 258(-66.25,-8.2) 259(-66.5,0) 260(-66.75,-8.2)
  rect 3.505x4.597 smd: 261(0.425,7.9) 262(-67.175,7.9)
BQ24777RUYR_WQFN28_4X4
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 15(4.1,-2.4) 16(4.1,-2) 17(4.1,-1.6) 18(4.1,-1.2) 19(4.1,-0.8) 20(4.1,-0.4) 21(4.1,0)
  oval 0.203x0.889 smd: 8(0.85,-3.25) 9(1.25,-3.25) 10(1.65,-3.25) 11(2.05,-3.25) 12(2.45,-3.25) 13(2.85,-3.25) 14(3.25,-3.25) 22(3.25,0.85) 23(2.85,0.85) 24(2.45,0.85) 25(2.05,0.85) 26(1.65,0.85) 27(1.25,0.85) 28(0.85,0.85)
  rect 2.591x2.591 smd: 29(2.05,-1.2)
C_0201
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
C_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
C_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
C_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
C_0906
  rect 0.991x1.397 smd: 1(0,0) 2(1.8,0)
C_B2
  rect 1.346x2.692 smd: 1(0,0) 2(-2.75,0)
C_D
  rect 2.388x2.896 smd: 1(0,0) 2(6.1,0)
C_D1
  rect 1.803x2.794 smd: 1(0,0) 2(6.5,0)
C_D2
  rect 2.388x2.794 smd: 1(0,0) 2(6.4,0)
C_EEFSS0D221R
  rect 2.388x2.794 smd: 1(0,0) 2(6.4,0)
CHILI_CMMI21T-900Y-N_4P
  rect 0.356x0.889 smd: 1(0,0) 2(0,1.7) 3(0.85,1.7) 4(0.85,0)
CHILI_PBY160808T-300Y-N_2P
  rect 0.559x1.041 smd: 1(0,0) 2(1.3,0)
CLIP_C5P5
  round 5.512 smd: 1(0,0)
CLIP_C5P5-NPM
  round 5.512 smd: 1(0,0)
CLIP_C6-NPM
  round 5.994 smd: 1(0,0)
COILC_XFL4012-601MEC_2P
  rect 0.991x3.404 smd: 1(0,0) 2(2.37,0)
CONCR_213AAAA32FA_67P
  round 1.092 hole 1.092 unplated: (-0.75,-5.275)
  round 1.6 hole 1.6 unplated: (19.25,-5.275)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 8(3.75,-7.55) 9(4,0) 10(4.25,-7.55) 11(4.5,0) 12(4.75,-7.55) 13(5,0) 14(5.25,-7.55) 15(5.5,0) 16(5.75,-7.55) 17(6,0) 18(6.25,-7.55) 19(6.5,0) 20(6.75,-7.55) 21(7,0) 22(7.25,-7.55) 23(7.5,0) 24(7.75,-7.55) 25(8,0) 26(8.25,-7.55) 27(8.5,0) 28(8.75,-7.55) 29(9,0) 30(9.25,-7.55) 31(9.5,0) 32(9.75,-7.55) 33(10,0) 34(10.25,-7.55) 35(10.5,0) 36(10.75,-7.55) 37(11,0) 38(11.25,-7.55) 39(11.5,0) 40(11.75,-7.55) 41(12,0) 42(12.25,-7.55) 43(12.5,0) 44(12.75,-7.55) 45(13,0) 46(13.25,-7.55) 47(13.5,0) 48(13.75,-7.55) 49(14,0) 50(14.25,-7.55) 51(14.5,0) 52(14.75,-7.55) 53(15,0) 54(15.25,-7.55) 55(15.5,0) 56(15.75,-7.55) 57(16,0) 58(16.25,-7.55) 59(16.5,0) 60(16.75,-7.55) 61(17,0) 62(17.25,-7.55) 63(17.5,0) 64(17.75,-7.55) 65(18,0) 66(18.25,-7.55) 67(18.5,0)
  rect 1.194x2.743 smd: 68(-1.1,-0.775) 69(19.6,-0.775)
CONCR_213MAAA32FA_67P-T
  round 1.092 hole 1.092 unplated: (-0.75,-5.275)
  round 1.6 hole 1.6 unplated: (19.25,-5.275)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 8(1.75,-7.55) 9(2,0) 10(2.25,-7.55) 11(2.5,0) 12(2.75,-7.55) 13(3,0) 14(3.25,-7.55) 15(3.5,0) 16(3.75,-7.55) 17(4,0) 18(4.25,-7.55) 19(4.5,0) 20(4.75,-7.55) 21(5,0) 22(5.25,-7.55) 23(5.5,0) 24(5.75,-7.55) 25(6,0) 26(6.25,-7.55) 27(6.5,0) 28(6.75,-7.55) 29(7,0) 30(7.25,-7.55) 31(7.5,0) 32(7.75,-7.55) 33(8,0) 34(8.25,-7.55) 35(8.5,0) 36(8.75,-7.55) 37(9,0) 38(9.25,-7.55) 39(9.5,0) 40(9.75,-7.55) 41(10,0) 42(10.25,-7.55) 43(10.5,0) 44(10.75,-7.55) 45(11,0) 46(11.25,-7.55) 47(11.5,0) 48(11.75,-7.55) 49(12,0) 50(12.25,-7.55) 51(12.5,0) 52(12.75,-7.55) 53(13,0) 54(13.25,-7.55) 55(13.5,0) 56(13.75,-7.55) 57(14,0) 58(14.25,-7.55) 59(16.5,0) 60(16.75,-7.55) 61(17,0) 62(17.25,-7.55) 63(17.5,0) 64(17.75,-7.55) 65(18,0) 66(18.25,-7.55) 67(18.5,0)
  rect 1.194x2.743 smd: 68(-1.1,-0.775) 69(19.6,-0.775)
CSD86360Q5D_SON8-7
  oval 1.93x0.838 smd: 1(0,0)
  oval 0.66x0.838 smd: 2(1.905,0) 3(3.175,0) 4(3.175,5.39) 5(1.905,5.39) 6(0.635,5.39) 7(-0.635,5.39)
  custom 0.87x0.87 smd: 8(1.27,2.695)
CYNTE_PCMB053T-1R0MS_2P
  rect 2.007x2.489 smd: 1(0,0) 2(5,0)
CYNTE_PCMB063T-1R0MS_2P
  rect 2.362x3.505 smd: 1(0,0) 2(6.05,0)
CYNTE_PCMB063T-3R3MS_2P
  rect 2.362x3.505 smd: 1(0,0) 2(6.05,0)
CYNTE_PCMC063T-1R5MN_2P
  rect 2.159x3.505 smd: 1(0,0) 2(5.85,0)
DMG2301U-7_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
DMN63D8LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
DMN65D8LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
E-T_3806K-F02N-03R_2P
  oval 0.787x1.905 smd: 1(0,0) 2(1.25,0)
  rect 1.295x3.353 smd: 3(-2.85,-4.875) 4(4.1,-4.875)
E-T_6705K-Y20N-00L_20P
  oval 0.305x1.092 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0) 5(-2,0) 6(-2.5,0) 7(-3,0) 8(-3.5,0) 9(-4,0) 10(-4.5,0) 11(-5,0) 12(-5.5,0) 13(-6,0) 14(-6.5,0) 15(-7,0) 16(-7.5,0) 17(-8,0) 18(-8.5,0) 19(-9,0) 20(-9.5,0)
  rect 0.991x2.007 smd: 21(2.1,-3.15) 22(-11.6,-3.15)
E-T_6710K-Y15M-31L_15P
  oval 0.305x0.965 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0)
  rect 0.305x1.143 smd: 16(7.885,-2.965) 17(-0.885,-2.965)
EM5209VF_DFN14_3X2
  oval 0.203x0.711 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.4,2) 9(2,2) 10(1.6,2) 11(1.2,2) 12(0.8,2) 13(0.4,2) 14(0,2)
  rect 2.591x0.991 smd: 15(1.2,1)
EMIST_SUL-12A2M_1P
  rect 6.909x1.194 smd: 1(0,0)
ESD3V3S1B-02LS_PG-TSSLP-2-1-2
  rect 0.279x0.381 smd: 1(0,0) 2(0.38,0)
ESD108-B1-CSP0201_WLL-2-1-2
  rect 0.279x0.381 smd: 1(0,0) 2(0.38,0)
ESD8011MUT5G_X3DFN2-2
  rect 0.33x0.356 smd: 1(0,0) 2(0.43,0)
FDV301N-G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
FIDUCIAL_C40M80
  round 1.016 smd: 1(0,0)
G5616ARZ1U_TQFN20_3X3
  oval 0.203x1.016 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,2.975) 12(1.2,2.975) 13(0.8,2.975) 14(0.4,2.975) 15(0,2.975)
  oval 1.016x0.203 smd: 6(2.288,0.688) 7(2.288,1.088) 8(2.288,1.488) 9(2.288,1.888) 10(2.288,2.288) 16(-0.688,2.288) 17(-0.688,1.888) 18(-0.688,1.488) 19(-0.688,1.088) 20(-0.688,0.688)
  rect 1.6x1.6 smd: 21(0.8,1.488)
G5719CRC1U_TDFN8_2X2-S
  oval 0.254x0.838 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.15) 6(1,2.15) 7(0.5,2.15) 8(0,2.15)
  rect 1.549x0.838 smd: 9(0.75,1.075)
G9090-180T11U_SOT23-5
  oval 0.533x1.194 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,3) 5(0,3)
H5GQ1H24AFR-T2L_BGA_170P
  round 0.343 smd: A1(0,0) A2(0.8,0) A3(1.6,0) A4(2.4,0) A5(3.2,0) A10(7.201,0) A11(8.001,0) A12(8.801,0) A13(9.601,0) A14(10.401,0) B1(0,-0.8) B2(0.8,-0.8) B3(1.6,-0.8) B4(2.4,-0.8) B5(3.2,-0.8) B10(7.201,-0.8) B11(8.001,-0.8) B12(8.801,-0.8) B13(9.601,-0.8) B14(10.401,-0.8) C1(0,-1.6) C2(0.8,-1.6) C3(1.6,-1.6) C4(2.4,-1.6) C5(3.2,-1.6) C10(7.201,-1.6) C11(8.001,-1.6) C12(8.801,-1.6) C13(9.601,-1.6) C14(10.401,-1.6) D1(0,-2.4) D2(0.8,-2.4) D3(1.6,-2.4) D4(2.4,-2.4) D5(3.2,-2.4) D10(7.201,-2.4) D11(8.001,-2.4) D12(8.801,-2.4) D13(9.601,-2.4) D14(10.401,-2.4) E1(0,-3.2) E2(0.8,-3.2) E3(1.6,-3.2) E4(2.4,-3.2) E5(3.2,-3.2) E10(7.201,-3.2) E11(8.001,-3.2) E12(8.801,-3.2) E13(9.601,-3.2) E14(10.401,-3.2) F1(0,-4) F2(0.8,-4) F3(1.6,-4) F4(2.4,-4) F5(3.2,-4) F10(7.201,-4) F11(8.001,-4) F12(8.801,-4) F13(9.601,-4) F14(10.401,-4) G1(0,-4.801) G2(0.8,-4.801) G3(1.6,-4.801) G4(2.4,-4.801) G5(3.2,-4.801) G10(7.201,-4.801) G11(8.001,-4.801) G12(8.801,-4.801) G13(9.601,-4.801) G14(10.401,-4.801) H1(0,-5.601) H2(0.8,-5.601) H3(1.6,-5.601) H4(2.4,-5.601) H5(3.2,-5.601) H10(7.201,-5.601) H11(8.001,-5.601) H12(8.801,-5.601) H13(9.601,-5.601) H14(10.401,-5.601) J1(0,-6.401) J2(0.8,-6.401) J3(1.6,-6.401) J4(2.4,-6.401) J5(3.2,-6.401) J10(7.201,-6.401) J11(8.001,-6.401) J12(8.801,-6.401) J13(9.601,-6.401) J14(10.401,-6.401) K1(0,-7.201) K2(0.8,-7.201) K3(1.6,-7.201) K4(2.4,-7.201) K5(3.2,-7.201) K10(7.201,-7.201) K11(8.001,-7.201) K12(8.801,-7.201) K13(9.601,-7.201) K14(10.401,-7.201) L1(0,-8.001) L2(0.8,-8.001) L3(1.6,-8.001) L4(2.4,-8.001) L5(3.2,-8.001) L10(7.201,-8.001) L11(8.001,-8.001) L12(8.801,-8.001) L13(9.601,-8.001) L14(10.401,-8.001) M1(0,-8.801) M2(0.8,-8.801) M3(1.6,-8.801) M4(2.4,-8.801) M5(3.2,-8.801) M10(7.201,-8.801) M11(8.001,-8.801) M12(8.801,-8.801) M13(9.601,-8.801) M14(10.401,-8.801) N1(0,-9.601) N2(0.8,-9.601) N3(1.6,-9.601) N4(2.4,-9.601) N5(3.2,-9.601) N10(7.201,-9.601) N11(8.001,-9.601) N12(8.801,-9.601) N13(9.601,-9.601) N14(10.401,-9.601) P1(0,-10.401) P2(0.8,-10.401) P3(1.6,-10.401) P4(2.4,-10.401) P5(3.2,-10.401) P10(7.201,-10.401) P11(8.001,-10.401) P12(8.801,-10.401) P13(9.601,-10.401) P14(10.401,-10.401) R1(0,-11.201) R2(0.8,-11.201) R3(1.6,-11.201) R4(2.4,-11.201) R5(3.2,-11.201) R10(7.201,-11.201) R11(8.001,-11.201) R12(8.801,-11.201) R13(9.601,-11.201) R14(10.401,-11.201) T1(0,-12.002) T2(0.8,-12.002) T3(1.6,-12.002) T4(2.4,-12.002) T5(3.2,-12.002) T10(7.201,-12.002) T11(8.001,-12.002) T12(8.801,-12.002) T13(9.601,-12.002) T14(10.401,-12.002) U1(0,-12.802) U2(0.8,-12.802) U3(1.6,-12.802) U4(2.4,-12.802) U5(3.2,-12.802) U10(7.201,-12.802) U11(8.001,-12.802) U12(8.801,-12.802) U13(9.601,-12.802) U14(10.401,-12.802)
H_2P1N
  round 2.108 hole 2.108 unplated: (0,0)
H_2P1X2P5N
  oval 2.108x2.489 hole 2.108x2.489 unplated: (0,0)
H_2P3
  round 2.819 hole 2.311: 1(0,0)
H_2P5
  round 2.997 hole 2.489: 1(0,0)
H_2P8
  round 3.302 hole 2.794: 1(0,0)
H_2P9X2P1N
  oval 2.896x2.108 hole 2.896x2.108 unplated: (0,0)
H_3P2
  round 3.708 hole 3.2: 1(0,0)
H_3P9
  round 4.42 hole 3.912: 1(0,0)
H_4P2
  round 4.699 hole 4.191: 1(0,0)
H_6P0N
  round 5.994 hole 5.994 unplated: (0,0)
HB_A531015-SCHR21_10P
  oval 0.305x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0)
  rect 0.991x2.007 smd: 11(6.6,-3.05) 12(-2.1,-3.05)
INPAQ_HCM2012GA900AE_4P
  rect 0.762x0.508 smd: 1(0,0) 2(1.85,0) 3(1.85,-0.9) 4(0,-0.9)
INPAQ_MCM1012B900F06BP_4P
  rect 0.711x0.305 smd: 1(0,0) 2(1.25,0) 3(1.25,-0.5) 4(0,-0.5)
IP4223CZ6_SO6-6
  oval 0.508x1.422 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.35) 5(0.95,2.35) 6(0,2.35)
ISL95808HRZ-TS2378_DFN8_2X2
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.549x0.889 smd: 9(0.75,1.1)
ISL95829AHRTZ-T_TQFN48_6X6
  oval 0.94x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 25(6.05,-4.4) 26(6.05,-4) 27(6.05,-3.6) 28(6.05,-3.2) 29(6.05,-2.8) 30(6.05,-2.4) 31(6.05,-2) 32(6.05,-1.6) 33(6.05,-1.2) 34(6.05,-0.8) 35(6.05,-0.4) 36(6.05,0)
  oval 0.203x0.94 smd: 13(0.825,-5.225) 14(1.225,-5.225) 15(1.625,-5.225) 16(2.025,-5.225) 17(2.425,-5.225) 18(2.825,-5.225) 19(3.225,-5.225) 20(3.625,-5.225) 21(4.025,-5.225) 22(4.425,-5.225) 23(4.825,-5.225) 24(5.225,-5.225) 37(5.225,0.825) 38(4.825,0.825) 39(4.425,0.825) 40(4.025,0.825) 41(3.625,0.825) 42(3.225,0.825) 43(2.825,0.825) 44(2.425,0.825) 45(2.025,0.825) 46(1.625,0.825) 47(1.225,0.825) 48(0.825,0.825)
  rect 4.394x4.394 smd: 49(3.025,-2.2)
J-L_UCNR2234B020-0_20P
  oval 0.254x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0)
  rect 1.194x2.692 smd: 21(-2.4,1.95) 22(11.9,1.95)
  rect 2.311x1.295 smd: 23(0.85,3.9) 24(8.65,3.9)
JAE_DX07S024XJ2_24P-T
  round 0.762 hole 0.762 unplated: (-0.85,-0.66)
  oval 0.94x0.762 hole 0.94x0.762 unplated: (6.35,-0.66)
  oval 1.092x2.108 hole 0.61x1.6: 1(-1.85,-5.06) 2(-1.85,-2.06) 3(7.35,-5.06) 4(7.35,-2.06)
  oval 0.305x1.092 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2,0) A6(2.5,0) A7(3,0) A8(3.5,0) A9(4,0) A10(4.5,0) A11(5,0) A12(5.5,0)
  round 0.61 hole 0.406: B1(5.55,-1.31) B2(5.15,-2.01) B3(4.35,-2.01) B4(3.95,-1.31) B5(3.55,-2.01) B6(3.15,-1.31) B7(2.35,-1.31) B8(1.95,-2.01) B9(1.55,-1.31) B10(1.15,-2.01) B11(0.35,-2.01) B12(-0.05,-1.31)
JUMP_43X39
  custom 0.191x0.191 smd: 1(0,0) 2(0.914,0)
JUMP_43X79
  custom 0.188x0.188 smd: 1(0,0) 2(1.1,0)
JUMP_43X118
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
JXT_FP241AH-006GAAM_6P
  oval 0.305x0.965 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0)
  rect 0.305x1.143 smd: 7(-0.885,-2.965) 8(3.385,-2.965)
KC_FBMA-L11-160808300LMA25T_2P
  rect 0.889x1.092 smd: 1(0,0) 2(1.5,0)
L2N7002WT1G_SC-70-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
LED_HT-F196BP5_2P
  rect 0.787x0.787 smd: 1(0,0) 2(1.5,0)
LED_LTW-270TLA_2P
  rect 0.889x0.889 smd: 1(0,0) 2(1.9,0)
LM393DMR2G_MICRO8
  oval 0.381x1.041 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,4.24) 6(1.3,4.24) 7(0.65,4.24) 8(0,4.24)
LNG3DMTR_LGA16_3X3
  oval 0.305x0.864 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 9(2,2.96) 10(1.5,2.96) 11(1,2.96) 12(0.5,2.96) 13(0,2.96)
  oval 0.864x0.305 smd: 6(2.48,0.98) 7(2.48,1.48) 8(2.48,1.98) 14(-0.48,1.98) 15(-0.48,1.48) 16(-0.48,0.98)
MAG_MMD05CZR47M_4P
  custom 0.591x0.591 smd: 1(0,0) 4(6.248,0)
  rect 1.956x0.508 smd: 2(1.257,0) 3(4.991,0)
MAG_MMD-06CZ-R47M-V1_2P
  rect 1.905x3.988 smd: 1(0,0) 2(5.6,0)
MAG_MMD-06DZIR22MEM2L_2P
  rect 2.362x3.505 smd: 1(0,0) 2(6.05,0)
MC74VHC1G08DFT2G_SC70-5
  oval 0.381x0.711 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
MC74VHC1G09DFT2G_SC70-5
  oval 0.406x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
MC74VHC1G32DFT2G_SC70-5
  oval 0.457x0.711 smd: 1(-0.65,-0.925) 2(0,-0.925) 3(0.65,-0.925) 4(0.65,0.925) 5(-0.65,0.925)
MCP23017T-E-ML_QFN28_6X6
  oval 0.457x1.041 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(2.6,0) 6(3.25,0) 7(3.9,0) 15(3.9,5.95) 16(3.25,5.95) 17(2.6,5.95) 18(1.95,5.95) 19(1.3,5.95) 20(0.65,5.95) 21(0,5.95)
  oval 1.041x0.457 smd: 8(4.925,1.025) 9(4.925,1.675) 10(4.925,2.325) 11(4.925,2.975) 12(4.925,3.625) 13(4.925,4.275) 14(4.925,4.925) 22(-1.025,4.925) 23(-1.025,4.275) 24(-1.025,3.625) 25(-1.025,2.975) 26(-1.025,2.325) 27(-1.025,1.675) 28(-1.025,1.025)
  rect 3.708x3.708 smd: 29(1.95,2.975)
MDU1512RH_POWERDFN56-8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.715)
MDU1516URH_POWERDFN56-8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.715)
MDV1524URH_PDFN33-8-5
  oval 0.406x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0)
  custom 0.65x0.65 smd: 5(0.975,1.475)
MDV1528URH_PDFN33-8-5
  oval 0.406x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0)
  custom 0.65x0.65 smd: 5(0.975,1.475)
MEC5085-LZY_DQFN132_11X11
  oval 0.279x0.711 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2,0) A6(2.5,0) A7(3,0) A8(3.5,0) A9(4,0) A10(4.5,0) A11(5,0) A12(5.5,0) A13(6,0) A14(6.5,0) A15(7,0) A16(7.5,0) A33(7.5,10.9) A34(7,10.9) A35(6.5,10.9) A36(6,10.9) A37(5.5,10.9) A38(5,10.9) A39(4.5,10.9) A40(4,10.9) A41(3.5,10.9) A42(3,10.9) A43(2.5,10.9) A44(2,10.9) A45(1.5,10.9) A46(1,10.9) A47(0.5,10.9) A48(0,10.9)
  oval 0.711x0.279 smd: A17(9.2,1.7) A18(9.2,2.2) A19(9.2,2.7) A20(9.2,3.2) A21(9.2,3.7) A22(9.2,4.2) A23(9.2,4.7) A24(9.2,5.2) A25(9.2,5.7) A26(9.2,6.2) A27(9.2,6.7) A28(9.2,7.2) A29(9.2,7.7) A30(9.2,8.2) A31(9.2,8.7) A32(9.2,9.2) A49(-1.7,9.2) A50(-1.7,8.7) A51(-1.7,8.2) A52(-1.7,7.7) A53(-1.7,7.2) A54(-1.7,6.7) A55(-1.7,6.2) A56(-1.7,5.7) A57(-1.7,5.2) A58(-1.7,4.7) A59(-1.7,4.2) A60(-1.7,3.7) A61(-1.7,3.2) A62(-1.7,2.7) A63(-1.7,2.2) A64(-1.7,1.7)
  oval 0.305x0.61 smd: B1(-0.25,0.85) B2(0.25,0.85) B3(0.75,0.85) B4(1.25,0.85) B5(1.75,0.85) B6(2.25,0.85) B7(2.75,0.85) B8(3.25,0.85) B9(3.75,0.85) B10(4.25,0.85) B11(4.75,0.85) B12(5.25,0.85) B13(5.75,0.85) B14(6.25,0.85) B15(6.75,0.85) B16(7.25,0.85) B17(7.75,0.85) B35(7.75,10.05) B36(7.25,10.05) B37(6.75,10.05) B38(6.25,10.05) B39(5.75,10.05) B40(5.25,10.05) B41(4.75,10.05) B42(4.25,10.05) B43(3.75,10.05) B44(3.25,10.05) B45(2.75,10.05) B46(2.25,10.05) B47(1.75,10.05) B48(1.25,10.05) B49(0.75,10.05) B50(0.25,10.05) B51(-0.25,10.05)
  oval 0.61x0.305 smd: B18(8.35,1.45) B19(8.35,1.95) B20(8.35,2.45) B21(8.35,2.95) B22(8.35,3.45) B23(8.35,3.95) B24(8.35,4.45) B25(8.35,4.95) B26(8.35,5.45) B27(8.35,5.95) B28(8.35,6.45) B29(8.35,6.95) B30(8.35,7.45) B31(8.35,7.95) B32(8.35,8.45) B33(8.35,8.95) B34(8.35,9.45) B52(-0.85,9.45) B53(-0.85,8.95) B54(-0.85,8.45) B55(-0.85,7.95) B56(-0.85,7.45) B57(-0.85,6.95) B58(-0.85,6.45) B59(-0.85,5.95) B60(-0.85,5.45) B61(-0.85,4.95) B62(-0.85,4.45) B63(-0.85,3.95) B64(-0.85,3.45) B65(-0.85,2.95) B66(-0.85,2.45) B67(-0.85,1.95) B68(-0.85,1.45)
  rect 5.004x5.004 smd: C1(3.75,5.45)
MMBT3904WH_SOT323-3
  oval 0.61x0.787 smd: 1(0,0) 2(-0.65,-1.6) 3(0.65,-1.6)
MMBT3904WH_SOT323-3-S
  oval 0.61x1.041 smd: 1(0,0) 2(-0.65,-1.854) 3(0.65,-1.854)
MURAT_BLM15AG102SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM15AX700SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM15BB220SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
MURAT_BLM15PX221SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM15PX600SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM21PG600SN1D_L0805_2P
  rect 0.991x1.753 smd: 1(0,0) 2(1.5,0)
N15P-GT_BGA_908P
  round 0.381 smd: A2(0.8,0) A3(1.6,0) A5(3.3,0) A6(4.1,0) A8(5.8,0) A9(6.6,0) A11(8.3,0) A12(9.1,0) A14(10.8,0) A15(11.6,0) A17(13.3,0) A18(14.1,0) A20(15.8,0) A21(16.6,0) A23(18.3,0) A24(19.1,0) A26(20.8,0) A27(21.6,0) A29(23.3,0) A30(24.1,0) A32(25.8,0) A33(26.6,0) AA1(0,-16.6) AA2(0.8,-16.6) AA3(1.6,-16.6) AA4(2.4,-16.6) AA5(3.2,-16.6) AA6(4.05,-16.6) AA7(4.9,-16.6) AA8(5.7,-16.6) AA27(21.7,-16.6) AA28(22.5,-16.6) AA29(23.35,-16.6) AA30(24.2,-16.6) AA31(25,-16.6) AA32(25.8,-16.6) AA33(26.6,-16.6) AA34(27.4,-16.6) AB2(0.8,-17.45) AB3(1.6,-17.45) AB4(2.4,-17.45) AB5(3.2,-17.45) AB7(4.9,-17.45) AB8(5.7,-17.45) AB27(21.7,-17.45) AB28(22.5,-17.45) AB30(24.2,-17.45) AB31(25,-17.45) AB32(25.8,-17.45) AB33(26.6,-17.45) AC1(0,-18.3) AC2(0.8,-18.3) AC3(1.6,-18.3) AC4(2.4,-18.3) AC5(3.2,-18.3) AC6(4.05,-18.3) AC7(4.9,-18.3) AC8(5.7,-18.3) AC27(21.7,-18.3) AC28(22.5,-18.3) AC29(23.35,-18.3) AC30(24.2,-18.3) AC31(25,-18.3) AC32(25.8,-18.3) AC33(26.6,-18.3) AC34(27.4,-18.3) AD1(0,-19.1) AD2(0.8,-19.1) AD3(1.6,-19.1) AD4(2.4,-19.1) AD5(3.2,-19.1) AD6(4.05,-19.1) AD7(4.9,-19.1) AD8(5.7,-19.1) AD27(21.7,-19.1) AD28(22.5,-19.1) AD29(23.35,-19.1) AD30(24.2,-19.1) AD31(25,-19.1) AD32(25.8,-19.1) AD33(26.6,-19.1) AD34(27.4,-19.1) AE2(0.8,-19.95) AE3(1.6,-19.95) AE4(2.4,-19.95) AE5(3.2,-19.95) AE7(4.9,-19.95) AE8(5.7,-19.95) AE27(21.7,-19.95) AE28(22.5,-19.95) AE30(24.2,-19.95) AE31(25,-19.95) AE32(25.8,-19.95) AE33(26.6,-19.95) AF1(0,-20.8) AF2(0.8,-20.8) AF3(1.6,-20.8) AF4(2.4,-20.8) AF5(3.2,-20.8) AF6(4.05,-20.8) AF7(4.9,-20.8) AF8(5.7,-20.8) AF27(21.7,-20.8) AF28(22.5,-20.8) AF29(23.35,-20.8) AF30(24.2,-20.8) AF31(25,-20.8) AF32(25.8,-20.8) AF33(26.6,-20.8) AF34(27.4,-20.8) AG1(0,-21.6) AG2(0.8,-21.6) AG3(1.6,-21.6) AG4(2.4,-21.6) AG5(3.2,-21.6) AG6(4.05,-21.6) AG7(4.9,-21.6) AG8(5.7,-21.7) AG9(6.6,-21.7) AG10(7.45,-21.7) AG11(8.3,-21.7) AG12(9.1,-21.7) AG13(9.95,-21.7) AG14(10.8,-21.7) AG15(11.6,-21.7) AG16(12.45,-21.7) AG17(13.3,-21.7) AG18(14.1,-21.7) AG19(14.95,-21.7) AG20(15.8,-21.7) AG21(16.6,-21.7) AG22(17.45,-21.7) AG23(18.3,-21.7) AG24(19.1,-21.7) AG25(19.95,-21.7) AG26(20.8,-21.7) AG27(21.7,-21.7) AG28(22.5,-21.6) AG29(23.35,-21.6) AG30(24.2,-21.6) AG31(25,-21.6) AG32(25.8,-21.6) AG33(26.6,-21.6) AG34(27.4,-21.6) AH2(0.8,-22.45) AH3(1.6,-22.45) AH4(2.4,-22.45) AH5(3.2,-22.45) AH6(4.05,-22.45) AH7(4.9,-22.5) AH8(5.8,-22.5) AH9(6.6,-22.5) AH10(7.45,-22.5) AH11(8.3,-22.5) AH12(9.1,-22.5) AH13(9.95,-22.5) AH14(10.8,-22.5) AH15(11.6,-22.5) AH16(12.45,-22.5) AH17(13.3,-22.5) AH18(14.1,-22.5) AH19(14.95,-22.5) AH20(15.8,-22.5) AH21(16.6,-22.5) AH22(17.45,-22.5) AH23(18.3,-22.5) AH24(19.1,-22.5) AH25(19.95,-22.5) AH26(20.8,-22.5) AH27(21.6,-22.5) AH28(22.5,-22.5) AH29(23.35,-22.45) AH30(24.2,-22.45) AH31(25,-22.45) AH32(25.8,-22.45) AH33(26.6,-22.45) AJ1(0,-23.3) AJ2(0.8,-23.3) AJ3(1.6,-23.3) AJ4(2.4,-23.3) AJ5(3.2,-23.3) AJ6(4.05,-23.35) AJ7(4.95,-23.35) AJ8(5.8,-23.35) AJ9(6.6,-23.35) AJ11(8.3,-23.35) AJ12(9.1,-23.35) AJ14(10.8,-23.35) AJ15(11.6,-23.35) AJ17(13.3,-23.35) AJ18(14.1,-23.35) AJ20(15.8,-23.35) AJ21(16.6,-23.35) AJ23(18.3,-23.35) AJ24(19.1,-23.35) AJ26(20.8,-23.35) AJ27(21.6,-23.35) AJ28(22.45,-23.35) AJ29(23.35,-23.35) AJ30(24.2,-23.3) AJ31(25,-23.3) AJ32(25.8,-23.3) AJ33(26.6,-23.3) AJ34(27.4,-23.3) AK1(0,-24.1) AK2(0.8,-24.1) AK3(1.6,-24.1) AK4(2.4,-24.1) AK5(3.2,-24.2) AK6(4.1,-24.2) AK7(4.95,-24.2) AK8(5.8,-24.2) AK9(6.6,-24.2) AK10(7.45,-24.2) AK11(8.3,-24.2) AK12(9.1,-24.2) AK13(9.95,-24.2) AK14(10.8,-24.2) AK15(11.6,-24.2) AK16(12.45,-24.2) AK17(13.3,-24.2) AK18(14.1,-24.2) AK19(14.95,-24.2) AK20(15.8,-24.2) AK21(16.6,-24.2) AK22(17.45,-24.2) AK23(18.3,-24.2) AK24(19.1,-24.2) AK25(19.95,-24.2) AK26(20.8,-24.2) AK27(21.6,-24.2) AK28(22.45,-24.2) AK29(23.3,-24.2) AK30(24.2,-24.2) AK31(25,-24.1) AK32(25.8,-24.1) AK33(26.6,-24.1) AK34(27.4,-24.1) AL2(0.8,-24.95) AL3(1.6,-24.95) AL4(2.4,-25) AL5(3.3,-25) AL6(4.1,-25) AL7(4.95,-25) AL8(5.8,-25) AL9(6.6,-25) AL10(7.45,-25) AL11(8.3,-25) AL12(9.1,-25) AL13(9.95,-25) AL14(10.8,-25) AL15(11.6,-25) AL16(12.45,-25) AL17(13.3,-25) AL18(14.1,-25) AL19(14.95,-25) AL20(15.8,-25) AL21(16.6,-25) AL22(17.45,-25) AL23(18.3,-25) AL24(19.1,-25) AL25(19.95,-25) AL26(20.8,-25) AL27(21.6,-25) AL28(22.45,-25) AL29(23.3,-25) AL30(24.1,-25) AL31(25,-25) AL32(25.8,-24.95) AL33(26.6,-24.95) AM1(0,-25.8) AM2(0.8,-25.8) AM3(1.6,-25.8) AM4(2.45,-25.8) AM5(3.3,-25.8) AM6(4.1,-25.8) AM7(4.95,-25.8) AM8(5.8,-25.8) AM9(6.6,-25.8) AM10(7.45,-25.8) AM11(8.3,-25.8) AM12(9.1,-25.8) AM13(9.95,-25.8) AM14(10.8,-25.8) AM15(11.6,-25.8) AM16(12.45,-25.8) AM17(13.3,-25.8) AM18(14.1,-25.8) AM19(14.95,-25.8) AM20(15.8,-25.8) AM21(16.6,-25.8) AM22(17.45,-25.8) AM23(18.3,-25.8) AM24(19.1,-25.8) AM25(19.95,-25.8) AM26(20.8,-25.8) AM27(21.6,-25.8) AM28(22.45,-25.8) AM29(23.3,-25.8) AM30(24.1,-25.8) AM31(24.95,-25.8) AM32(25.8,-25.8) AM33(26.6,-25.8) AM34(27.4,-25.8) AN1(0,-26.6) AN2(0.8,-26.6) AN3(1.6,-26.6) AN4(2.45,-26.6) AN5(3.3,-26.6) AN6(4.1,-26.6) AN7(4.95,-26.6) AN8(5.8,-26.6) AN9(6.6,-26.6) AN10(7.45,-26.6) AN11(8.3,-26.6) AN12(9.1,-26.6) AN13(9.95,-26.6) AN14(10.8,-26.6) AN15(11.6,-26.6) AN16(12.45,-26.6) AN17(13.3,-26.6) AN18(14.1,-26.6) AN19(14.95,-26.6) AN20(15.8,-26.6) AN21(16.6,-26.6) AN22(17.45,-26.6) AN23(18.3,-26.6) AN24(19.1,-26.6) AN25(19.95,-26.6) AN26(20.8,-26.6) AN27(21.6,-26.6) AN28(22.45,-26.6) AN29(23.3,-26.6) AN30(24.1,-26.6) AN31(24.95,-26.6) AN32(25.8,-26.6) AN33(26.6,-26.6) AN34(27.4,-26.6) AP2(0.8,-27.4) AP3(1.6,-27.4) AP5(3.3,-27.4) AP6(4.1,-27.4) AP8(5.8,-27.4) AP9(6.6,-27.4) AP11(8.3,-27.4) AP12(9.1,-27.4) AP14(10.8,-27.4) AP15(11.6,-27.4) AP17(13.3,-27.4) AP18(14.1,-27.4) AP20(15.8,-27.4) AP21(16.6,-27.4) AP23(18.3,-27.4) AP24(19.1,-27.4) AP26(20.8,-27.4) AP27(21.6,-27.4) AP29(23.3,-27.4) AP30(24.1,-27.4) AP32(25.8,-27.4) AP33(26.6,-27.4) B1(0,-0.8) B2(0.8,-0.8) B3(1.6,-0.8) B4(2.45,-0.8) B5(3.3,-0.8) B6(4.1,-0.8) B7(4.95,-0.8) B8(5.8,-0.8) B9(6.6,-0.8) B10(7.45,-0.8) B11(8.3,-0.8) B12(9.1,-0.8) B13(9.95,-0.8) B14(10.8,-0.8) B15(11.6,-0.8) B16(12.45,-0.8) B17(13.3,-0.8) B18(14.1,-0.8) B19(14.95,-0.8) B20(15.8,-0.8) B21(16.6,-0.8) B22(17.45,-0.8) B23(18.3,-0.8) B24(19.1,-0.8) B25(19.95,-0.8) B26(20.8,-0.8) B27(21.6,-0.8) B28(22.45,-0.8) B29(23.3,-0.8) B30(24.1,-0.8) B31(24.95,-0.8) B32(25.8,-0.8) B33(26.6,-0.8) B34(27.4,-0.8) C1(0,-1.6) C2(0.8,-1.6) C3(1.6,-1.6) C4(2.45,-1.6) C5(3.3,-1.6) C6(4.1,-1.6) C7(4.95,-1.6) C8(5.8,-1.6) C9(6.6,-1.6) C10(7.45,-1.6) C11(8.3,-1.6) C12(9.1,-1.6) C13(9.95,-1.6) C14(10.8,-1.6) C15(11.6,-1.6) C16(12.45,-1.6) C17(13.3,-1.6) C18(14.1,-1.6) C19(14.95,-1.6) C20(15.8,-1.6) C21(16.6,-1.6) C22(17.45,-1.6) C23(18.3,-1.6) C24(19.1,-1.6) C25(19.95,-1.6) C26(20.8,-1.6) C27(21.6,-1.6) C28(22.45,-1.6) C29(23.3,-1.6) C30(24.1,-1.6) C31(24.95,-1.6) C32(25.8,-1.6) C33(26.6,-1.6) C34(27.4,-1.6) D2(0.8,-2.45) D3(1.6,-2.45) D4(2.4,-2.4) D5(3.3,-2.4) D6(4.1,-2.4) D7(4.95,-2.4) D8(5.8,-2.4) D9(6.6,-2.4) D10(7.45,-2.4) D11(8.3,-2.4) D12(9.1,-2.4) D13(9.95,-2.4) D14(10.8,-2.4) D15(11.6,-2.4) D16(12.45,-2.4) D17(13.3,-2.4) D18(14.1,-2.4) D19(14.95,-2.4) D20(15.8,-2.4) D21(16.6,-2.4) D22(17.45,-2.4) D23(18.3,-2.4) D24(19.1,-2.4) D25(19.95,-2.4) D26(20.8,-2.4) D27(21.6,-2.4) D28(22.45,-2.4) D29(23.3,-2.4) D30(24.1,-2.4) D31(25,-2.4) D32(25.8,-2.45) D33(26.6,-2.45) E1(0,-3.3) E2(0.8,-3.3) E3(1.6,-3.3) E4(2.4,-3.3) E5(3.2,-3.2) E6(4.1,-3.2) E7(4.95,-3.2) E8(5.8,-3.2) E9(6.6,-3.2) E10(7.45,-3.2) E11(8.3,-3.2) E12(9.1,-3.2) E13(9.95,-3.2) E14(10.8,-3.2) E15(11.6,-3.2) E16(12.45,-3.2) E17(13.3,-3.2) E18(14.1,-3.2) E19(14.95,-3.2) E20(15.8,-3.2) E21(16.6,-3.2) E22(17.45,-3.2) E23(18.3,-3.2) E24(19.1,-3.2) E25(19.95,-3.2) E26(20.8,-3.2) E27(21.6,-3.2) E28(22.45,-3.2) E29(23.3,-3.2) E30(24.2,-3.2) E31(25,-3.3) E32(25.8,-3.3) E33(26.6,-3.3) E34(27.4,-3.3) F1(0,-4.1) F2(0.8,-4.1) F3(1.6,-4.1) F4(2.4,-4.1) F5(3.2,-4.1) F6(4.05,-4.05) F7(4.95,-4.05) F8(5.8,-4.05) F9(6.6,-4.05) F11(8.3,-4.05) F12(9.1,-4.05) F14(10.8,-4.05) F15(11.6,-4.05) F17(13.3,-4.05) F18(14.1,-4.05) F20(15.8,-4.05) F21(16.6,-4.05) F23(18.3,-4.05) F24(19.1,-4.05) F26(20.8,-4.05) F27(21.6,-4.05) F28(22.45,-4.05) F29(23.35,-4.05) F30(24.2,-4.1) F31(25,-4.1) F32(25.8,-4.1) F33(26.6,-4.1) F34(27.4,-4.1) G2(0.8,-4.95) G3(1.6,-4.95) G4(2.4,-4.95) G5(3.2,-4.95) G6(4.05,-4.95) G7(4.9,-4.9) G8(5.8,-4.9) G9(6.6,-4.9) G10(7.45,-4.9) G11(8.3,-4.9) G12(9.1,-4.9) G13(9.95,-4.9) G14(10.8,-4.9) G15(11.6,-4.9) G16(12.45,-4.9) G17(13.3,-4.9) G18(14.1,-4.9) G19(14.95,-4.9) G20(15.8,-4.9) G21(16.6,-4.9) G22(17.45,-4.9) G23(18.3,-4.9) G24(19.1,-4.9) G25(19.95,-4.9) G26(20.8,-4.9) G27(21.6,-4.9) G28(22.5,-4.9) G29(23.35,-4.95) G30(24.2,-4.95) G31(25,-4.95) G32(25.8,-4.95) G33(26.6,-4.95) H1(0,-5.8) H2(0.8,-5.8) H3(1.6,-5.8) H4(2.4,-5.8) H5(3.2,-5.8) H6(4.05,-5.8) H7(4.9,-5.8) H8(5.7,-5.7) H9(6.6,-5.7) H10(7.45,-5.7) H11(8.3,-5.7) H12(9.1,-5.7) H13(9.95,-5.7) H14(10.8,-5.7) H15(11.6,-5.7) H16(12.45,-5.7) H17(13.3,-5.7) H18(14.1,-5.7) H19(14.95,-5.7) H20(15.8,-5.7) H21(16.6,-5.7) H22(17.45,-5.7) H23(18.3,-5.7) H24(19.1,-5.7) H25(19.95,-5.7) H26(20.8,-5.7) H27(21.7,-5.7) H28(22.5,-5.8) H29(23.35,-5.8) H30(24.2,-5.8) H31(25,-5.8) H32(25.8,-5.8) H33(26.6,-5.8) H34(27.4,-5.8) J1(0,-6.6) J2(0.8,-6.6) J3(1.6,-6.6) J4(2.4,-6.6) J5(3.2,-6.6) J6(4.05,-6.6) J7(4.9,-6.6) J8(5.7,-6.6) J27(21.7,-6.6) J28(22.5,-6.6) J29(23.35,-6.6) J30(24.2,-6.6) J31(25,-6.6) J32(25.8,-6.6) J33(26.6,-6.6) J34(27.4,-6.6) K2(0.8,-7.45) K3(1.6,-7.45) K4(2.4,-7.45) K5(3.2,-7.45) K7(4.9,-7.45) K8(5.7,-7.45) K27(21.7,-7.45) K28(22.5,-7.45) K30(24.2,-7.45) K31(25,-7.45) K32(25.8,-7.45) K33(26.6,-7.45) L1(0,-8.3) L2(0.8,-8.3) L3(1.6,-8.3) L4(2.4,-8.3) L5(3.2,-8.3) L6(4.05,-8.3) L7(4.9,-8.3) L8(5.7,-8.3) L27(21.7,-8.3) L28(22.5,-8.3) L29(23.35,-8.3) L30(24.2,-8.3) L31(25,-8.3) L32(25.8,-8.3) L33(26.6,-8.3) L34(27.4,-8.3) M1(0,-9.1) M2(0.8,-9.1) M3(1.6,-9.1) M4(2.4,-9.1) M5(3.2,-9.1) M6(4.05,-9.1) M7(4.9,-9.1) M8(5.7,-9.1) M27(21.7,-9.1) M28(22.5,-9.1) M29(23.35,-9.1) M30(24.2,-9.1) M31(25,-9.1) M32(25.8,-9.1) M33(26.6,-9.1) M34(27.4,-9.1) N2(0.8,-9.95) N3(1.6,-9.95) N4(2.4,-9.95) N5(3.2,-9.95) N7(4.9,-9.95) N8(5.7,-9.95) N27(21.7,-9.95) N28(22.5,-9.95) N30(24.2,-9.95) N31(25,-9.95) N32(25.8,-9.95) N33(26.6,-9.95) P1(0,-10.8) P2(0.8,-10.8) P3(1.6,-10.8) P4(2.4,-10.8) P5(3.2,-10.8) P6(4.05,-10.8) P7(4.9,-10.8) P8(5.7,-10.8) P27(21.7,-10.8) P28(22.5,-10.8) P29(23.35,-10.8) P30(24.2,-10.8) P31(25,-10.8) P32(25.8,-10.8) P33(26.6,-10.8) P34(27.4,-10.8) R1(0,-11.6) R2(0.8,-11.6) R3(1.6,-11.6) R4(2.4,-11.6) R5(3.2,-11.6) R6(4.05,-11.6) R7(4.9,-11.6) R8(5.7,-11.6) R27(21.7,-11.6) R28(22.5,-11.6) R29(23.35,-11.6) R30(24.2,-11.6) R31(25,-11.6) R32(25.8,-11.6) R33(26.6,-11.6) R34(27.4,-11.6) T2(0.8,-12.45) T3(1.6,-12.45) T4(2.4,-12.45) T5(3.2,-12.45) T7(4.9,-12.45) T8(5.7,-12.45) T27(21.7,-12.45) T28(22.5,-12.45) T30(24.2,-12.45) T31(25,-12.45) T32(25.8,-12.45) T33(26.6,-12.45) U1(0,-13.3) U2(0.8,-13.3) U3(1.6,-13.3) U4(2.4,-13.3) U5(3.2,-13.3) U6(4.05,-13.3) U7(4.9,-13.3) U8(5.7,-13.3) U27(21.7,-13.3) U28(22.5,-13.3) U29(23.35,-13.3) U30(24.2,-13.3) U31(25,-13.3) U32(25.8,-13.3) U33(26.6,-13.3) U34(27.4,-13.3) V1(0,-14.1) V2(0.8,-14.1) V3(1.6,-14.1) V4(2.4,-14.1) V5(3.2,-14.1) V6(4.05,-14.1) V7(4.9,-14.1) V8(5.7,-14.1) V27(21.7,-14.1) V28(22.5,-14.1) V29(23.35,-14.1) V30(24.2,-14.1) V31(25,-14.1) V32(25.8,-14.1) V33(26.6,-14.1) V34(27.4,-14.1) W2(0.8,-14.95) W3(1.6,-14.95) W4(2.4,-14.95) W5(3.2,-14.95) W7(4.9,-14.95) W8(5.7,-14.95) W27(21.7,-14.95) W28(22.5,-14.95) W30(24.2,-14.95) W31(25,-14.95) W32(25.8,-14.95) W33(26.6,-14.95) Y1(0,-15.8) Y2(0.8,-15.8) Y3(1.6,-15.8) Y4(2.4,-15.8) Y5(3.2,-15.8) Y6(4.05,-15.8) Y7(4.9,-15.8) Y8(5.7,-15.8) Y27(21.7,-15.8) Y28(22.5,-15.8) Y29(23.35,-15.8) Y30(24.2,-15.8) Y31(25,-15.8) Y32(25.8,-15.8) Y33(26.6,-15.8) Y34(27.4,-15.8)
  round 0.406 smd: AA12(8.2,-17.2) AA13(9.2,-17.2) AA14(10.2,-17.2) AA15(11.2,-17.2) AA16(12.2,-17.2) AA17(13.2,-17.2) AA18(14.2,-17.2) AA19(15.2,-17.2) AA20(16.2,-17.2) AA21(17.2,-17.2) AA22(18.2,-17.2) AA23(19.2,-17.2) AB12(8.2,-18.2) AB13(9.2,-18.2) AB14(10.2,-18.2) AB15(11.2,-18.2) AB16(12.2,-18.2) AB17(13.2,-18.2) AB18(14.2,-18.2) AB19(15.2,-18.2) AB20(16.2,-18.2) AB21(17.2,-18.2) AB22(18.2,-18.2) AB23(19.2,-18.2) AC12(8.2,-19.2) AC13(9.2,-19.2) AC14(10.2,-19.2) AC15(11.2,-19.2) AC16(12.2,-19.2) AC17(13.2,-19.2) AC18(14.2,-19.2) AC19(15.2,-19.2) AC20(16.2,-19.2) AC21(17.2,-19.2) AC22(18.2,-19.2) AC23(19.2,-19.2) M12(8.2,-8.2) M13(9.2,-8.2) M14(10.2,-8.2) M15(11.2,-8.2) M16(12.2,-8.2) M17(13.2,-8.2) M18(14.2,-8.2) M19(15.2,-8.2) M20(16.2,-8.2) M21(17.2,-8.2) M22(18.2,-8.2) M23(19.2,-8.2) N12(8.2,-9.2) N13(9.2,-9.2) N14(10.2,-9.2) N15(11.2,-9.2) N16(12.2,-9.2) N17(13.2,-9.2) N18(14.2,-9.2) N19(15.2,-9.2) N20(16.2,-9.2) N21(17.2,-9.2) N22(18.2,-9.2) N23(19.2,-9.2) P12(8.2,-10.2) P13(9.2,-10.2) P14(10.2,-10.2) P15(11.2,-10.2) P16(12.2,-10.2) P17(13.2,-10.2) P18(14.2,-10.2) P19(15.2,-10.2) P20(16.2,-10.2) P21(17.2,-10.2) P22(18.2,-10.2) P23(19.2,-10.2) R12(8.2,-11.2) R13(9.2,-11.2) R14(10.2,-11.2) R15(11.2,-11.2) R16(12.2,-11.2) R17(13.2,-11.2) R18(14.2,-11.2) R19(15.2,-11.2) R20(16.2,-11.2) R21(17.2,-11.2) R22(18.2,-11.2) R23(19.2,-11.2) T12(8.2,-12.2) T13(9.2,-12.2) T14(10.2,-12.2) T15(11.2,-12.2) T16(12.2,-12.2) T17(13.2,-12.2) T18(14.2,-12.2) T19(15.2,-12.2) T20(16.2,-12.2) T21(17.2,-12.2) T22(18.2,-12.2) T23(19.2,-12.2) U12(8.2,-13.2) U13(9.2,-13.2) U14(10.2,-13.2) U15(11.2,-13.2) U16(12.2,-13.2) U17(13.2,-13.2) U18(14.2,-13.2) U19(15.2,-13.2) U20(16.2,-13.2) U21(17.2,-13.2) U22(18.2,-13.2) U23(19.2,-13.2) V12(8.2,-14.2) V13(9.2,-14.2) V14(10.2,-14.2) V15(11.2,-14.2) V16(12.2,-14.2) V17(13.2,-14.2) V18(14.2,-14.2) V19(15.2,-14.2) V20(16.2,-14.2) V21(17.2,-14.2) V22(18.2,-14.2) V23(19.2,-14.2) W12(8.2,-15.2) W13(9.2,-15.2) W14(10.2,-15.2) W15(11.2,-15.2) W16(12.2,-15.2) W17(13.2,-15.2) W18(14.2,-15.2) W19(15.2,-15.2) W20(16.2,-15.2) W21(17.2,-15.2) W22(18.2,-15.2) W23(19.2,-15.2) Y12(8.2,-16.2) Y13(9.2,-16.2) Y14(10.2,-16.2) Y15(11.2,-16.2) Y16(12.2,-16.2) Y17(13.2,-16.2) Y18(14.2,-16.2) Y19(15.2,-16.2) Y20(16.2,-16.2) Y21(17.2,-16.2) Y22(18.2,-16.2) Y23(19.2,-16.2)
NL17SZ14DFT2G_SOT353-5
  oval 0.381x1.219 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
NPCT650JAAYX_QFN32_5X5
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2) 6(0,-2.5) 7(0,-3) 8(0,-3.5) 17(5.1,-3.5) 18(5.1,-3) 19(5.1,-2.5) 20(5.1,-2) 21(5.1,-1.5) 22(5.1,-1) 23(5.1,-0.5) 24(5.1,0)
  oval 0.254x0.889 smd: 9(0.8,-4.3) 10(1.3,-4.3) 11(1.8,-4.3) 12(2.3,-4.3) 13(2.8,-4.3) 14(3.3,-4.3) 15(3.8,-4.3) 16(4.3,-4.3) 25(4.3,0.8) 26(3.8,0.8) 27(3.3,0.8) 28(2.8,0.8) 29(2.3,0.8) 30(1.8,0.8) 31(1.3,0.8) 32(0.8,0.8)
  rect 3.505x3.505 smd: 33(2.55,-1.75)
NTR4502PT1G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PCA9515BDGKR_VSSOP8
  oval 0.381x1.575 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,4.35) 6(1.3,4.35) 7(0.65,4.35) 8(0,4.35)
PESD5V0U2BT_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PESD24VS2UT_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PS8713BTQFN24GTR2_TQFN24_4X4
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 13(2.5,4.1) 14(2,4.1) 15(1.5,4.1) 16(1,4.1) 17(0.5,4.1) 18(0,4.1)
  oval 0.889x0.254 smd: 7(3.3,0.8) 8(3.3,1.3) 9(3.3,1.8) 10(3.3,2.3) 11(3.3,2.8) 12(3.3,3.3) 19(-0.8,3.3) 20(-0.8,2.8) 21(-0.8,2.3) 22(-0.8,1.8) 23(-0.8,1.3) 24(-0.8,0.8)
  rect 2.692x2.692 smd: 25(1.25,2.05)
R0402_0OHM
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R0402_0OHM-NPM
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R0603_0OHM
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R0805_0OHM
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_0201
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
R_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_1206
  rect 1.016x1.651 smd: 1(0,0) 2(2.667,0)
R_1206_4P-D
  custom 0.371x0.371 smd: 1(0,0) 4(3.327,0)
  custom 0.114x0.114 smd: 2(0.775,0) 3(2.553,0)
RB751S40T1G_SOD523-2
  rect 0.406x0.406 smd: 1(0,0) 2(1.4,0)
RJU003N03_UMT3
  oval 0.787x0.889 smd: 1(0,0) 2(-0.65,-1.6) 3(0.65,-1.6)
RL-3264-9W-R005-FNH_2512_2512
  rect 2.108x2.489 smd: 1(0,0) 4(1.35,-4.3)
  rect 1.041x2.489 smd: 2(1.875,0) 3(-0.525,-4.3)
RP_0804_8P4R
  oval 0.66x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(1.15,-1.5) 6(1.15,-1) 7(1.15,-0.5) 8(1.15,0)
RP_1206_10P8R
  oval 0.356x0.914 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(2.6,0) 6(2.6,1.422) 7(1.95,1.422) 8(1.3,1.422) 9(0.65,1.422) 10(0,1.422)
RT8816AGQW_WQFN20_3X3
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,3.1) 12(1.2,3.1) 13(0.8,3.1) 14(0.4,3.1) 15(0,3.1)
  oval 0.889x0.203 smd: 6(2.35,0.75) 7(2.35,1.15) 8(2.35,1.55) 9(2.35,1.95) 10(2.35,2.35) 16(-0.75,2.35) 17(-0.75,1.95) 18(-0.75,1.55) 19(-0.75,1.15) 20(-0.75,0.75)
  rect 1.702x1.702 smd: 21(0.8,1.55)
RT9059GQW_WDFN10_3X3
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,3.1) 7(1.5,3.1) 8(1,3.1) 9(0.5,3.1) 10(0,3.1)
  rect 2.464x1.626 smd: 11(1,1.55)
RT9069-33GB_SOT23-5
  oval 0.711x0.991 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.6) 5(0,2.6)
RTS5242-GR_QFN32_4X4
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 17(4.1,-2.8) 18(4.1,-2.4) 19(4.1,-2) 20(4.1,-1.6) 21(4.1,-1.2) 22(4.1,-0.8) 23(4.1,-0.4) 24(4.1,0)
  oval 0.203x0.889 smd: 9(0.65,-3.45) 10(1.05,-3.45) 11(1.45,-3.45) 12(1.85,-3.45) 13(2.25,-3.45) 14(2.65,-3.45) 15(3.05,-3.45) 16(3.45,-3.45) 25(3.45,0.65) 26(3.05,0.65) 27(2.65,0.65) 28(2.25,0.65) 29(1.85,0.65) 30(1.45,0.65) 31(1.05,0.65) 32(0.65,0.65)
  rect 2.692x2.692 smd: 33(2.05,-1.4)
SAMTE_BSH-030-01-L-D-A_60P
  round 1.016 hole 1.016 unplated: (-2.81,5.53) (17.316,5.53)
  oval 0.279x2.261 smd: 1(0,0) 2(0,5.728) 3(0.5,0) 4(0.5,5.728) 5(1,0) 6(1,5.728) 7(1.5,0) 8(1.5,5.728) 9(2,0) 10(2,5.728) 11(2.5,0) 12(2.5,5.728) 13(3,0) 14(3,5.728) 15(3.5,0) 16(3.5,5.728) 17(4,0) 18(4,5.728) 19(4.5,0) 20(4.5,5.728) 21(5,0) 22(5,5.728) 23(5.5,0) 24(5.5,5.728) 25(6,0) 26(6,5.728) 27(6.5,0) 28(6.5,5.728) 29(7,0) 30(7,5.728) 31(7.5,0) 32(7.5,5.728) 33(8,0) 34(8,5.728) 35(8.5,0) 36(8.5,5.728) 37(9,0) 38(9,5.728) 39(9.5,0) 40(9.5,5.728) 41(10,0) 42(10,5.728) 43(10.5,0) 44(10.5,5.728) 45(11,0) 46(11,5.728) 47(11.5,0) 48(11.5,5.728) 49(12,0) 50(12,5.728) 51(12.5,0) 52(12.5,5.728) 53(13,0) 54(13,5.728) 55(13.5,0) 56(13.5,5.728) 57(14,0) 58(14,5.728) 59(14.5,0) 60(14.5,5.728)
SDMK0340L-7-F_SOD323-2
  rect 1.346x0.66 smd: 1(0,0) 2(2.4,0)
SHORTPADS
  custom 0.19x0.19 smd: 1(-0.483,0) 2(0.483,0)
SI3457BDV-T1-E3_TSOP6
  oval 0.508x1.448 smd: 1(0,0) 2(1,0) 3(2,0) 4(2,2.425) 5(1,2.425) 6(0,2.425)
SIR472DP-T1-GE3_POWERPAK8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.715)
SIRA06DP-T1-GE_POWERPAKSO-8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.715)
SKL-H_BGA_1440P-T
  round 0.406 smd: A3(-1.254,0) A37(-26.054,0) B2(-0.66,0.66) B38(-26.628,0.553) BR1(0,40.062) BR38(-26.628,40.036) BT2(-0.571,40.628) BT37(-26.037,40.628) C1(0,1.267)
  round 0.381 smd: A4(-1.971,0) A34(-24.46,0) A36(-25.272,0) AA13(-7.813,14.548) AA14(-8.463,14.548) AA29(-20.725,14.415) AA30(-21.376,14.415) AB29(-20.725,15.203) AB30(-21.376,15.203) AC13(-7.813,15.463) AC14(-8.463,15.463) AC29(-20.725,15.99) AC30(-21.376,15.99) AD13(-7.813,16.377) AD14(-8.463,16.377) AD29(-20.725,16.777) AD30(-21.376,16.777) AE13(-7.813,17.291) AE14(-8.463,17.291) AE29(-20.725,17.565) AE30(-21.376,17.565) AF13(-7.813,18.206) AF14(-8.463,18.206) AF29(-20.725,18.352) AF30(-21.376,18.352) AG13(-7.813,19.12) AG14(-8.463,19.12) AG29(-20.725,19.14) AG30(-21.376,19.14) AH13(-7.813,20.035) AH14(-8.463,20.035) AH29(-20.725,19.927) AH30(-21.376,19.927) AJ13(-7.813,20.949) AJ14(-8.463,20.949) AJ29(-20.725,20.714) AJ30(-21.376,20.714) AK29(-20.725,21.502) AK30(-21.376,21.502) AL13(-7.813,21.863) AL14(-8.463,21.863) AL29(-20.725,22.289) AL30(-21.376,22.289) AM13(-7.813,22.778) AM14(-8.463,22.778) AM29(-20.725,23.077) AM30(-21.376,23.077) AN13(-7.813,23.692) AN14(-8.463,23.692) AN29(-20.725,23.864) AN30(-21.376,23.864) AP13(-7.813,24.607) AP14(-8.463,24.607) AP29(-20.725,24.651) AP30(-21.376,24.651) AR13(-7.813,25.521) AR14(-8.463,25.521) AR29(-20.725,25.439) AR30(-21.376,25.439) AT13(-7.813,26.435) AT14(-8.463,26.435) AT29(-20.725,26.226) AT30(-21.376,26.226) AU13(-7.813,27.35) AU14(-8.463,27.35) AU29(-20.725,27.014) AU30(-21.376,27.014) AV29(-20.725,27.801) AV30(-21.376,27.801) AW13(-7.813,28.264) AW14(-8.463,28.264) AW29(-20.725,28.588) AW30(-21.376,28.588) AY13(-7.813,29.179) AY14(-8.463,29.179) AY29(-20.725,29.376) AY30(-21.376,29.376) B3(-1.382,0.699) B37(-25.909,0.703) BA13(-7.813,30.093) BA14(-8.463,30.093) BA29(-20.725,30.163) BA30(-21.376,30.163) BB13(-7.813,31.007) BB14(-8.463,31.007) BB29(-20.725,30.951) BB30(-21.376,30.951) BC13(-7.813,31.922) BC14(-8.463,31.922) BC29(-20.725,31.738) BC30(-21.376,31.738) BD13(-7.813,32.836) BD14(-8.463,32.836) BD29(-20.725,32.525) BD30(-21.376,32.525) BE29(-20.725,33.313) BE30(-21.376,33.313) BF13(-7.813,33.751) BF14(-8.463,33.751) BF29(-20.725,34.1) BF30(-21.376,34.1) BG13(-7.813,34.665) BG14(-8.463,34.665) BG29(-20.725,34.888) BG30(-21.376,34.888) BH13(-7.813,35.579) BH14(-8.463,35.541) BH29(-20.725,35.548) BH30(-21.376,35.675) BJ13(-8.171,36.126) BJ14(-8.851,36.077) BJ15(-9.601,36.077) BJ16(-10.388,36.077) BJ17(-11.175,36.077) BJ18(-11.963,36.077) BJ19(-12.75,36.077) BJ20(-13.538,36.077) BJ21(-14.325,36.077) BJ22(-15.112,36.077) BJ23(-15.9,36.077) BJ24(-16.687,36.077) BJ25(-17.475,36.077) BJ26(-18.262,36.077) BJ27(-19.049,36.077) BJ28(-19.837,36.077) BJ29(-20.497,36.158) BJ30(-21.353,36.329) BK14(-8.813,36.727) BK15(-9.601,36.727) BK16(-10.388,36.727) BK17(-11.175,36.727) BK18(-11.963,36.727) BK19(-12.75,36.727) BK20(-13.538,36.727) BK21(-14.325,36.727) BK22(-15.112,36.727) BK23(-15.9,36.727) BK24(-16.687,36.727) BK25(-17.475,36.727) BK26(-18.262,36.727) BK27(-19.049,36.727) BK28(-19.837,36.727) BK29(-20.833,36.735) BN1(0,38.614) BN38(-26.628,38.599) BP1(0,39.338) BP38(-26.628,39.31) BR2(-0.719,39.934) BR37(-25.904,39.927) BT3(-1.295,40.628) BT4(-2.019,40.628) BT35(-24.498,40.628) BT36(-25.311,40.628) C2(-0.699,1.361) C38(-26.628,1.334) D1(0,1.991) D38(-26.628,2.097) H13(-8.255,4.602) H14(-9.042,4.602) H15(-9.83,4.602) H16(-10.617,4.602) H17(-11.405,4.602) H18(-12.192,4.602) H19(-12.979,4.602) H20(-13.767,4.602) H21(-14.554,4.602) H22(-15.342,4.602) H23(-16.129,4.602) H24(-16.916,4.602) H25(-17.704,4.602) H26(-18.491,4.602) H27(-19.279,4.602) H28(-20.066,4.602) H29(-20.853,4.552) J14(-9.042,5.253) J15(-9.83,5.253) J16(-10.617,5.253) J17(-11.405,5.253) J18(-12.192,5.253) J19(-12.979,5.253) J20(-13.767,5.253) J21(-14.554,5.253) J22(-15.342,5.253) J23(-16.129,5.253) J24(-16.916,5.253) J25(-17.704,5.253) J26(-18.491,5.253) J27(-19.279,5.253) J28(-20.066,5.253) J30(-21.061,5.168) K13(-7.879,5.176) K14(-8.463,5.658) K29(-20.725,5.754) K30(-21.376,5.754) L13(-7.813,6.319) L14(-8.463,6.319) L29(-20.725,6.541) L30(-21.376,6.541) M13(-7.813,7.233) M14(-8.463,7.233) M29(-20.725,7.329) M30(-21.376,7.329) N13(-7.813,8.147) N14(-8.463,8.147) N29(-20.725,8.116) N30(-21.376,8.116) P13(-7.813,9.062) P14(-8.463,9.062) P29(-20.725,8.903) P30(-21.376,8.903) R13(-7.813,9.976) R14(-8.463,9.976) R29(-20.725,9.691) R30(-21.376,9.691) T13(-7.813,10.891) T14(-8.463,10.891) T29(-20.725,10.478) T30(-21.376,10.478) U29(-20.725,11.266) U30(-21.376,11.266) V13(-7.813,11.805) V14(-8.463,11.805) V29(-20.725,12.053) V30(-21.376,12.053) W13(-7.813,12.719) W14(-8.463,12.719) W29(-20.725,12.84) W30(-21.376,12.84) Y13(-7.813,13.634) Y14(-8.463,13.634) Y29(-20.725,13.628) Y30(-21.376,13.628)
  round 0.356 smd: A5(-2.771,0) A33(-23.66,0) B4(-2.031,0.971) B36(-25.198,0.701) BM1(0,37.814) BM38(-26.628,37.888) BP2(-0.828,39.28) BP37(-25.689,39.257) BR3(-1.387,39.978) BR36(-25.193,39.971) BT5(-2.819,40.628) BT34(-23.698,40.628) C37(-25.908,1.402) D3(-1.233,1.822) E1(0,2.779) E38(-26.628,2.897)
  round 0.33 smd: A6(-3.546,0) A32(-22.872,0) AA11(-6.512,14.548) AA12(-7.162,14.548) AC11(-6.512,15.463) AC12(-7.162,15.463) AD11(-6.512,16.377) AD12(-7.162,16.377) AE11(-6.512,17.291) AE12(-7.162,17.291) AF11(-6.512,18.206) AF12(-7.162,18.206) AG11(-6.512,19.12) AG12(-7.162,19.12) AH11(-6.512,20.035) AH12(-7.162,20.035) AJ11(-6.512,20.949) AJ12(-7.162,20.949) AL11(-6.512,21.863) AL12(-7.162,21.863) AM11(-6.512,22.778) AM12(-7.162,22.778) AN11(-6.512,23.692) AN12(-7.162,23.692) AP11(-6.512,24.607) AP12(-7.162,24.607) AR11(-6.512,25.521) AR12(-7.162,25.521) AT11(-6.512,26.435) AT12(-7.162,26.435) AU11(-6.512,27.35) AU12(-7.162,27.35) AW11(-6.512,28.264) AW12(-7.162,28.264) AY11(-6.512,29.179) AY12(-7.162,29.179) B5(-2.743,0.65) B34(-24.443,0.67) BA11(-6.512,30.093) BA12(-7.162,30.093) BB11(-6.512,31.007) BB12(-7.162,31.007) BC11(-6.512,31.922) BC12(-7.162,31.922) BD11(-6.512,32.836) BD12(-7.162,32.836) BF11(-6.512,33.751) BF12(-7.162,33.751) BG11(-6.512,34.665) BG12(-7.162,34.665) BH11(-6.512,35.579) BH12(-7.162,35.579) BJ11(-6.512,36.494) BJ12(-7.282,36.405) BK1(0,37.037) BK13(-7.899,36.727) BL38(-26.628,37.176) BN2(-0.65,38.642) BN37(-25.965,38.665) BR5(-2.166,39.984) BR35(-24.536,39.978) BT6(-3.594,40.628) BT32(-22.923,40.628) D37(-25.603,1.985) E2(-0.65,2.474) G1(0,3.581) G38(-26.628,3.671) K11(-6.512,5.48) K12(-7.162,5.48) L11(-6.512,6.319) L12(-7.162,6.319) M11(-6.512,7.233) M12(-7.162,7.233) N11(-6.512,8.147) N12(-7.162,8.147) P11(-6.512,9.062) P12(-7.162,9.062) R11(-6.512,9.976) R12(-7.162,9.976) T11(-6.512,10.891) T12(-7.162,10.891) V11(-6.512,11.805) V12(-7.162,11.805) W11(-6.512,12.719) W12(-7.162,12.719) Y11(-6.512,13.634) Y12(-7.162,13.634)
  round 0.305 smd: A8(-4.318,0) A9(-5.105,0) A10(-5.893,0) A11(-6.68,0) A12(-7.468,0) A13(-8.255,0) A14(-9.042,0) A15(-9.83,0) A16(-10.617,0) A17(-11.405,0) A18(-12.192,0) A19(-12.979,0) A20(-13.767,0) A21(-14.554,0) A22(-15.342,0) A23(-16.129,0) A24(-16.916,0) A25(-17.704,0) A26(-18.491,0) A27(-19.279,0) A28(-20.066,0) A29(-20.853,0) A30(-21.844,0) AA1(0,14.019) AA2(-0.65,14.019) AA3(-1.3,14.019) AA4(-1.951,14.019) AA5(-2.601,14.019) AA6(-3.251,13.968) AA7(-3.911,14.548) AA8(-4.561,14.548) AA9(-5.212,14.548) AA10(-5.862,14.548) AA31(-22.077,14.415) AA32(-22.727,14.415) AA33(-23.377,14.415) AA34(-24.027,14.415) AA35(-24.678,14.415) AA36(-25.328,14.415) AA37(-25.978,14.415) AA38(-26.628,14.415) AB1(0,14.756) AB2(-0.65,14.756) AB3(-1.3,14.756) AB4(-1.951,14.756) AB5(-2.601,14.756) AB6(-3.251,14.806) AB31(-22.077,15.203) AB32(-22.727,15.203) AB33(-23.377,15.203) AB34(-24.027,15.203) AB35(-24.678,15.203) AB36(-25.328,15.203) AB37(-25.978,15.203) AB38(-26.628,15.203) AC1(0,15.645) AC2(-0.65,15.645) AC3(-1.3,15.645) AC4(-1.951,15.645) AC5(-2.601,15.645) AC6(-3.251,15.645) AC7(-3.911,15.463) AC8(-4.561,15.463) AC9(-5.212,15.463) AC10(-5.862,15.463) AC31(-22.077,15.99) AC32(-22.727,15.99) AC33(-23.377,15.99) AC34(-24.027,15.99) AC35(-24.678,15.99) AC36(-25.328,15.99) AC37(-25.978,15.99) AC38(-26.628,15.99) AD1(0,16.534) AD2(-0.65,16.534) AD3(-1.3,16.534) AD4(-1.951,16.534) AD5(-2.601,16.534) AD6(-3.251,16.483) AD7(-3.911,16.377) AD8(-4.561,16.377) AD9(-5.212,16.377) AD10(-5.862,16.377) AD31(-22.077,16.777) AD32(-22.727,16.777) AD33(-23.377,16.777) AD34(-24.027,16.777) AD35(-24.678,16.777) AD36(-25.328,16.777) AD37(-25.978,16.777) AD38(-26.628,16.777) AE1(0,17.27) AE2(-0.65,17.27) AE3(-1.3,17.27) AE4(-1.951,17.27) AE5(-2.601,17.27) AE6(-3.251,17.321) AE7(-3.911,17.291) AE8(-4.561,17.291) AE9(-5.212,17.291) AE10(-5.862,17.291) AE31(-22.077,17.565) AE32(-22.727,17.565) AE33(-23.377,17.565) AE34(-24.027,17.565) AE35(-24.678,17.565) AE36(-25.328,17.565) AE37(-25.978,17.565) AE38(-26.628,17.565) AF1(0,18.159) AF2(-0.65,18.159) AF3(-1.3,18.159) AF4(-1.951,18.159) AF5(-2.601,18.159) AF6(-3.251,18.159) AF7(-3.911,18.206) AF8(-4.561,18.206) AF9(-5.212,18.206) AF10(-5.862,18.206) AF31(-22.077,18.352) AF32(-22.727,18.352) AF33(-23.377,18.352) AF34(-24.027,18.352) AF35(-24.678,18.352) AF36(-25.328,18.352) AF37(-25.978,18.352) AF38(-26.628,18.352) AG1(0,19.048) AG2(-0.65,19.048) AG3(-1.3,19.048) AG4(-1.951,19.048) AG5(-2.601,19.048) AG6(-3.251,18.997) AG7(-3.911,19.12) AG8(-4.561,19.12) AG9(-5.212,19.12) AG10(-5.862,19.12) AG31(-22.077,19.14) AG32(-22.727,19.14) AG33(-23.377,19.14) AG34(-24.027,19.14) AG35(-24.678,19.14) AG36(-25.328,19.14) AG37(-25.978,19.14) AG38(-26.628,19.14) AH1(0,19.785) AH2(-0.65,19.785) AH3(-1.3,19.785) AH4(-1.951,19.785) AH5(-2.601,19.785) AH6(-3.251,19.836) AH7(-3.911,20.035) AH8(-4.561,20.035) AH9(-5.212,20.035) AH10(-5.862,20.035) AH31(-22.077,19.927) AH32(-22.727,19.927) AH33(-23.377,19.927) AH34(-24.027,19.927) AH35(-24.678,19.927) AH36(-25.328,19.927) AH37(-25.978,19.927) AH38(-26.628,19.927) AJ1(0,20.674) AJ2(-0.65,20.674) AJ3(-1.3,20.674) AJ4(-1.951,20.674) AJ5(-2.601,20.674) AJ6(-3.251,20.674) AJ7(-3.911,20.949) AJ8(-4.561,20.949) AJ9(-5.212,20.949) AJ10(-5.862,20.949) AJ31(-22.077,20.714) AJ32(-22.727,20.714) AJ33(-23.377,20.714) AJ34(-24.027,20.714) AJ35(-24.678,20.714) AJ36(-25.328,20.714) AJ37(-25.978,20.714) AJ38(-26.628,20.714) AK1(0,21.563) AK2(-0.65,21.563) AK3(-1.3,21.563) AK4(-1.951,21.563) AK5(-2.601,21.563) AK6(-3.251,21.512) AK31(-22.077,21.502) AK32(-22.727,21.502) AK33(-23.377,21.502) AK34(-24.027,21.502) AK35(-24.678,21.502) AK36(-25.328,21.502) AK37(-25.978,21.502) AK38(-26.628,21.502) AL1(0,22.299) AL2(-0.65,22.299) AL3(-1.3,22.299) AL4(-1.951,22.299) AL5(-2.601,22.299) AL6(-3.251,22.35) AL7(-3.911,21.863) AL8(-4.561,21.863) AL9(-5.212,21.863) AL10(-5.862,21.863) AL31(-22.077,22.289) AL32(-22.727,22.289) AL33(-23.377,22.289) AL34(-24.027,22.289) AL35(-24.678,22.289) AL36(-25.328,22.289) AL37(-25.978,22.289) AL38(-26.628,22.289) AM1(0,23.188) AM2(-0.65,23.188) AM3(-1.3,23.188) AM4(-1.951,23.188) AM5(-2.601,23.188) AM6(-3.251,23.188) AM7(-3.911,22.778) AM8(-4.561,22.778) AM9(-5.212,22.778) AM10(-5.862,22.778) AM31(-22.077,23.077) AM32(-22.727,23.077) AM33(-23.377,23.077) AM34(-24.027,23.077) AM35(-24.678,23.077) AM36(-25.328,23.077) AM37(-25.978,23.077) AM38(-26.628,23.077) AN1(0,24.077) AN2(-0.65,24.077) AN3(-1.3,24.077) AN4(-1.951,24.077) AN5(-2.601,24.077) AN6(-3.251,24.027) AN7(-3.911,23.692) AN8(-4.561,23.692) AN9(-5.212,23.692) AN10(-5.862,23.692) AN31(-22.077,23.864) AN32(-22.727,23.864) AN33(-23.377,23.864) AN34(-24.027,23.864) AN35(-24.678,23.864) AN36(-25.328,23.864) AN37(-25.978,23.864) AN38(-26.628,23.864) AP1(0,24.814) AP2(-0.65,24.814) AP3(-1.3,24.814) AP4(-1.951,24.814) AP5(-2.601,24.814) AP6(-3.251,24.865) AP7(-3.911,24.607) AP8(-4.561,24.607) AP9(-5.212,24.607) AP10(-5.862,24.607) AP31(-22.077,24.651) AP32(-22.727,24.651) AP33(-23.377,24.651) AP34(-24.027,24.651) AP35(-24.678,24.651) AP36(-25.328,24.651) AP37(-25.978,24.651) AP38(-26.628,24.651) AR1(0,25.703) AR2(-0.65,25.703) AR3(-1.3,25.703) AR4(-1.951,25.703) AR5(-2.601,25.703) AR6(-3.251,25.703) AR7(-3.911,25.521) AR8(-4.561,25.521) AR9(-5.212,25.521) AR10(-5.862,25.521) AR31(-22.077,25.439) AR32(-22.727,25.439) AR33(-23.377,25.439) AR34(-24.027,25.439) AR35(-24.678,25.439) AR36(-25.328,25.439) AR37(-25.978,25.439) AR38(-26.628,25.439) AT1(0,26.592) AT2(-0.65,26.592) AT3(-1.3,26.592) AT4(-1.951,26.592) AT5(-2.601,26.592) AT6(-3.251,26.541) AT7(-3.911,26.435) AT8(-4.561,26.435) AT9(-5.212,26.435) AT10(-5.862,26.435) AT31(-22.077,26.226) AT32(-22.727,26.226) AT33(-23.377,26.226) AT34(-24.027,26.226) AT35(-24.678,26.226) AT36(-25.328,26.226) AT37(-25.978,26.226) AT38(-26.628,26.226) AU1(0,27.329) AU2(-0.65,27.329) AU3(-1.3,27.329) AU4(-1.951,27.329) AU5(-2.601,27.329) AU6(-3.251,27.379) AU7(-3.911,27.35) AU8(-4.561,27.35) AU9(-5.212,27.35) AU10(-5.862,27.35) AU31(-22.077,27.014) AU32(-22.727,27.014) AU33(-23.377,27.014) AU34(-24.027,27.014) AU35(-24.678,27.014) AU36(-25.328,27.014) AU37(-25.978,27.014) AU38(-26.628,27.014) AV31(-22.077,27.801) AV32(-22.727,27.801) AV33(-23.377,27.801) AV34(-24.027,27.801) AV35(-24.678,27.801) AV36(-25.328,27.801) AV37(-25.978,27.801) AV38(-26.628,27.801) AW1(0,28.218) AW2(-0.65,28.218) AW3(-1.3,28.218) AW4(-1.951,28.218) AW5(-2.601,28.218) AW6(-3.251,28.218) AW7(-3.911,28.264) AW8(-4.561,28.264) AW9(-5.212,28.264) AW10(-5.862,28.264) AW31(-22.077,28.588) AW32(-22.727,28.588) AW33(-23.377,28.588) AW34(-24.027,28.588) AW35(-24.678,28.588) AW36(-25.328,28.588) AW37(-25.978,28.588) AW38(-26.628,28.588) AY1(0,29.107) AY2(-0.65,29.107) AY3(-1.3,29.107) AY4(-1.951,29.107) AY5(-2.601,29.107) AY6(-3.251,29.056) AY7(-3.911,29.179) AY8(-4.561,29.179) AY9(-5.212,29.179) AY10(-5.862,29.179) AY31(-22.077,29.376) AY32(-22.727,29.376) AY33(-23.377,29.376) AY34(-24.027,29.376) AY35(-24.678,29.376) AY36(-25.328,29.376) AY37(-25.978,29.376) AY38(-26.628,29.376) B6(-3.531,0.65) B8(-4.318,0.65) B9(-5.105,0.65) B10(-5.893,0.65) B11(-6.68,0.65) B12(-7.468,0.65) B13(-8.255,0.65) B14(-9.042,0.65) B15(-9.83,0.65) B16(-10.617,0.65) B17(-11.405,0.65) B18(-12.192,0.65) B19(-12.979,0.65) B20(-13.767,0.65) B21(-14.554,0.65) B22(-15.342,0.65) B23(-16.129,0.65) B24(-16.916,0.65) B25(-17.704,0.65) B26(-18.491,0.65) B27(-19.279,0.65) B28(-20.066,0.65) B29(-20.853,0.65) B30(-21.641,0.65) B31(-22.428,0.65) B33(-23.216,0.65) BA1(0,29.843) BA2(-0.65,29.843) BA3(-1.3,29.843) BA4(-1.951,29.843) BA5(-2.601,29.843) BA6(-3.251,29.894) BA7(-3.911,30.093) BA8(-4.561,30.093) BA9(-5.212,30.093) BA10(-5.862,30.093) BA31(-22.077,30.163) BA32(-22.727,30.163) BA33(-23.377,30.163) BA34(-24.027,30.163) BA35(-24.678,30.163) BA36(-25.328,30.163) BA37(-25.978,30.163) BA38(-26.628,30.163) BB1(0,30.732) BB2(-0.65,30.732) BB3(-1.3,30.732) BB4(-1.951,30.732) BB5(-2.601,30.732) BB6(-3.251,30.732) BB7(-3.911,31.007) BB8(-4.561,31.007) BB9(-5.212,31.007) BB10(-5.862,31.007) BB31(-22.077,30.951) BB32(-22.727,30.951) BB33(-23.377,30.951) BB34(-24.027,30.951) BB35(-24.678,30.951) BB36(-25.328,30.951) BB37(-25.978,30.951) BB38(-26.628,30.951) BC1(0,31.621) BC2(-0.65,31.621) BC3(-1.3,31.621) BC4(-1.951,31.621) BC5(-2.601,31.621) BC6(-3.251,31.57) BC7(-3.911,31.922) BC8(-4.561,31.922) BC9(-5.212,31.922) BC10(-5.862,31.922) BC31(-22.077,31.738) BC32(-22.727,31.738) BC33(-23.377,31.738) BC34(-24.027,31.738) BC35(-24.678,31.738) BC36(-25.328,31.738) BC37(-25.978,31.738) BC38(-26.628,31.738) BD1(0,32.358) BD2(-0.65,32.358) BD3(-1.3,32.358) BD4(-1.951,32.358) BD5(-2.601,32.358) BD6(-3.251,32.409) BD7(-3.911,32.836) BD8(-4.561,32.836) BD9(-5.212,32.836) BD10(-5.862,32.836) BD31(-22.077,32.525) BD32(-22.727,32.525) BD33(-23.377,32.525) BD34(-24.027,32.525) BD35(-24.678,32.525) BD36(-25.328,32.525) BD37(-25.978,32.525) BD38(-26.628,32.525) BE1(0,33.247) BE2(-0.65,33.247) BE3(-1.3,33.247) BE4(-1.951,33.247) BE5(-2.601,33.247) BE6(-3.251,33.247) BE31(-22.077,33.313) BE32(-22.727,33.313) BE33(-23.377,33.313) BE34(-24.027,33.313) BE35(-24.678,33.313) BE36(-25.328,33.313) BE37(-25.978,33.313) BE38(-26.628,33.313) BF1(0,34.136) BF2(-0.65,34.136) BF3(-1.3,34.136) BF4(-1.951,34.136) BF5(-2.601,34.136) BF6(-3.251,34.085) BF7(-3.911,33.751) BF8(-4.561,33.751) BF9(-5.212,33.751) BF10(-5.862,33.751) BF31(-22.077,34.1) BF32(-22.727,34.1) BF33(-23.377,34.1) BF34(-24.027,34.1) BF35(-24.678,34.1) BF36(-25.328,34.1) BF37(-25.978,34.1) BF38(-26.628,34.1) BG1(0,34.872) BG2(-0.65,34.872) BG3(-1.3,34.872) BG4(-1.951,34.872) BG5(-2.601,34.872) BG6(-3.251,34.923) BG7(-3.911,34.665) BG8(-4.561,34.665) BG9(-5.212,34.665) BG10(-5.862,34.665) BG31(-22.077,34.888) BG32(-22.727,34.888) BG33(-23.377,34.888) BG34(-24.027,34.888) BG35(-24.678,34.888) BG36(-25.328,34.888) BG37(-25.978,34.888) BG38(-26.628,34.888) BH1(0,36.015) BH2(-0.65,35.761) BH3(-1.3,35.761) BH4(-1.951,35.761) BH5(-2.601,35.761) BH6(-3.251,35.761) BH7(-3.911,35.579) BH8(-4.561,35.579) BH9(-5.212,35.579) BH10(-5.862,35.579) BH31(-22.077,35.675) BH32(-22.727,35.675) BH33(-23.377,35.675) BH34(-24.027,35.675) BH35(-24.678,35.675) BH36(-25.328,35.675) BH37(-25.978,35.675) BH38(-26.628,35.675) BJ7(-3.911,36.494) BJ8(-4.561,36.494) BJ9(-5.212,36.494) BJ10(-5.862,36.494) BJ31(-22.077,36.462) BJ32(-22.727,36.462) BJ33(-23.377,36.462) BJ34(-24.027,36.462) BJ35(-24.678,36.462) BJ36(-25.328,36.462) BJ37(-25.978,36.462) BJ38(-26.628,36.412) BK2(-0.65,36.6) BK3(-1.3,36.6) BK4(-1.951,36.6) BK5(-2.601,36.6) BK6(-3.251,36.6) BL2(-0.65,37.438) BL3(-1.3,37.387) BL4(-1.951,37.387) BL5(-2.601,37.387) BL6(-3.251,37.438) BL7(-3.987,37.383) BL8(-4.876,37.377) BL9(-5.664,37.377) BL11(-6.451,37.377) BL12(-7.238,37.377) BL13(-8.026,37.377) BL14(-8.813,37.377) BL15(-9.601,37.377) BL16(-10.388,37.377) BL17(-11.175,37.377) BL18(-11.963,37.377) BL19(-12.75,37.377) BL20(-13.538,37.377) BL21(-14.325,37.377) BL22(-15.112,37.377) BL23(-15.9,37.377) BL24(-16.687,37.377) BL25(-17.475,37.377) BL26(-18.262,37.377) BL27(-19.049,37.377) BL28(-19.837,37.377) BL29(-20.624,37.377) BL30(-21.426,37.25) BL31(-22.077,37.25) BL32(-22.727,37.25) BL33(-23.377,37.25) BL34(-24.027,37.25) BL35(-24.678,37.25) BL36(-25.328,37.25) BL37(-25.978,37.25) BM2(-0.963,38.053) BM3(-1.613,38.129) BM5(-2.525,38.129) BM6(-3.169,38.231) BM7(-4.089,38.027) BM8(-4.876,38.027) BM9(-5.664,38.027) BM11(-6.451,38.027) BM12(-7.238,38.027) BM13(-8.026,38.027) BM14(-8.813,38.027) BM15(-9.601,38.027) BM16(-10.388,38.027) BM17(-11.175,38.027) BM18(-11.963,38.027) BM19(-12.75,38.027) BM20(-13.538,38.027) BM21(-14.325,38.027) BM22(-15.112,38.027) BM23(-15.9,38.027) BM24(-16.687,38.027) BM25(-17.475,38.027) BM26(-18.262,38.027) BM27(-19.049,38.027) BM28(-19.837,38.027) BM29(-20.624,38.027) BM30(-21.412,38.027) BM31(-22.199,38.027) BM33(-22.986,38.027) BM34(-23.774,38.027) BM35(-24.561,38.027) BM36(-25.328,37.986) BM37(-25.978,37.986) BN3(-1.3,38.701) BN4(-2.106,38.629) BN5(-2.748,38.793) BN7(-4.089,38.678) BN8(-4.876,38.678) BN9(-5.664,38.678) BN11(-6.451,38.678) BN12(-7.238,38.678) BN13(-8.026,38.678) BN14(-8.813,38.678) BN15(-9.601,38.678) BN16(-10.388,38.678) BN17(-11.175,38.678) BN18(-11.963,38.678) BN19(-12.75,38.678) BN20(-13.538,38.678) BN21(-14.325,38.678) BN22(-15.112,38.678) BN23(-15.9,38.678) BN24(-16.687,38.678) BN25(-17.475,38.678) BN26(-18.262,38.678) BN27(-19.049,38.678) BN28(-19.837,38.678) BN29(-20.624,38.678) BN30(-21.412,38.678) BN31(-22.199,38.678) BN33(-22.986,38.678) BN34(-23.774,38.678) BN35(-24.562,38.678) BN36(-25.314,38.638) BP3(-1.483,39.334) BP5(-2.374,39.351) BP6(-3.294,39.288) BP7(-4.089,39.328) BP8(-4.876,39.328) BP9(-5.664,39.328) BP11(-6.451,39.328) BP12(-7.238,39.328) BP13(-8.026,39.328) BP14(-8.813,39.328) BP15(-9.601,39.328) BP16(-10.388,39.328) BP17(-11.175,39.328) BP18(-11.963,39.328) BP19(-12.75,39.328) BP20(-13.538,39.328) BP21(-14.325,39.328) BP22(-15.112,39.328) BP23(-15.9,39.328) BP24(-16.687,39.328) BP25(-17.475,39.328) BP26(-18.262,39.328) BP27(-19.049,39.328) BP28(-19.837,39.328) BP29(-20.624,39.328) BP30(-21.412,39.328) BP31(-22.199,39.328) BP33(-22.986,39.328) BP34(-23.774,39.328) BP35(-24.561,39.328) BR6(-3.192,39.961) BR7(-4.089,39.978) BR8(-4.876,39.978) BR9(-5.664,39.978) BR11(-6.451,39.978) BR12(-7.238,39.978) BR13(-8.026,39.978) BR14(-8.813,39.978) BR15(-9.601,39.978) BR16(-10.388,39.978) BR17(-11.175,39.978) BR18(-11.963,39.978) BR19(-12.75,39.978) BR20(-13.538,39.978) BR21(-14.325,39.978) BR22(-15.112,39.978) BR23(-15.9,39.978) BR24(-16.687,39.978) BR25(-17.475,39.978) BR26(-18.262,39.978) BR27(-19.049,39.978) BR28(-19.837,39.978) BR29(-20.624,39.978) BR30(-21.412,39.978) BR31(-22.199,39.978) BR33(-22.986,39.978) BR34(-23.774,39.978) BT8(-4.648,40.628) BT9(-5.664,40.628) BT11(-6.451,40.628) BT12(-7.238,40.628) BT13(-8.026,40.628) BT14(-8.813,40.628) BT15(-9.601,40.628) BT16(-10.388,40.628) BT17(-11.175,40.628) BT18(-11.963,40.628) BT19(-12.75,40.628) BT20(-13.538,40.628) BT21(-14.325,40.628) BT22(-15.112,40.628) BT23(-15.9,40.628) BT24(-16.687,40.628) BT25(-17.475,40.628) BT26(-18.262,40.628) BT27(-19.049,40.628) BT28(-19.837,40.628) BT29(-20.624,40.628) BT30(-21.412,40.628) BT31(-22.174,40.628) C5(-2.743,1.3) C6(-3.531,1.3) C8(-4.318,1.3) C9(-5.105,1.3) C10(-5.893,1.3) C11(-6.68,1.3) C12(-7.468,1.3) C13(-8.255,1.3) C14(-9.042,1.3) C15(-9.83,1.3) C16(-10.617,1.3) C17(-11.405,1.3) C18(-12.192,1.3) C19(-12.979,1.3) C20(-13.767,1.3) C21(-14.554,1.3) C22(-15.342,1.3) C23(-16.129,1.3) C24(-16.916,1.3) C25(-17.704,1.3) C26(-18.491,1.3) C27(-19.279,1.3) C28(-20.066,1.3) C29(-20.853,1.3) C30(-21.641,1.3) C31(-22.428,1.3) C33(-23.216,1.3) C34(-24.011,1.29) C36(-25.145,1.388) D4(-1.894,1.655) D5(-2.743,1.951) D6(-3.531,1.951) D8(-4.318,1.951) D9(-5.105,1.951) D10(-5.893,1.951) D11(-6.68,1.951) D12(-7.468,1.951) D13(-8.255,1.951) D14(-9.042,1.951) D15(-9.83,1.951) D16(-10.617,1.951) D17(-11.405,1.951) D18(-12.192,1.951) D19(-12.979,1.951) D20(-13.767,1.951) D21(-14.554,1.951) D22(-15.342,1.951) D23(-16.129,1.951) D24(-16.916,1.951) D25(-17.704,1.951) D26(-18.491,1.951) D27(-19.279,1.951) D28(-20.066,1.951) D29(-20.853,1.951) D30(-21.641,1.951) D31(-22.428,1.951) D33(-23.216,1.951) D34(-24.003,1.951) D35(-24.655,1.861) E3(-1.3,2.474) E4(-1.951,2.575) E5(-2.743,2.601) E6(-3.531,2.601) E8(-4.318,2.601) E9(-5.105,2.601) E10(-5.893,2.601) E11(-6.68,2.601) E12(-7.468,2.601) E13(-8.255,2.601) E14(-9.042,2.601) E15(-9.83,2.601) E16(-10.617,2.601) E17(-11.405,2.601) E18(-12.192,2.601) E19(-12.979,2.601) E20(-13.767,2.601) E21(-14.554,2.601) E22(-15.342,2.601) E23(-16.129,2.601) E24(-16.916,2.601) E25(-17.704,2.601) E26(-18.491,2.601) E27(-19.279,2.601) E28(-20.066,2.601) E29(-20.853,2.601) E30(-21.641,2.601) E31(-22.428,2.601) E33(-23.216,2.601) E34(-24.003,2.601) E35(-24.678,2.604) E36(-25.328,2.604) E37(-25.978,2.604) F2(-0.65,3.16) F3(-1.3,3.16) F4(-1.951,3.261) F5(-2.743,3.273) F6(-3.531,3.273) F8(-4.318,3.251) F9(-5.105,3.251) F10(-5.893,3.251) F11(-6.68,3.251) F12(-7.468,3.251) F13(-8.255,3.251) F14(-9.042,3.251) F15(-9.83,3.251) F16(-10.617,3.251) F17(-11.405,3.251) F18(-12.192,3.251) F19(-12.979,3.251) F20(-13.767,3.251) F21(-14.554,3.251) F22(-15.342,3.251) F23(-16.129,3.251) F24(-16.916,3.251) F25(-17.704,3.251) F26(-18.491,3.251) F27(-19.279,3.251) F28(-20.066,3.251) F29(-20.853,3.251) F30(-21.641,3.251) F31(-22.428,3.251) F33(-23.216,3.251) F34(-24.027,3.392) F35(-24.678,3.392) F36(-25.328,3.392) F37(-25.978,3.392) G2(-0.65,3.947) G3(-1.3,3.947) G4(-1.951,3.947) G5(-2.601,3.947) G6(-3.251,3.947) G8(-4.318,3.901) G9(-5.105,3.901) G10(-5.893,3.901) G11(-6.68,3.901) G12(-7.468,3.901) G13(-8.255,3.901) G14(-9.042,3.901) G15(-9.83,3.901) G16(-10.617,3.901) G17(-11.405,3.901) G18(-12.192,3.901) G19(-12.979,3.901) G20(-13.767,3.901) G21(-14.554,3.901) G22(-15.342,3.901) G23(-16.129,3.901) G24(-16.916,3.901) G25(-17.704,3.901) G26(-18.491,3.901) G27(-19.279,3.901) G28(-20.066,3.901) G29(-20.853,3.901) G30(-21.641,3.901) H1(0,4.443) H11(-6.68,4.552) H12(-7.468,4.552) H30(-21.603,4.552) H32(-22.727,4.179) H33(-23.377,4.179) H34(-24.027,4.179) H35(-24.678,4.179) H36(-25.328,4.179) H37(-25.978,4.179) J2(-0.65,4.748) J3(-1.3,4.748) J4(-1.951,4.748) J5(-2.601,4.748) J6(-3.251,4.748) J7(-3.893,4.619) J8(-4.541,4.716) J9(-5.212,4.693) J10(-5.893,4.628) J31(-22.077,5.005) J32(-22.727,4.966) J33(-23.377,4.966) J34(-24.027,4.966) J35(-24.678,4.966) J36(-25.328,4.966) J37(-25.978,4.966) J38(-26.628,4.712) K1(0,5.586) K2(-0.65,5.586) K3(-1.3,5.586) K4(-1.951,5.586) K5(-2.601,5.586) K6(-3.251,5.586) K7(-3.911,5.557) K8(-4.561,5.48) K9(-5.212,5.48) K10(-5.862,5.48) K31(-22.077,5.754) K32(-22.727,5.754) K33(-23.377,5.754) K34(-24.027,5.754) K35(-24.678,5.754) K36(-25.328,5.754) K37(-25.978,5.754) K38(-26.628,5.754) L1(0,6.475) L2(-0.65,6.475) L3(-1.3,6.475) L4(-1.951,6.475) L5(-2.601,6.475) L6(-3.251,6.424) L7(-3.911,6.395) L8(-4.561,6.344) L9(-5.212,6.319) L10(-5.862,6.319) L31(-22.077,6.541) L32(-22.727,6.541) L33(-23.377,6.541) L34(-24.027,6.541) L35(-24.678,6.541) L36(-25.328,6.541) L37(-25.978,6.541) L38(-26.628,6.541) M1(0,7.212) M2(-0.65,7.212) M3(-1.3,7.212) M4(-1.951,7.212) M5(-2.601,7.212) M6(-3.251,7.263) M7(-3.911,7.233) M8(-4.561,7.233) M9(-5.212,7.233) M10(-5.862,7.233) M31(-22.077,7.329) M32(-22.727,7.329) M33(-23.377,7.329) M34(-24.027,7.329) M35(-24.678,7.329) M36(-25.328,7.329) M37(-25.978,7.329) M38(-26.628,7.329) N1(0,8.101) N2(-0.65,8.101) N3(-1.3,8.101) N4(-1.951,8.101) N5(-2.601,8.101) N6(-3.251,8.101) N7(-3.911,8.147) N8(-4.561,8.147) N9(-5.212,8.147) N10(-5.862,8.147) N31(-22.077,8.116) N32(-22.727,8.116) N33(-23.377,8.116) N34(-24.027,8.116) N35(-24.678,8.116) N36(-25.328,8.116) N37(-25.978,8.116) N38(-26.628,8.116) P1(0,8.99) P2(-0.65,8.99) P3(-1.3,8.99) P4(-1.951,8.99) P5(-2.601,8.99) P6(-3.251,8.939) P7(-3.911,9.062) P8(-4.561,9.062) P9(-5.212,9.062) P10(-5.862,9.062) P31(-22.077,8.903) P32(-22.727,8.903) P33(-23.377,8.903) P34(-24.027,8.903) P35(-24.678,8.903) P36(-25.328,8.903) P37(-25.978,8.903) P38(-26.628,8.903) R1(0,9.726) R2(-0.65,9.726) R3(-1.3,9.726) R4(-1.951,9.726) R5(-2.601,9.726) R6(-3.251,9.777) R7(-3.911,9.976) R8(-4.561,9.976) R9(-5.212,9.976) R10(-5.862,9.976) R31(-22.077,9.691) R32(-22.727,9.691) R33(-23.377,9.691) R34(-24.027,9.691) R35(-24.678,9.691) R36(-25.328,9.691) R37(-25.978,9.691) R38(-26.628,9.691) T1(0,10.615) T2(-0.65,10.615) T3(-1.3,10.615) T4(-1.951,10.615) T5(-2.601,10.615) T6(-3.251,10.615) T7(-3.911,10.891) T8(-4.561,10.891) T9(-5.212,10.891) T10(-5.862,10.891) T31(-22.077,10.478) T32(-22.727,10.478) T33(-23.377,10.478) T34(-24.027,10.478) T35(-24.678,10.478) T36(-25.328,10.478) T37(-25.978,10.478) T38(-26.628,10.478) U1(0,11.504) U2(-0.65,11.504) U3(-1.3,11.504) U4(-1.951,11.504) U5(-2.601,11.504) U6(-3.251,11.454) U31(-22.077,11.266) U32(-22.727,11.266) U33(-23.377,11.266) U34(-24.027,11.266) U35(-24.678,11.266) U36(-25.328,11.266) U37(-25.978,11.266) U38(-26.628,11.266) V1(0,12.241) V2(-0.65,12.241) V3(-1.3,12.241) V4(-1.951,12.241) V5(-2.601,12.241) V6(-3.251,12.292) V7(-3.911,11.805) V8(-4.561,11.805) V9(-5.212,11.805) V10(-5.862,11.805) V31(-22.077,12.053) V32(-22.727,12.053) V33(-23.377,12.053) V34(-24.027,12.053) V35(-24.678,12.053) V36(-25.328,12.053) V37(-25.978,12.053) V38(-26.628,12.053) W1(0,13.13) W2(-0.65,13.13) W3(-1.3,13.13) W4(-1.951,13.13) W5(-2.601,13.13) W6(-3.251,13.13) W7(-3.911,12.719) W8(-4.561,12.719) W9(-5.212,12.719) W10(-5.862,12.719) W31(-22.077,12.84) W32(-22.727,12.84) W33(-23.377,12.84) W34(-24.027,12.84) W35(-24.678,12.84) W36(-25.328,12.84) W37(-25.978,12.84) W38(-26.628,12.84) Y7(-3.911,13.634) Y8(-4.561,13.634) Y9(-5.212,13.634) Y10(-5.862,13.634) Y31(-22.077,13.628) Y32(-22.727,13.628) Y33(-23.377,13.628) Y34(-24.027,13.628) Y35(-24.678,13.628) Y36(-25.328,13.628) Y37(-25.978,13.628) Y38(-26.628,13.628)
