# Allegro board Dell XPS 9560 LA-E331P R10.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TBT_USB3_TX0_N: length 42.1
  TOP w0.097: JUSBC1.A3 8.4,67.56 arc(8.54,67.59) 8.66,67.66 arc(8.72,67.7) 8.78,67.72 8.96,67.72 arc(9.1,67.74) 9.22,67.82 9.36,67.96 arc(9.4,68) 9.43,68.03 9.44,68.04 9.55,68.14 arc(9.97,68.43) 10.48,68.53 10.64,68.53 arc(10.76,68.51) 10.86,68.44 DT13.1 arc(11.22,68.29) 11.33,68.43 arc(11.56,68.59) 11.84,68.65 13.44,68.65 arc(13.96,68.55) 14.41,68.26 arc(14.42,68.25) 14.43,68.24 15.24,67.63 arc(15.3,67.57) 15.36,67.51 16.54,66.34 arc(16.8,65.94) 16.9,65.47 16.9,64.4 arc(16.97,63.27) 17.18,62.17 arc(17.25,61.89) 17.3,61.6 arc(17.35,61.19) 17.36,60.78 17.36,57.68 arc(17.4,57.28) 17.52,56.89 arc(17.93,55.52) 18.07,54.11 18.07,44.19 18.07,44.19 18.07,40.35 arc(18.22,39.6) 18.64,38.96 19.04,38.57 arc(19.28,38.2) 19.37,37.77 19.37,37.21 arc(19.34,37.04) 19.24,36.89 19.11,36.76 arc(19.1,36.75) 19.09,36.75 arc(19.06,36.73) 19.03,36.73 18.94,36.73 arc(18.94,36.73) 18.93,36.73 arc(18.88,36.74) 18.84,36.77 18.75,36.86 arc(18.68,36.96) v2(18.66,37.08)
  BOTTOM w0.097: CT40.2 19.25,36.95 arc(19.13,36.87) 18.99,36.84 arc(18.91,36.86) 18.84,36.9 v2(18.66,37.08)
TBT_USB3_TX0_N_C: length 3.2
  BOTTOM w0.097: CT40.1 19.93,37.04 20.08,36.88 20.12,36.86 arc(20.15,36.85) 20.18,36.84 arc(20.19,36.84) 20.19,36.84 arc(20.22,36.85) 20.25,36.87 20.28,36.9 20.32,37.01 20.32,37.17 arc(20.35,37.31) 20.43,37.42 20.63,37.62 arc(20.77,37.71) 20.93,37.75 21.37,37.75 arc(21.43,37.74) 21.49,37.72 arc(21.5,37.71) 21.51,37.71 arc(21.6,37.68) 21.69,37.67 22.08,37.67 arc(22.2,37.65) 22.31,37.57 UT1.B19
TBT_USB3_TX0_P: length 42.1
  TOP w0.097: JUSBC1.A2 8.4,68.06 arc(8.54,68.03) 8.66,67.95 arc(8.72,67.92) 8.78,67.9 8.96,67.9 arc(9.03,67.92) 9.09,67.96 9.23,68.09 arc(9.27,68.13) 9.31,68.17 9.42,68.28 arc(9.9,68.6) 10.48,68.72 10.83,68.72 arc(11.02,68.75) DT12.1 arc(11.21,68.84) 11.25,68.83 13.44,68.83 arc(14.03,68.72) 14.54,68.39 arc(14.98,68.11) 15.37,67.76 arc(15.43,67.71) 15.5,67.64 16.67,66.47 arc(16.98,66.01) 17.08,65.47 17.08,64.4 arc(17.11,63.77) 17.17,63.15 arc(17.23,62.81) 17.3,62.47 arc(17.33,62.34) 17.36,62.22 arc(17.43,61.92) 17.48,61.63 arc(17.53,61.2) 17.55,60.78 17.55,57.68 arc(17.58,57.31) 17.69,56.96 arc(18.12,55.56) 18.26,54.11 18.26,44.11 18.26,44.11 18.26,40.35 arc(18.39,39.67) 18.78,39.1 19.17,38.7 arc(19.46,38.27) 19.56,37.77 19.56,37.21 arc(19.51,36.97) 19.37,36.76 19.24,36.63 arc(19.22,36.61) 19.2,36.6 19.2,36.59 arc(19.12,36.56) 19.03,36.54 18.92,36.54 arc(18.78,36.51) v2(18.66,36.43)
  BOTTOM w0.097: v2(18.66,36.43) 18.8,36.58 arc(18.89,36.63) 18.99,36.65 arc(19.18,36.59) CT39.2
TBT_USB3_TX0_P_C: length 3.2
  BOTTOM w0.097: UT1.A19 22,37.45 arc(22.11,37.33) 22,37.22 21.8,37.22 arc(21.68,37.26) 21.6,37.36 21.57,37.43 arc(21.54,37.48) 21.49,37.51 21.44,37.54 arc(21.42,37.54) 21.4,37.55 arc(21.39,37.56) 21.37,37.56 20.93,37.56 arc(20.84,37.54) 20.76,37.49 20.56,37.29 arc(20.52,37.23) 20.51,37.17 20.51,37.01 arc(20.48,36.88) 20.41,36.77 20.38,36.74 arc(20.3,36.69) 20.22,36.66 arc(20.2,36.66) 20.18,36.66 arc(20.16,36.66) 20.15,36.66 arc(20.13,36.65) 20.12,36.65 20.08,36.62 CT39.1
TBT_USB3_TX1_N: length 41.6
  TOP w0.097: v2(17.27,36.9) 16.98,36.61 arc(16.91,36.57) 16.84,36.55 16.55,36.55 arc(16.42,36.58) 16.32,36.65 16.12,36.85 arc(15.94,37.12) 15.88,37.44 15.88,41.42 arc(15.85,41.53) 15.79,41.63 15.75,41.66 15.75,41.67 15.71,41.71 arc(15.69,41.74) 15.68,41.77 15.68,43.9 arc(15.75,44.24) 15.94,44.52 16.19,44.78 arc(16.48,45.2) 16.57,45.69 16.57,51.51 arc(16.58,51.73) 16.58,51.94 arc(16.58,51.94) 16.58,51.95 arc(16.59,52.46) 16.57,52.98 arc(16.42,53.86) 16.11,54.7 arc(15.93,55.17) 15.88,55.67 15.88,58.23 arc(15.73,58.94) 15.33,59.55 15.33,59.55 arc(14.67,59.99) 13.89,60.14 10.73,60.14 arc(10.2,60.25) 9.76,60.55 9.74,60.56 arc(9.69,60.64) 9.67,60.73 arc(9.67,60.75) 9.67,60.78 9.67,60.79 arc(9.68,60.85) 9.72,60.91 9.92,61.1 arc(9.97,61.14) v2(10.03,61.15)
  BOTTOM w0.097: v2(17.27,36.9) 17.4,36.76 arc(17.49,36.71) 17.59,36.69 17.68,36.69 17.79,36.73 arc(17.83,36.78) 17.84,36.84 17.84,37.64 arc(17.91,37.99) 18.11,38.29 18.25,38.43 arc(18.47,38.58) 18.74,38.63 19.28,38.63 arc(19.46,38.68) CT38.2 ; v2(10.03,61.15) arc(9.87,61.22) 9.81,61.38 arc(9.84,61.55) 9.94,61.7 DT26.1 10.04,61.92 arc(9.94,62.07) 9.9,62.24 arc(9.87,62.42) 9.77,62.57 9.33,63 arc(9.11,63.15) 8.84,63.21 7.87,63.21 arc(7.69,63.24) 7.53,63.34 7,63.88 arc(6.85,63.98) 6.67,64.02 6.32,64.02 arc(6.06,64.07) JUSBC1.B3
TBT_USB3_TX1_N_C: length 2.4
  BOTTOM w0.097: UT1.B17 22.3,38.5 22.29,38.51 arc(22.2,38.57) 22.1,38.59 20.63,38.59 arc(20.42,38.63) 20.23,38.76 CT38.1
TBT_USB3_TX1_P: length 41.6
  TOP w0.097: v2(17.27,36.34) arc(17.23,36.36) 17.2,36.37 16.55,36.37 arc(16.35,36.41) 16.19,36.52 15.99,36.72 arc(15.77,37.05) 15.69,37.44 15.69,41.41 arc(15.68,41.46) 15.66,41.49 15.58,41.57 arc(15.52,41.67) 15.5,41.77 15.5,43.9 arc(15.58,44.31) 15.81,44.65 16.06,44.91 arc(16.3,45.27) 16.39,45.69 16.39,51.51 arc(16.39,51.73) 16.4,51.95 arc(16.4,52.46) 16.38,52.97 arc(16.24,53.82) 15.94,54.62 arc(15.75,55.13) 15.69,55.67 15.69,58.23 arc(15.56,58.87) 15.2,59.42 arc(14.6,59.82) 13.89,59.96 10.73,59.96 arc(10.13,60.08) 9.62,60.42 9.61,60.43 arc(9.51,60.56) 9.47,60.72 9.47,60.98 arc(9.45,61.08) v2(9.4,61.15)
  BOTTOM w0.097: v2(17.27,36.34) 17.37,36.45 arc(17.43,36.49) 17.5,36.5 17.68,36.5 arc(17.81,36.53) 17.92,36.6 arc(18,36.71) 18.03,36.84 18.03,37.64 arc(18.08,37.92) 18.24,38.16 18.38,38.3 arc(18.54,38.41) 18.74,38.45 19.28,38.45 arc(19.47,38.39) CT37.2 ; JUSBC1.B2 6.22,63.78 arc(6.28,63.82) 6.35,63.83 6.67,63.83 arc(6.77,63.81) 6.86,63.75 7.4,63.21 arc(7.61,63.07) 7.87,63.02 8.84,63.02 arc(9.04,62.98) 9.2,62.87 9.64,62.44 arc(9.7,62.35) 9.72,62.24 9.72,62.24 arc(9.6,61.97) DT27.1 9.55,61.64 arc(9.6,61.56) 9.62,61.48 9.62,61.36 arc(9.55,61.21) v2(9.4,61.15)
TBT_USB3_TX1_P_C: length 2.4
  BOTTOM w0.097: UT1.A17 22.04,38.37 arc(22.08,38.35) 22.1,38.31 22.1,38.25 arc(22.07,38.17) 21.98,38.14 21.79,38.14 arc(21.69,38.18) 21.65,38.27 arc(21.62,38.37) 21.52,38.41 20.49,38.41 arc(20.36,38.38) 20.25,38.31 CT37.1
TBTA_AUX_N: length 65.5
  TOP w0.14: v2(41.5,36.98) 41.38,37.11 40.44,37.11 39.88,37.66 38.3,37.66 v5(37.3,36.66) 36.59,35.95 34.67,35.95 33.86,36.77 33.86,37.62 34.21,37.98 34.21,38.19 34.04,38.36 CT42.2 ; RT432.2 20.16,62.5 19.51,61.85 v2(19.51,61.47)
  IN3 w0.091: v2(19.94,48.28) 19.63,48.28 19.56,48.35 19.56,48.59 20.51,49.54 20.51,53.34 21.23,54.05 21.23,60.53 20.54,61.21 19.82,61.21 19.7,61.22 v2(19.51,61.47)
  IN6 w0.099: v2(19.94,48.28) 19.82,48.16 19.47,48.16 19.16,47.85 19.16,45.45 19.56,45.05 19.56,41.47 20.02,41.01 20.99,41.01 22.08,39.93 22.08,37.01 23.28,35.8 27.47,35.8 27.8,35.48 30.89,35.48 33.71,38.3 36.6,38.3 37.36,37.54 39.96,37.54 40.33,37.17 41.32,37.17 v2(41.5,36.98)
  BOTTOM w0.081: UT4.J2 21.12,60.65 20.72,60.65 20.53,60.84 20.53,60.86 20.54,60.87 20.1,61.3 19.68,61.3 v2(19.51,61.47)
TBTA_AUX_N_C: length 4.6
  TOP w0.089: v2(29.96,39.69) 30.34,39.32 30.81,39.32 31.01,39.52 31.29,39.52 31.83,38.99 32.74,38.99 CT42.1
  BOTTOM w0.102: v2(29.96,39.69) UT1.W15
TBTA_AUX_P: length 63.8
  TOP w0.14: RT431.2 20.04,60.84 v2(19.43,60.84) ; v2(41.5,37.57) 41.38,37.44 40.57,37.44 40.02,37.99 38.17,37.99 36.45,36.28 34.81,36.28 34.19,36.9 34.19,37.49 34.55,37.84 34.55,38.42 34.27,38.69 34.27,38.7 34.04,38.93 CT41.2
  IN3 w0.091: v2(19.94,47.7) 19.37,48.27 19.37,48.67 20.32,49.62 20.32,53.42 21.03,54.13 21.03,60.45 20.46,61.02 19.81,61.02 19.68,61.03 v2(19.43,60.84)
  IN6 w0.099: v2(19.94,47.7) 19.69,47.95 19.56,47.95 19.37,47.76 19.37,45.54 19.77,45.14 19.77,41.56 20.11,41.23 21.08,41.23 22.29,40.01 22.29,37.09 23.37,36.01 27.56,36.01 27.88,35.69 30.8,35.69 33.62,38.51 36.68,38.51 37.45,37.75 40.05,37.75 40.42,37.38 41.32,37.38 v2(41.5,37.57)
  BOTTOM w0.081: UT4.J1 20.67,60.4 20.4,60.68 20.35,60.68 19.99,61.03 19.62,61.03 v2(19.43,60.84)
TBTA_AUX_P_C: length 3.5
  TOP w0.089: v2(30.61,39.69) 31.36,39.69 31.9,39.16 32.81,39.16 33.04,38.93 CT41.1
  BOTTOM w0.102: v2(30.61,39.69) UT1.Y15
TBTA_CC1: length 32.1
  TOP w0.254: v2(26.29,62.81) 27.1,62.81 CT160.1 ; v2(9.54,66.43) 9.54,66.47 9.74,66.67 DT14.1 9.35,66.95 8.97,66.56 JUSBC1.A5
  IN2 w0.254: v2(26.29,62.81) 25.78,63.32 25.78,63.7 23.5,65.99 22.79,65.99 21.48,67.29 20.37,67.29 20,67.66 17.72,67.66 17.25,67.19 15.62,67.19 15.05,66.62 15.05,64.14 14.73,63.83 8.89,63.83 8.32,64.4 8.32,64.84 9.15,65.67 9.3,65.67 9.54,65.91 v2(9.54,66.43)
  BOTTOM w0.254: v2(26.29,62.81) 26.28,62.81 UT4.L9 UT4.K9
TBTA_CC2: length 40.7
  TOP w0.254: v2(8.47,60.27) 8.47,60.02 8.12,59.67 DT25.1 6.27,59.67 6,59.95 v2(5.46,59.95) ; CT159.1 25.59,62.51 v1(25.81,62.28) 25.9,62.2 v2(26.35,62.2)
  IN1 w0.508: v2(5.46,59.95) 5.1,59.95 4.38,60.67 4.38,60.81 4.36,60.83 4.36,61.59 4.38,61.61 4.38,64.91 4.76,65.29 5.57,65.29 JUSBC1.B5
  IN2 w0.254: v2(8.47,60.27) 9.05,59.7 9.88,59.7 11.69,61.5 11.69,62.94 12.07,63.32 15.24,63.32 15.5,63.57 15.5,66.52 15.81,66.84 17.4,66.84 17.87,67.3 19.86,67.3 20.22,66.94 21.34,66.94 22.64,65.63 23.35,65.63 25.43,63.56 25.43,62.85 26.07,62.2 v2(26.35,62.2)
  BOTTOM w0.254: v2(26.35,62.2) 26.16,62.2 25.37,61.41 UT4.L10 UT4.K10
TBTA_DEBUG1: length 2.8
  BOTTOM w0.081: UT4.L2 21.29,61.48 21.29,61.98 20.66,62.6
  BOTTOM w0.14: 20.66,62.6 20.5,62.77 20.21,62.77 RT184.2
TBTA_DEBUG2: length 4.1
  BOTTOM w0.081: UT4.K2 21.12,61.15 21.12,61.5 21.12,61.5 21.12,61.81 20.44,62.49 20.1,62.49
  BOTTOM w0.14: RT185.2 19.23,62.84 19.75,62.84 20.1,62.49
TBTA_DEBUG3_LSTX: length 4.1
  BOTTOM w0.081: UT4.L3 21.87,61.49 21.61,61.75 21.61,62.44 21.12,62.93 RT187.2
  BOTTOM w0.14: RT187.2 21.22,63.47 RT233.2 21.79,64.03 v1(22.16,64.4)
TBTA_DEBUG4_LSRX: length 5.2
  BOTTOM w0.081: 20.66,63.19 20.93,62.92 20.93,62.61 21.45,62.09 21.45,61.67 21.62,61.5 21.62,61.15 UT4.K3
  BOTTOM w0.14: 20.66,63.19 RT188.2 20.32,63.37 20.1,63.59 20.1,64.59 RT232.2
TBTA_HPD: length 33.6
  TOP w0.089: 20.64,34.3 v2(21.07,34.73)
  TOP w0.14: RT43.2 20.57,34.24 20.64,34.3
  IN3 w0.089: 20.58,44.71 21.25,44.71 21.36,44.6 21.93,44.6 23.09,45.76 25.68,45.76 26.48,44.95 26.48,44.46 v2(26.7,44.24) 28.13,45.67 28.13,46.62 27.62,47.13 ; v2(21.07,34.73) 21.47,35.13 21.47,39.37 20.58,40.26 20.58,40.84
  IN3 w0.091: v2(24.89,52.78) 25.56,52.78 25.8,52.54 25.8,48.38 26.8,47.38 27.37,47.38 27.62,47.13 ; 20.58,40.84 18.66,42.75 18.66,44.05 19.32,44.71 20.58,44.71
  BOTTOM w0.089: v2(26.7,44.24) 26.73,44.24 27.03,44.54 UT1.M4
  BOTTOM w0.14: v2(24.89,52.78) 24.51,53.16 24.51,53.4 RT181.2
TBTA_HRESET: length 1.5
  TOP w0.14: v2(23.58,57.44) 23.58,57.87 RT429.1
  BOTTOM w0.14: UT4.D6 23.37,57.65 v2(23.58,57.44)
TBTA_I2C_C_N: length 12.6
  TOP w0.14: v2(10.23,73.07) 10.37,72.93 11.01,72.93 DT23.1 11.34,72.93 11.69,72.93 11.93,73.18 LT13.3
  IN2 w0.099: v2(10.23,73.07) 9.96,72.8 8.96,72.8 7.56,71.41 7.56,70.05 7.95,69.66 7.95,66.44 7.39,65.88 6.88,65.88 JUSBC1.B7
TBTA_I2C_C_P: length 12.5
  TOP w0.14: LT13.2 11.96,72.33 11.69,72.6 11.34,72.6 DT24.1 11.01,72.6 10.34,72.6 v2(10.23,72.48)
  IN2 w0.099: JUSBC1.B6 6.81,65.67 7.47,65.67 8.16,66.36 8.16,69.75 7.77,70.14 7.77,71.32 9.04,72.59 10.12,72.59 v2(10.23,72.48)
TBTA_I2C_D_N: length 28.8
  TOP w0.14: v2(12.56,75.45) 12.78,75.23 12.78,74.65 13.39,74.04 v5(14.23,74.04) 14.91,74.04 15.29,73.66 15.29,72.85 15.1,72.66 14.81,72.66 14.67,72.8 14.67,73.1 14.59,73.18 LT13.4
  IN3 w0.091: v2(12.56,75.45) 12.95,75.06 12.95,74.37 14.54,72.78 14.54,69.6 16.57,67.57 21.06,67.57 23.76,64.88 23.76,64.68 23.62,64.54 23.35,64.54 v2(23.31,64.59)
  BOTTOM w0.081: UT4.L7 23.87,61.64 24,61.77 24,61.87 24.2,62.07 24.2,62.81 23.98,63.04 23.98,63.12 23.36,63.74 23.36,63.81
  BOTTOM w0.14: 23.36,63.81 23.24,63.92 23.24,64.52 v2(23.31,64.59)
TBTA_I2C_D_P: length 28.9
  TOP w0.14: v2(13.15,75.45) 13.11,75.41 13.11,74.78 13.53,74.37 15.05,74.37 15.62,73.79 15.62,72.72 15.23,72.33 LT13.1
  IN3 w0.091: v2(13.15,75.45) 13.15,74.45 14.74,72.86 14.74,69.68 16.65,67.77 21.14,67.77 23.95,64.96 23.95,64.6 23.69,64.33 v2(23.69,64.14)
  BOTTOM w0.081: 23.69,63.81 23.69,63.79 24.25,63.23 24.25,63.15 24.47,62.92 24.47,61.96 24.27,61.75 24.27,61.65 24.12,61.5 24.12,61.15 UT4.K7
  BOTTOM w0.14: 23.69,63.81 v2(23.69,64.14)
TBTA_I2C_INT#: length 25.2
  IN2 w0.099: v2(19.5,57.29) 19.08,56.88 19.08,43.8 v2(19.07,43.79)
  IN3 w0.089: v2(25.39,44.25) 24.39,45.24 23.16,45.24 21.75,43.84 21.75,43.47 21.49,43.21 20.58,43.21
  IN3 w0.091: 20.58,43.21 19.65,43.21 v2(19.07,43.79)
  BOTTOM w0.081: 19.93,57.11 20.48,57.11 20.77,57.4 UT4.C1
  BOTTOM w0.089: UT1.J4 25.73,44.54 25.44,44.25 v2(25.39,44.25)
  BOTTOM w0.14: 19.93,57.11 19.41,56.59 RT167.2 19.09,56.94 19.43,57.29 v2(19.5,57.29)
TBTA_LDO_BMC: length 4.8
  BOTTOM w0.081: 20,58.62 20.55,58.62 20.77,58.4 UT4.E1
  BOTTOM w0.14: v1(16.89,58.05) 17.5,57.44 18.27,57.44 CT144.1
  BOTTOM w0.152: 20,58.62 19.64,58.26 19.08,58.26 CT144.1
TBTA_PD_SBU1: length 3
  BOTTOM w0.081: 25.19,62.63 25.19,62.62 24.87,62.3 24.87,61.77 24.62,61.52 24.62,61.15 UT4.K8
  BOTTOM w0.14: RT176.1 25.25,63.06 25.25,62.7 25.19,62.63
TBTA_PD_SBU2: length 2.4
  BOTTOM w0.081: UT4.L8 24.46,61.49 24.46,61.6 24.7,61.85 24.7,62.42 25.01,62.72 25.01,63.1
  BOTTOM w0.14: RT177.1 25.01,63.1
TBTA_RESET_N: length 29.8
  TOP w0.089: v2(25.41,43.58) 25.4,43.57 DT29.1
  IN2 w0.099: v2(25.41,43.58) 25.75,43.25 26.41,43.25 27.24,44.08 27.24,44.97 27.69,45.41 30.1,45.41 30.86,46.17 30.86,47.25 30.42,47.7 25.03,47.7 23.85,48.88 23.85,53.01 24.64,53.79 26.42,53.79 26.9,54.28 26.9,58.43 v2(26.54,58.79)
  BOTTOM w0.081: v2(26.54,58.79) 26.44,58.9 UT4.F11
TBTA_SBU1: length 23.7
  TOP w0.14: v2(9.46,65.17) DT17.1 9.37,64.65 8.97,65.06 JUSBC1.A8
  IN3 w0.091: v2(25.43,65.19) 25.22,64.98 25.22,64.33 24.21,63.32 22.4,63.32 21.4,64.32 21.4,65.94 20.72,66.62 13.93,66.62 13.82,66.72 11.29,66.72 10.4,65.83 9.59,65.83 9.46,65.71 v2(9.46,65.17)
  BOTTOM w0.14: v2(25.43,65.19) 25.35,65.1 25.35,64.57 RT176.2
TBTA_SBU2: length 38.7
  TOP w0.14: JUSBC1.B8 5.82,66.58 4.93,66.58 4.49,67.02 4.49,70.79 5.21,71.51 5.82,71.51 6.1,71.8 DT22.1 5.54,72.22 v2(5.53,72.22)
  IN3 w0.091: v2(5.53,72.22) 7.54,72.22 8.24,71.52 8.24,66.56 8.77,66.03 10.32,66.03 11.21,66.92 13.9,66.92 14.01,66.81 20.8,66.81 21.59,66.02 21.59,64.4 22.48,63.51 24.13,63.51 25.03,64.41 25.03,65.18 v2(24.84,65.37)
  BOTTOM w0.14: v2(24.84,65.37) 24.99,65.22 24.99,64.61 RT177.2
TBTA_USB2_D_N_C: length 4.9
  TOP w0.14: LT12.2 11.97,65.85 11.69,66.14 11.35,66.14 DT16.1 11,66.14 10.56,66.14 v5(10.32,65.9) 10.07,65.65 8.41,65.65 8.32,65.56 JUSBC1.A7
TBTA_USB2_D_N_R: length 16.3
  TOP w0.14: v2(16.05,64.5) 15.83,64.72 15.47,64.72 15.11,65.07 15.11,65.99 14.9,66.21 14.7,66.21 14.34,65.85 LT12.1
  IN2 w0.099: v2(16.05,64.5) 16.42,64.87 16.98,64.87 18.32,66.21 19.3,66.21 20.53,64.98 21.27,64.98 22.13,64.11 22.52,64.11 23.19,63.45 23.64,63.45 24.11,62.98 24.11,62.68 24.01,62.58 23.73,62.58 23.55,62.76 v2(23.55,62.86)
  BOTTOM w0.081: v2(23.55,62.86) 23.55,62.63 23.43,62.52 23.43,61.73 23.37,61.67 UT4.L6
TBTA_USB2_D_P_C: length 4.8
  TOP w0.14: JUSBC1.A6 8.31,66.06 8.39,65.98 v5(9.05,65.98) 9.93,65.98 10.42,66.47 11.02,66.47 DT15.1 11.33,66.47 11.69,66.47 11.92,66.7 LT12.3
TBTA_USB2_D_P_R: length 16.2
  TOP w0.14: LT12.4 14.4,66.7 14.56,66.54 15.03,66.54 15.44,66.13 15.44,65.21 15.6,65.05 16.02,65.05 v2(16.05,65.08)
  IN2 w0.099: v2(23.79,62.18) 23.98,62.37 24.1,62.37 24.32,62.59 24.32,63.06 23.73,63.66 23.27,63.66 22.61,64.32 22.22,64.32 21.35,65.19 20.62,65.19 19.39,66.42 18.23,66.42 16.89,65.08 v2(16.05,65.08)
  BOTTOM w0.081: v2(23.79,62.18) 23.74,62.12 23.74,61.74 23.62,61.62 23.62,61.15 UT4.K6
TBTA_VBUS_L: length 6.5
  IN3 w0.508: v2(25.52,55.86) 25.93,56.28 25.93,58.37 25.93,60.29 v2(26.48,60.84)
  BOTTOM w0.254: v2(25.52,55.86) 25.37,56.01 UT4.A10 UT4.B10
  vias: v1(27.19,61.24)
TESTMODE: length 8.3
  BOTTOM w0.102: 193.24,62.43 194.28,63.46 195.52,63.46 195.81,63.75 195.81,63.99 196.08,64.27 196.33,64.27 196.61,64.55 196.61,64.79 196.98,65.16 197.17,65.16 197.42,65.41 197.42,65.98 UV18.AK11
  BOTTOM w0.14: 193.24,62.43 v1(193.13,62.32) 192.93,62.11 RV592.1
THERMAL_ALERT#: length 0.8
  BOTTOM w0.14: RV1102.2 212.24,55.43 RV553.1
THERMATRIP2#: length 6.8
  TOP w0.14: UE3.B34 303.85,19.38 303.92,19.45 303.92,20.02 304.67,20.77 v1(305.43,20.77) 306.3,19.9 CE52.1 RE66.2 307.8,19.44 QE10.1
THERMATRIP3#: length 106.5
  TOP w0.14: v2(216.94,44.39) 217.12,44.57 RV1083.2 ; RE25.1 294.82,7.9 294.97,8.06 294.97,8.31 v2(295.28,8.61) 295.47,8.61 295.85,8.99 295.85,9.48 295.77,9.56 UE3.A2
  IN3 w0.091: v2(216.94,44.39) 217.18,44.39 230.21,31.36 251.56,31.36 252.52,30.4 253.07,30.4 258.51,24.96 258.66,24.96 261.5,22.13 263.42,22.13 263.72,22.43 266.19,22.43 267.37,23.61 v2(275.85,23.61)
  BOTTOM w0.14: v2(275.85,23.61) 276.31,24.08 276.77,24.08 279.22,21.63 281.3,21.63 282.44,20.49 282.44,18.37 282.06,17.99 282.06,15.06 283.1,14.03 283.1,11.38 282.56,10.84 282.56,10.26 284.93,7.89 289.59,7.89 289.7,7.77 295.09,7.77 295.28,7.96 v2(295.28,8.61)
THERMATRIP_GPU#: length 22.4
  TOP w0.14: v2(217.8,45.46) 218.4,46.06 RV1082.1 RV594.1
  IN1 w0.099: v2(217.8,45.46) 217.16,45.46 216.13,44.43 213.58,44.43 210.99,47.02 210.99,56.63 v2(211.66,57.3)
  BOTTOM w0.102: UV18.M1 212.14,57.3 v2(211.66,57.3)
THERMDA: length 0.5
  BOTTOM w0.089: UT1.AC23 UT1.AB23
THSEL_STRAP: length 11.4
  TOP w0.14: UE3.B29 303.2,16.88 v2(302.92,16.59) ; v2(309.83,16.99) 309.83,16.54 309.42,16.14 RE57.1 309.07,15.5 v1(308.28,14.72)
  IN6 w0.099: v2(302.92,16.59) 303.43,16.59 304.24,17.39 309.43,17.39 v2(309.83,16.99)
TMDS_L_TX0N: length 9.6
  TOP w0.14: JHDMI1.3 12.11,80.09 12.53,80.09 12.76,80.33 12.76,81.5 13.46,82.2 v5(14.05,82.2) 14.42,82.2 14.5,82.29 DV5.6 DV5.5 16.49,82.29 16.57,82.2 16.71,82.2 17.04,82.53 17.49,82.53 RV539.1 18.08,82.53 18.83,82.53 RV532.2
TMDS_L_TX0P: length 9.6
  TOP w0.14: JHDMI1.1 12.1,79.76 12.66,79.76 13.09,80.2 13.09,81.37 13.6,81.87 14.42,81.87 14.5,81.79 DV5.7 DV5.4 16.49,81.79 16.57,81.87 16.85,81.87 17.18,82.2 17.49,82.2 RV539.2 18.07,82.2 18.81,82.2 RV533.2
TMDS_L_TX1N: length 13.5
  TOP w0.076: 11.29,79 11.29,79.02 11.2,79.11 11.2,79.64 11.28,79.71 11.28,80.25 11.2,80.32 11.2,80.6 11.28,80.68 11.28,81.25 11.09,81.44 10.71,81.44 10.57,81.58 JHDMI1.6
  TOP w0.14: 11.29,79 11.29,78.74 11.41,78.62 12.83,78.62 13.81,79.6 13.81,80.37 14.14,80.7 14.42,80.7 14.5,80.79 DV5.8 DV5.2 16.49,80.79 16.62,80.65 17.27,80.65 17.34,80.59 17.52,80.59 RV540.1 18.1,80.54 18.81,80.54 RV534.2
TMDS_L_TX1P: length 13.5
  TOP w0.076: JHDMI1.4 10.93,81.29 11.03,81.29 11.13,81.19 11.13,80.74 11.05,80.67 11.05,80.26 11.13,80.18 11.13,79.78 11.05,79.7 11.05,79.11 10.96,79.02 10.96,79
  TOP w0.14: RV535.2 18.83,80.21 18.05,80.21 RV540.2 17.46,80.26 17.2,80.26 17.14,80.32 16.52,80.32 16.49,80.29 DV5.1 DV5.9 14.5,80.29 14.42,80.37 14.28,80.37 14.14,80.23 v5(14.14,79.88) 14.14,79.47 12.96,78.29 11.28,78.29 10.96,78.61 10.96,79
TMDS_L_TX2N: length 8.6
  TOP w0.14: JHDMI1.9 12.11,83.09 12.35,83.09 14.02,84.77 14.42,84.77 14.5,84.85 DV4.4 DV4.7 16.49,84.85 16.57,84.77 16.85,84.77 16.99,84.63 17.49,84.63 RV541.1 18.08,84.62 18.83,84.62 RV536.2
TMDS_L_TX2P: length 8.7
  TOP w0.14: RV537.2 18.81,84.29 18.07,84.29 RV541.2 17.49,84.3 16.85,84.3 16.71,84.44 16.57,84.44 16.49,84.35 DV4.6 DV4.5 14.5,84.35 14.42,84.44 14.16,84.44 v5(13.99,84.27) 12.48,82.76 12.1,82.76 JHDMI1.7
TMDS_L_TXCN: length 16.6
  TOP w0.076: JHDMI1.12 10.92,84.58 11.02,84.58 11.1,84.66 11.1,85.15 11.05,85.2 11.05,85.55 11.1,85.61 11.1,86.22 11.05,86.27 11.05,86.67 11.1,86.72 11.1,87.18 11.02,87.26 11.02,87.56 11.1,87.64 11.1,88.13 11.05,88.19 11.05,88.78 11.02,88.8 10.97,88.8 10.96,88.81 10.96,88.82
  TOP w0.14: 10.96,88.82 10.96,89.1 11.38,89.52 12.02,89.52 12.68,88.86 12.68,86.96 13.37,86.27 v5(14.05,86.27) 14.42,86.27 14.5,86.35 DV4.1 DV4.9 16.49,86.35 16.57,86.27 16.71,86.27 16.85,86.41 17.49,86.41 RV538.1 18.08,86.4 18.83,86.4 RV530.2
TMDS_L_TXCP: length 16.6
  TOP w0.076: 11.29,88.82 11.29,88.8 11.2,88.72 11.2,88.25 11.25,88.19 11.25,87.58 11.18,87.5 11.18,87.32 11.25,87.24 11.25,86.66 11.2,86.61 11.2,86.33 11.25,86.28 11.25,85.54 11.2,85.49 11.2,85.27 11.25,85.21 11.25,84.6 11.08,84.43 10.71,84.43 10.57,84.29 JHDMI1.10
  TOP w0.14: RV531.2 18.81,86.07 18.07,86.07 RV538.2 17.49,86.08 16.99,86.08 16.85,85.94 16.57,85.94 16.49,85.85 DV4.8 DV4.2 14.5,85.85 14.42,85.94 13.23,85.94 12.35,86.83 12.35,88.72 11.88,89.19 11.52,89.19 11.29,88.96 11.29,88.82
TMDS_TX0N: length 42.7
  TOP w0.14: RV517.1 21.62,82.47 21.17,82.47 v2(20.96,82.69) 20.8,82.53 20.29,82.53 RV532.1
  IN6 w0.099: v2(28.9,48.88) 28.9,48.87 29.24,48.54 29.24,48.48 29.12,48.35 28.66,48.35 28.41,48.61 28.41,50 28.82,50.4 28.82,56.43 28.02,57.23 27.77,57.48 27.77,66.6 23.11,71.26 23.11,81.67 22.51,82.26 21.38,82.26 v2(20.96,82.69)
  BOTTOM w0.14: CV172.1 29.03,48.38 29.03,48.75 v2(28.9,48.88)
TMDS_TX0P: length 42.7
  TOP w0.14: RV516.1 21.61,82.14 21.05,82.14 v2(20.96,82.05) 20.81,82.2 20.3,82.2 RV533.1
  IN6 w0.099: v2(20.96,82.05) 20.96,82.05 22.43,82.05 22.9,81.58 22.9,71.18 27.56,66.51 27.56,57.39 27.88,57.08 28.61,56.35 28.61,50.49 28.2,50.08 28.2,48.52 28.58,48.14 29.2,48.14 29.49,48.42 v2(29.49,48.88)
  BOTTOM w0.14: CV173.1 29.36,48.35 29.36,48.75 v2(29.49,48.88)
TMDS_TX1N: length 39.3
  TOP w0.14: RV515.1 21.62,80.64 21.3,80.64 v2(21.21,80.73) 21.06,80.58 20.27,80.58 RV534.1
  IN6 w0.099: v2(27.15,49.86) 27.15,50.19 27.95,50.99 27.95,56.07 25.77,58.26 25.77,61.49 25.4,61.86 25.4,63.76 23.83,65.33 23.83,69.14 22.29,70.68 22.29,79.95 21.79,80.45 21.49,80.45 v2(21.21,80.73)
  BOTTOM w0.14: v2(27.15,49.86) 27.15,50.12 27.27,50.24 27.45,50.24 27.95,49.74 27.95,48.44 CV174.1
TMDS_TX1P: length 39.3
  TOP w0.14: RV514.1 21.61,80.31 21.37,80.31 v2(21.21,80.15) 21.11,80.25 20.32,80.25 RV535.1
  IN6 w0.099: v2(21.21,80.15) 21.3,80.23 21.71,80.23 22.08,79.86 22.08,70.6 23.62,69.05 23.62,65.24 25.19,63.68 25.19,61.77 25.56,61.4 25.56,58.17 27.74,55.99 27.74,51.08 26.95,50.29 v2(26.76,50.29)
  BOTTOM w0.14: CV175.1 28.28,48.29 28.28,49.88 27.59,50.57 27.13,50.57 26.85,50.29 26.76,50.29 v2(26.76,50.29)
TMDS_TX2N: length 46.6
  TOP w0.14: RV513.1 21.8,84.75 v2(20.95,84.75) 20.83,84.63 20.29,84.63 RV536.1
  IN6 w0.099: v2(20.95,84.75) 20.83,84.63 20.46,84.63 20.12,84.29 20.12,76.68 21.25,75.55 21.25,70.32 20.3,69.37 20.3,67.74 21.29,66.75 21.29,63.76 21.11,63.58 21.11,57.17 21.71,56.57 25.76,56.57 26.86,55.47 26.86,52.14 25.72,50.99 25.72,50.37 26.77,49.31 26.77,48.77 v2(26.62,48.62)
  BOTTOM w0.14: CV176.1 26.73,48.12 26.73,48.5 v2(26.62,48.62)
TMDS_TX2P: length 46.4
  TOP w0.14: RV512.1 21.69,84.16 v2(20.98,84.16) 20.85,84.29 20.3,84.29 RV537.1
  IN6 w0.099: v2(20.98,84.16) 20.97,84.16 20.71,84.42 20.55,84.42 20.33,84.2 20.33,76.77 21.46,75.64 21.46,70.23 20.51,69.28 20.51,67.83 21.5,66.84 21.5,63.68 21.32,63.49 21.32,57.26 21.8,56.78 25.85,56.78 27.07,55.56 27.07,52.05 25.93,50.91 25.93,50.45 26.98,49.4 26.98,48.79 27.16,48.62 v2(27.21,48.62)
  BOTTOM w0.14: v2(27.21,48.62) 27.06,48.47 27.06,48.1 CV177.1
TMDS_TXCN: length 45.8
  TOP w0.14: RV530.1 20.29,86.4 21.15,86.4 v2(21.26,86.51) 21.41,86.37 21.64,86.37 RV519.1
  IN6 w0.099: v2(24.79,51.55) 24.65,51.7 23.77,51.7 22.08,53.39 20.8,53.39 20.77,53.35 19.57,53.35 18.21,54.71 18.21,63.29 17.91,63.59 17.91,70.67 18.59,71.34 18.59,72.61 19.3,73.32 19.3,85.22 20.51,86.43 21.18,86.43 v2(21.26,86.51)
  BOTTOM w0.14: CV170.1 25.56,50.36 25.56,51.09 v5(25.35,51.3) 24.98,51.67 24.91,51.67 v2(24.79,51.55)
TMDS_TXCP: length 45.8
  TOP w0.14: RV518.1 21.59,86.04 21.37,86.04 v2(21.26,85.93) 21.12,86.07 20.3,86.07 RV531.1
  IN6 w0.099: v2(24.79,52.14) 24.56,51.91 23.86,51.91 22.17,53.6 20.72,53.6 20.68,53.56 19.65,53.56 18.42,54.8 18.42,63.38 18.12,63.68 18.12,70.58 18.8,71.26 18.8,72.53 19.51,73.24 19.51,85.13 20.6,86.22 20.97,86.22 v2(21.26,85.93)
  BOTTOM w0.14: CV171.1 25.89,50.33 25.89,51.23 25.11,52 24.93,52 v2(24.79,52.14)
TOUCH_SCREEN_PD#: length 44.2
  TOP w0.089: v1(77.14,13.39) 76.67,12.92 v2(76.67,12.9)
  IN2 w0.099: v2(58.02,28.59) 58.31,28.59 61.8,25.11 65.85,25.11 66.42,24.54 74.09,24.54 75.18,23.45 75.18,21.57 73.33,19.73 73.33,14.97 74.68,13.63 75.94,13.63 v2(76.67,12.9)
  BOTTOM w0.089: v2(76.67,12.9) 76.67,13.23 76.82,13.38 77.76,13.38 78.09,13.71 UH2.AE44
  BOTTOM w0.127: v2(58.02,28.59) 58.02,28 55.69,25.66 ; RH510.1 73.08,13.45 74.58,13.45
  BOTTOM w0.14: 74.58,13.45 74.96,13.06 76.11,13.06 76.26,12.9 v2(76.67,12.9) ; DI1.1 55.56,25.54 55.69,25.66
TOUCHPAD_INTR#: length 36.1
  TOP w0.089: DH1.2 88.64,5.46 v3(88.39,5.72) v2(87.25,6.86)
  TOP w0.14: v2(69.89,6.8) 68.96,6.8 68.08,7.68 67.5,7.68 66.83,8.35 66.83,9.22 v2(67.14,9.53)
  IN5 w0.089: v2(87.25,6.86) 86.94,6.56 85.34,6.56 85.08,6.82 83.58,6.82 83.38,6.61 83.38,6.36 83.08,6.06 82.34,6.06 81.66,6.74 80.84,6.74 80.22,7.36 79.22,7.36 78.99,7.59 78.54,7.59 77.87,6.92 76.72,6.92 76.51,7.14 76.51,7.42 75.71,8.22 75.06,8.22
  IN5 w0.099: v2(67.14,9.53) 68.4,9.53 68.97,8.95 72.74,8.95 73.48,8.22 75.06,8.22
  BOTTOM w0.089: v2(87.25,6.86) 87.25,6.64 87.47,6.42 87.87,6.42 88.24,6.05 88.24,5.7 88.25,5.69 88.25,5.69 88.46,5.48 88.46,5.48 88.62,5.32 UH2.BC23
  BOTTOM w0.14: RH547.1 69.98,5.18 69.98,5.63 69.7,5.91 69.7,6.62 v2(69.89,6.8)
TP_PW_EN: length 91.9
  TOP w0.14: UE4.24 274.12,14.76 v2(273,13.64) ; UE6.3 192.61,4.82 192.85,4.58 193.49,4.58 193.74,4.83 193.74,5.28 v1(194.06,5.6) 194.17,5.71 194.49,5.71 RZ32.2 196.27,6.16 198.25,8.14 v2(200.66,8.14)
  IN3 w0.091: v2(200.66,8.14) 203.33,10.81 209.55,10.81 213.25,7.1 229.5,7.1 232.36,9.96 242.73,9.96 242.84,10.08 243.28,10.51 252.85,10.51 254.12,11.79 259.19,11.79 260.13,12.73 267.17,12.73 269.27,14.83 272.53,14.83 273,14.36 v2(273,13.64)
TPM_GPIO4: length 4.4
  TOP w0.14: v3(154.61,13.81) RE134.2
  TOP w0.254: UE1.13 153.93,10.09 154.61,10.77 RE126.2 RE134.2
TPM_LPM#: length 7.5
  TOP w0.14: UE1.3 157.39,6.43 157.7,6.12 159.1,6.12 159.64,5.58 159.64,3.99 159.38,3.73 158.58,3.73 RE144.2 158.74,3.15 v1(159.41,3.15)
TPM_PIRQ#: length 79.4
  TOP w0.127: UE1.18 151.28,8.43 150.69,9.03 150.69,10.57 v2(150.91,10.79)
  TOP w0.14: v2(150.91,10.79) 150.34,11.36 RE86.2 150.05,12.01 v1(150.56,12.52)
  IN6 w0.089: 101.98,11.2 101.04,11.2 101.01,11.22 99.36,11.22 99.07,10.93 98.12,10.93 97.65,11.4 95.58,11.4 94.98,10.8 92.19,10.8 91.15,9.76 89.05,9.76 88.9,9.91 88.19,9.91 88,9.72 85.92,9.72 85.47,10.17 83.09,10.17 82.73,9.8 82.09,9.8 v2(81.69,9.41)
  IN6 w0.099: v2(150.91,10.79) 150.31,10.2 147.54,10.2 146.89,10.85 145.8,10.85 145.32,11.32 128.93,11.32 128.3,11.95 125.78,11.95 124.85,11.03 116.14,11.03 115.54,11.63 113.48,11.63 112.67,10.82 108.19,10.82 107.39,11.62 102.87,11.62 102.45,11.2 101.98,11.2
  BOTTOM w0.089: UH2.AN38 81.31,9.84 v2(81.69,9.41)
TPM_VDD: length 1.3
  TOP w0.14: 158.13,11.96 v3(158.13,13.29)
UART2_RXD: length 83.2
  TOP w0.152: v2(66.58,13.52) 66.58,13.48 66.29,13.19 66.29,12.7 66.7,12.29 66.97,12.29 RH562.2
  IN2 w0.089: 76.94,8.98 76.85,8.89 75.44,8.89 75.43,8.9 75.27,8.9 75.23,8.86 75.22,8.86 75.21,8.85
  IN2 w0.107: 75.21,8.85 74.62,8.26 70.47,8.26 66.36,12.37 66.36,13.3 v2(66.58,13.52) ; v2(77.27,9.31) 76.94,8.98
  IN3 w0.099: v2(66.58,13.52) 66.36,13.75 66.36,15.19 66.61,15.44 66.61,20.63 68.33,22.35 73.21,22.35 73.61,22.75 73.61,23.09 v2(73.76,23.24)
  BOTTOM w0.089: UH2.AR45 77.36,9.16 77.27,9.25 v2(77.27,9.31)
  BOTTOM w0.152: JUART.3 103.99,50.55 104.23,50.31 104.78,50.31 105.36,49.73 105.36,43.87 100.33,38.85 96.78,38.85 94.82,36.89 89.74,36.89 83.07,30.22 77.06,30.22 73.62,26.78 73.62,23.37 v2(73.76,23.24)
UART2_TXD: length 87.3
  TOP w0.152: v2(65.96,13.47) 65.96,12.56 66.56,11.96 66.74,11.96 RH561.2
  IN2 w0.089: v2(80.76,9.42) 80.05,8.71 75.35,8.71
  IN2 w0.107: v2(65.96,13.47) 66.16,13.28 66.16,12.29 70.38,8.06 74.71,8.06 75.35,8.71
  IN3 w0.099: v2(65.96,13.47) 66.17,13.68 66.17,15.26 66.42,15.52 66.42,20.71 68.26,22.54 73.13,22.54 73.42,22.83 73.42,22.99 v2(73.17,23.24)
  BOTTOM w0.089: UH2.AR39 80.36,9.02 v2(80.76,9.42)
  BOTTOM w0.152: v2(73.17,23.24) 73.29,23.36 73.29,26.92 76.93,30.55 82.93,30.55 89.6,37.22 94.68,37.22 96.64,39.18 100.19,39.18 105.03,44.01 105.03,49.59 104.64,49.98 104.22,49.98 103.98,49.75 JUART.2
UARTT0_TX: length 282.1
  TOP w0.14: v2(312.52,7.88) v3(312.01,7.37)
  IN6 w0.099: v2(79.95,6.99) 80.59,6.35 81.38,6.35 82.04,5.7 82.04,5.09 82.75,4.37 86.48,4.37 86.7,4.14 87.83,4.14 88.49,4.8 90.96,4.8 91.69,5.53 92.14,5.53 92.25,5.42 95.34,5.42 96.12,6.21 97.1,6.21 97.66,6.77 99.01,6.77 99.57,7.33 101.17,7.33 102.81,8.98 105.14,8.98 106.21,7.9 107.19,7.9 107.45,8.16 107.45,8.79 107.54,8.89 107.64,8.89 107.92,9.17 114.67,9.17 114.82,9.02 134.27,9.02 134.9,9.65 144.73,9.65 147.67,6.7 156.5,6.7 157.2,6 161.68,6 163.15,7.46 165.3,7.46 177.94,7.46 178.87,8.38 194.65,8.38 195.81,9.55 198.11,9.55 198.95,8.71 199.44,8.71 199.88,9.14 201.32,9.14 202.79,10.62 210.59,10.62 214.34,6.87 227.11,6.87 228.18,5.8 244.46,5.8 245.73,7.07 252.71,7.07 253.12,6.66 256.47,6.66 257.07,7.27 262.43,7.27 262.46,7.24 272.47,7.24 273.65,6.06 282.78,6.06 283.99,7.27 305.94,7.27 306.47,7.81 306.47,8.45 306.9,8.88 311.53,8.88 v2(312.52,7.88)
  BOTTOM w0.089: UH2.AV44 78.37,7.78 78.75,7.78 78.77,7.77 78.94,7.77 79.17,7.54 79.4,7.54 v2(79.95,6.99)
  BOTTOM w0.14: JDEG1.9 307.11,31.86 307.33,32.08 311.5,32.08 314.1,29.49 314.1,27.29 311.84,25.03 311.84,19.07 312.73,18.18 312.73,8.35 312.52,8.15 v2(312.52,7.88)
UG_3V: length 12.5
  TOP w0.14: v2(342.71,22.81) v1(341.73,22.81)
  IN1 w1.016: 342.08,23.63 341.69,24.01 337.5,24.01 335.66,22.17 331.47,22.17
  vias: v2(330.2,22.42) v2(330.2,21.79) v2(343.16,22.42)
UG_5V: length 25.8
  TOP w0.14: v2(342.49,18.55) v3(341.42,18.55)
  IN1 w1.016: 333.06,11.44 337.76,11.44 339.79,9.41 345.63,9.41 347.83,11.6 347.83,14.89 345.57,17.15 344.17,17.15 343.92,17.41
  vias: v2(331.47,10.87) v2(331.47,10.23) v2(343.09,18.55)
UMA_DIS: length 15.8
  IN6 w0.099: v2(67.12,15.82) 67.4,15.54 70.12,15.54 73.29,12.38 73.65,12.38 v2(74.33,11.7)
  BOTTOM w0.089: UH2.AL44 77.89,10.98 75.06,10.98
  BOTTOM w0.14: 75.06,10.98 75.05,10.98 v2(74.33,11.7) ; RH589.1 RH588.1 67.62,14.8 v1(67.12,15.3) v2(67.12,15.82)
UPD_GPU_SMBCLK: length 517.1
  TOP w0.14: QV21.6 200.8,44.19 201.07,44.46 201.93,44.46 202.93,43.46 206.72,43.46 207.44,44.18 207.44,46.41 207.71,46.68 208.6,46.68 v2(208.79,46.87) ; RT201.1 20.53,67.75 20.67,67.61 v2(20.67,65.71) ; RE95.1 295.48,32.46 295.21,32.18 295.21,31.35 295.35,31.21 295.59,31.21 295.73,31.07 295.73,30.76 295.61,30.63 295.33,30.63 295.21,30.5 295.21,30.22 295.49,29.93 295.49,27.99 295.35,27.85 294.72,27.85 294.58,27.71 294.58,27.47 294.7,27.34 295.5,27.34 295.63,27.21 295.63,26.97 295.5,26.84 v1(294.02,26.84) 293.69,26.84 293.56,26.72 293.56,25.83 293.69,25.7 293.99,25.7 294.12,25.83 294.12,26.26 294.25,26.39 294.48,26.39 294.6,26.26 294.6,25.83 294.73,25.7 295.04,25.7 295.16,25.83 295.16,26.08 295.35,26.27 v2(295.81,26.27) ; UE3.B49 296.02,19.2 v2(295.97,19.15)
  IN1 w0.099: v2(208.79,46.87) 209.01,46.87 209.98,45.9 211.82,45.9 213.51,44.22 216.54,44.22 216.85,43.91 217.52,43.91 217.61,44.01 217.61,44.93 217.71,45.03 217.91,45.03 218.01,44.93 218.01,44.01 218.11,43.91 218.31,43.91 218.41,44.01 218.41,45.25 218.51,45.35 218.7,45.35 218.8,45.25 218.8,44.01 218.9,43.91 220.88,43.91 221.47,43.33 227.8,43.33 228.47,42.65 233.45,42.65 233.88,42.22 242.32,42.22 242.78,41.76 242.78,40.81 242.88,40.71 243.46,40.71 243.56,40.61 243.56,40.3 243.46,40.2 242.88,40.2 242.78,40.1 242.78,39.8 242.88,39.7 244.43,39.7 244.53,39.6 244.53,39.29 244.43,39.19 242.88,39.19 242.78,39.09 242.78,38.78 242.88,38.69 244.43,38.69 244.53,38.59 244.53,38.28 244.43,38.18 242.88,38.18 242.78,38.08 242.78,37.77 242.88,37.67 244.43,37.67 244.53,37.58 244.53,37.27 244.43,37.17 242.88,37.17 242.78,37.07 242.78,36.76 242.88,36.66 244.43,36.66 244.53,36.56 244.53,36.26 244.43,36.16 242.88,36.16 242.78,36.06 242.78,35.76 242.91,35.63 244.41,35.63 244.54,35.51 244.54,35.24 244.44,35.14 243.94,35.14 243.82,35.01 243.82,34.83 243.94,34.71 244.49,34.71 244.54,34.65 244.54,33.98 247.71,30.8 251.51,30.8 261.74,20.57 266.99,20.57 269.19,22.76 281.13,22.76 282.38,24.01 287.66,24.01 289.61,25.97 295.5,25.97 v2(295.81,26.27) ; v2(290.01,19.07) 290.05,19.07 290.45,18.67 291.11,18.67 291.29,18.84 294.02,18.84 294.74,19.57 295.56,19.57 v2(295.97,19.15)
  IN3 w0.091: v2(20.67,65.71) 17.38,65.71 17.25,65.59 17.25,64.59 17.34,64.5 19.15,64.5 19.24,64.41 19.24,64.23 19.15,64.13 17.34,64.13 17.25,64.04 17.25,63.86 17.34,63.77 19.15,63.77 19.24,63.68 19.24,63.49 19.15,63.4 17.34,63.4 17.25,63.31 17.25,63.13 17.34,63.04 19.15,63.04 19.24,62.95 19.24,62.76 19.15,62.67 17.34,62.67 17.25,62.58 17.25,45.27 16.08,44.1 16.08,43.34 15.23,42.49 15.23,34.51 15.38,34.36 15.38,32.69 v2(17.27,30.79)
  IN6 w0.099: v2(290.01,19.07) 289.58,19.5 285.1,19.5 284.71,19.12 283.49,19.12 281.28,16.91 278.77,16.91 277.49,15.64 271.81,15.64 271.71,15.54 271.71,14.41 271.6,14.3 271.43,14.3 271.32,14.41 271.32,14.58 271.22,14.68 271.02,14.68 270.92,14.58 270.92,14.41 270.8,14.3 268.52,14.3 266.37,12.15 263.41,12.15 261.47,10.21 250.67,10.21 249.5,11.39 237.11,11.39 236.66,10.94 235.06,10.94 234.56,11.43 231,11.43 230.83,11.43 228.36,13.9 186.68,13.9 185.9,13.12 176.44,13.12 175.52,12.2 161.18,12.2 160.82,12.56 152.3,12.56 152.24,12.61 149.14,12.61 149,12.48 146.47,12.48 146.02,12.93 129.59,12.93 128.77,13.75 125.3,13.75 124.19,12.64 116.8,12.64 116.08,13.36 101.91,13.36 101.89,13.39 101.61,13.39 101.5,13.5 101.5,13.51 101.34,13.66 100.07,13.66 99.96,13.56 99.66,13.56 99.55,13.66 98.96,13.66 98.36,14.26 96.36,14.26 96.12,14.5 92.15,14.5 91.64,13.99 85.84,13.99 85.52,14.31 78.22,14.31 78.05,14.14 73.77,14.14 71.4,16.5 69.06,16.5 67.31,18.25 67.31,18.5 v2(67.04,18.77) 67.27,19 67.27,19.66 66.41,20.51 65.25,20.51 64.4,21.37 64.4,21.65 61.7,24.35 58.18,24.35 55.55,26.98 50.08,26.98 48.4,28.67 38.68,28.67 38.01,28.01 38.01,28 37.89,27.89 36.83,27.89 35.7,29.02 33.95,29.02 33.36,28.43 33.36,27.63 32.1,26.37 28.59,26.37 27.05,27.91 26.31,27.91 25.73,28.49 20.38,28.49 19.86,29 19.06,29 v2(17.27,30.79)
  BOTTOM w0.14: v2(295.97,19.15) 296.07,19.25 296.07,22.53 296.79,23.25 296.79,25.26 295.84,26.22 295.83,26.22 295.78,26.27 v2(295.81,26.27) ; QE18.3 67.04,18.77 v2(67.04,18.77)
UPD_GPU_SMBDAT: length 504.8
  TOP w0.14: v2(299.81,29.27) 299.62,29.08 v1(298.9,29.08) 298.64,29.33 RE94.1 ; RT200.1 22.48,67.56 v2(22.87,67.17) ; v2(207.27,46.94) 207.16,46.83 207.16,44.24 206.62,43.7 203.04,43.7 202.02,44.71 200.48,44.71 200.03,45.17 199.7,45.17 199.5,45.36 QV21.3 ; v2(296.81,18.76) 296.4,19.17 296.4,19.53 296.52,19.65 UE3.B48
  IN1 w0.099: v2(299.81,29.27) 299.29,28.75 299.29,27.24 298.74,26.69 297.51,26.69 296.55,25.73 289.65,25.73 287.56,23.63 282.28,23.63 281.22,22.56 269.27,22.56 267.08,20.37 261.66,20.37 251.42,30.6 247.63,30.6 242.58,35.65 242.58,41.65 242.22,42.01 233.8,42.01 233.37,42.45 228.39,42.45 227.71,43.13 221.37,43.13 220.79,43.71 216.77,43.71 216.46,44.02 213.43,44.02 211.74,45.7 209.9,45.7 209.17,46.43 207.78,46.43 207.28,46.94 v2(207.27,46.94) ; v2(290.62,19.07) 293.86,19.07 294.55,19.77 295.93,19.77 296.27,19.43 296.27,19.43 296.4,19.29 296.4,19.17 v2(296.81,18.76)
  IN2 w0.099: v2(14.16,67.23) 15.27,67.23 15.51,67.47 17.14,67.47 17.6,67.94 20.12,67.94 20.48,67.57 22.47,67.57 v2(22.87,67.17)
  IN4 w0.091: v2(299.81,29.27) 297.76,27.22 297.76,25.64 296.85,24.73 296.85,24.6 297.35,24.1 297.35,23.95 297.24,23.84 297.09,23.84 296.59,24.34 296.46,24.34 296.1,23.98 296.1,23.79 296.19,23.7 296.63,23.7 296.72,23.61 296.72,23.42 296.63,23.33 296.19,23.33 296.1,23.24 296.1,21.93 296.19,21.84 296.58,21.84 296.67,21.75 296.67,21.57 296.58,21.48 296.19,21.48 296.1,21.39 296.1,21.2 296.19,21.11 296.98,21.11 297.09,21 297.09,20.85 296.98,20.75 296.19,20.75 296.1,20.65 296.1,20.44 296.19,20.35 297.76,20.35 297.85,20.25 297.85,20.07 297.7,19.92 296.83,19.92 296.43,19.52 296.43,19.15 v2(296.81,18.76)
  IN6 w0.089: 101.69,13.58 100.84,14.42 100.05,14.42 99.94,14.31 98.62,14.31 98.49,14.44 96.44,14.44 96.19,14.69 95.32,14.69 ; 92.06,14.69 91.55,14.18 91.38,14.18
  IN6 w0.099: v2(290.62,19.07) 289.99,19.7 285.01,19.7 284.63,19.33 283.38,19.33 281.17,17.12 278.69,17.12 277.42,15.85 269.77,15.85 266.28,12.35 263.33,12.35 261.4,10.42 250.76,10.42 249.58,11.6 237.03,11.6 236.59,11.16 235.12,11.16 234.65,11.63 230.91,11.63 228.36,14.18 186.68,14.18 185.82,13.32 176.36,13.32 175.44,12.4 161.27,12.4 160.85,12.81 149.06,12.81 148.92,12.68 146.56,12.68 146.11,13.13 129.68,13.13 128.85,13.95 125.22,13.95 124.1,12.84 116.89,12.84 116.15,13.58 101.69,13.58 ; 95.32,14.69 92.06,14.69 ; v2(14.16,67.23) 14.99,66.41 14.99,64.02 14.16,63.19 11.88,63.19 11.75,63.06 11.75,60.91 12.51,60.14 15.43,60.14 15.99,59.59 15.99,44.69 15.65,44.36 15.65,40.11 15.18,39.64 15.04,39.5 15.04,35.19 15.18,35.05 17.93,32.29 17.93,30.42 19.15,29.2 19.94,29.2 20.46,28.69 25.81,28.69 26.4,28.11 27.13,28.11 28.67,26.57 32.02,26.57 33.16,27.71 33.16,28.51 33.87,29.22 35.78,29.22 36.91,28.09 37.81,28.09 37.81,28.09 38.59,28.87 48.48,28.87 50.17,27.19 55.65,27.19 58.28,24.56 61.78,24.56 64.6,21.73 64.6,21.45 65.34,20.71 66.49,20.71 67.47,19.74 67.47,19.03 v2(67.73,18.78) 67.51,18.56 67.51,18.34 69.14,16.71 71.49,16.71 73.86,14.34 77.96,14.34 78.13,14.51 83.55,14.51 84.39,15.35 85.03,15.35 85.45,14.93 86.04,14.93 86.21,14.77 86.21,14.4 86.43,14.18 91.38,14.18
  BOTTOM w0.14: v2(67.73,18.78) 68.34,19.39 QE18.6
UPD_MRESET: length 363.1
  TOP w0.14: v1(281.61,21.11) 281.32,20.82 RZ41.1 281.33,20.06 281.89,20.06 v2(281.95,20.13) ; RT244.1 25.59,51.27 24.86,50.54 v2(24.86,50.41) ; v2(297.41,8.05) 297.22,8.24 297.22,8.71 296.91,9.02 296.91,9.46 296.77,9.59 UE3.A4
  IN3 w0.089: 101.98,7.91 100.42,7.91 98.76,6.24 98.76,5.01 97.94,4.19 96.03,4.19 95.95,4.27 95.61,4.27 94.88,5 92.24,5 91.99,4.75 91.68,4.75 91.55,4.88 89.81,4.88 89.75,4.82 88.43,4.82 87.88,4.27 87.11,4.27 86.59,4.79 85.92,4.79 85.19,4.07 80.33,4.07 79.12,2.86 79.12,2.55 78.46,1.89 75.57,1.89 75.06,2.39
  IN3 w0.091: 101.98,7.91 102.08,7.91 103.66,9.5 107.09,9.5 107.38,9.79 109.6,9.79 110.02,9.37 112.24,9.37 113.69,7.92 114.72,7.92 117.59,10.78 118.9,10.78 121.51,13.4 147.04,13.4 147.4,13.04 152.12,13.04 155.02,10.14 155.58,10.14 156.05,10.61 162.67,10.61 163.91,11.86 178.68,11.86 179.35,11.18 186.48,11.18 186.65,11.01 189.3,11.01 191.37,8.93 195.99,8.93 196.87,8.05 199.77,8.05 202.81,11.09 209.89,11.09 213.4,7.58 227.28,7.58 227.78,8.07 230.19,8.07 232.28,10.16 242.65,10.16 243.2,10.7 252.77,10.7 254.04,11.98 254.04,11.98 254.82,12.75 259.88,12.75 260.05,12.92 267.09,12.92 269.19,15.02 278.09,15.02 280.25,17.19 280.25,17.78 281.32,18.84 281.32,19.49 v2(281.95,20.13) ; v2(42.92,23.87) 45.53,21.26 46.59,21.26 46.88,20.97 52.46,20.97 53.08,20.35 54.36,20.35 55.57,19.15 57,19.15 57.21,18.93 57.21,17.5 58.4,16.32 58.97,16.32 61.11,14.17 61.11,7.71 63.46,5.36 63.46,4.2 64.39,3.27 64.39,2.97 64.62,2.73 65.43,2.73 66.57,1.6 69.43,1.6 70.91,3.08 73.12,3.08 73.45,2.75 74.7,2.75 75.06,2.39
  IN4 w0.091: v2(29.17,58.27) 28.96,58.05 28.96,55.13 30.02,54.07 30.31,54.07 30.99,53.39 30.99,53.09 31.24,52.84 31.24,52.27 31.69,51.82 31.69,50.62 31.05,49.98 ; v2(42.92,23.87) 43,23.96 43,29.41 43.53,29.94 43.53,37.63 42.93,38.24 42.55,38.24 40.51,40.27 40.01,40.27 39.63,39.89 39.63,38.88 38.95,38.2 38.01,38.2 34.8,41.41 34.8,42.68 33.39,44.09 32.73,44.09 31.14,45.68 31.14,49.9 31.05,49.98 ; 31.05,49.98 28.15,49.98 26.86,51.27 25.74,51.27 24.88,50.41 v2(24.86,50.41)
  BOTTOM w0.14: v2(281.95,20.13) 281.95,18.28 281.69,18.01 281.69,10.04 284.57,7.16 289.29,7.16 289.4,7.05 295.44,7.05 295.91,7.51 296.77,7.51 297.31,8.05 v2(297.41,8.05) ; v2(29.17,58.27) 29.08,58.36 28.88,58.36 28.87,58.37 RT245.2
UPD_SMBCLK: length 21.6
  TOP w0.14: v2(21.08,69.1) 20.65,68.67 RT201.2
  IN3 w0.091: v2(21.08,69.1) 21.53,69.54 23.31,69.54 26.04,66.81 26.04,63.83 25.53,63.32 25.53,57.01 24.85,56.33 23.7,56.33 v2(23.24,55.88)
  BOTTOM w0.081: v2(23.24,55.88) 23.2,55.88 23.12,55.96 23.12,56.65 UT4.B5
UPD_SMBDAT: length 21.3
  TOP w0.14: v2(21.72,69.1) 22.09,68.73 RT200.2
  IN3 w0.091: v2(21.72,69.1) 23.48,69.1 25.84,66.73 25.84,63.91 25.33,63.4 25.33,57.09 24.77,56.52 23.31,56.52 22.8,56.02 22.8,55.61 v2(23.23,55.18)
  BOTTOM w0.081: 23.02,55.47 22.88,55.62 22.88,55.68 22.82,55.74 22.82,56.05 22.87,56.09 UT4.A5
  BOTTOM w0.14: v2(23.23,55.18) 23.23,55.27 23.02,55.47
USB3RN1: length 240.3
  IN3 w0.099: v2(313.98,25.5) 314.16,25.33 314.16,25.25 313.94,25.03 312.59,25.03 311.08,26.54 308.31,26.54 307.42,25.65 293.32,25.65 292.47,24.8 289.46,24.8 288.21,23.55 281.46,23.55 279.44,21.53 270.7,21.53 268.45,19.28 261.18,19.28 260.45,20.01 257.18,20.01 256.48,20.71 255.05,20.71 253.55,19.21 252.94,19.21 251.33,17.6 232.09,17.6 230.63,16.14 229.69,16.14 229.43,15.88 165.63,15.88 165.48,16.03 165.48,17.93 164.55,18.87 126.68,18.87 125.79,19.76 109.72,19.76 108.94,20.53 108.94,20.92 107.96,21.89 107.96,22.57 106.8,23.73 105.64,23.73 104.71,22.81 104.14,22.81 101.6,25.35 100.98,25.35 99.71,26.62 97.52,26.62 97.32,26.82 97.23,26.82 v2(96.78,27.28)
  BOTTOM w0.089: UH2.B7 96.09,25.61 96.09,25.88 96.17,25.95 96.17,26.76 96.57,27.16 96.66,27.16 v2(96.78,27.28)
  BOTTOM w0.152: CI8.1 318.8,27.47 318.8,27.15 318.15,26.5 314.49,26.5 314.12,26.13 314.12,25.64 v2(313.98,25.5)
USB3RN1_C: length 1.8
  BOTTOM w0.14: UI3.23 318.91,29.05 CI8.2
USB3RN1_D-: length 9.4
  TOP w0.152: RI40.2 333.05,74.61 332.18,73.73 332.03,73.73 331.65,73.36 331.65,73.22 331.75,73.13 331.92,73.13 332.09,73.3 DI9.1 DI9.9 333.61,73.3 333.69,73.21 333.82,73.21 334.2,73.59 v5(334.2,74.33) 334.2,75.26 335.05,76.11 335.61,76.11 335.82,76.31 JUSB2.5
USB3RN1_RE: length 50.6
  TOP w0.152: v2(331.34,76.78) 332.7,76.78 333.19,76.3 RI40.1
  IN2 w0.107: v2(331.34,76.78) 331.28,76.72 330.74,76.72 330.52,76.49 330.52,52.39 318.88,40.75 v2(318.88,35.37)
  BOTTOM w0.152: UI3.8 318.91,35.34 v2(318.88,35.37)
USB3RN2: length 146.3
  TOP w0.152: v2(19.17,96.36) 19.38,96.16 19.51,96.16 19.67,96.32 19.67,98.31 19.18,98.8 RI44.1
  IN3 w0.099: v2(95.54,26.21) 95.57,26.23 96.12,26.23 96.33,26.44 96.33,27.19 95.94,27.58 95.44,27.58 95.01,28.01 89.28,28.01 86.56,25.29 84.02,25.29 82.73,24 81.02,24 80.69,24.33 79.67,24.33 79.56,24.44 77.93,24.44 77.29,23.81 76.32,23.81 75.67,24.46 57.7,24.46 56.78,25.37 50.63,25.37 50.41,25.59 47.21,25.59 46.02,26.77 46.02,27.4 43.55,29.88 42.24,29.88 41.96,30.16 41.96,30.7 41.28,31.38 40.07,31.38 34.34,37.1 34.34,41.13 34.53,41.32 34.53,44.57 33.85,45.25 33.85,46.74 33.16,47.43 33.16,48.91 28.55,53.52 28.55,67.01 27.28,68.27 27.28,76.61 26.42,77.48 26.42,81.29 28.74,83.61 28.74,88.57 25.61,91.7 23.77,91.7 22.35,93.12 22.35,93.77 19.76,96.36 v2(19.17,96.36)
  BOTTOM w0.089: v2(95.54,26.21) 95.64,26.11 95.64,25.6 95.51,25.47 95.51,25.22 UH2.C8
USB3RN2_D-: length 7.4
  TOP w0.152: JUSB1.5 16.18,99.5 16.78,100.1 17.46,100.1 17.9,100.53 17.9,100.94 18.02,101.06 18.34,101.06 18.41,100.99 DI7.9 DI7.1 19.92,100.99 20.09,101.16 20.22,101.16 20.36,101.02 20.36,100.84 19.79,100.28 19.67,100.28 RI44.2
USB3RP1: length 240.3
  IN3 w0.099: v2(314.57,25.5) 314.35,25.29 314.35,25.17 314.02,24.84 312.51,24.84 311,26.35 308.39,26.35 307.5,25.46 293.4,25.46 292.55,24.61 289.54,24.61 288.29,23.36 281.53,23.36 279.52,21.34 270.78,21.34 268.53,19.09 261.1,19.09 260.37,19.82 257.1,19.82 256.4,20.52 255.13,20.52 253.63,19.02 253.02,19.02 251.41,17.41 232.17,17.41 230.71,15.95 229.77,15.95 229.51,15.69 165.55,15.69 165.29,15.95 165.29,17.85 164.47,18.68 126.6,18.68 125.72,19.57 109.64,19.57 108.75,20.46 108.75,20.84 107.77,21.81 107.77,22.49 106.72,23.54 105.72,23.54 104.79,22.61 104.06,22.61 101.52,25.15 100.9,25.15 99.63,26.42 97.45,26.42 97.24,26.63 96.99,26.63 v2(96.79,26.42)
  BOTTOM w0.089: UH2.A7 96.5,25.83 96.5,26.06 96.36,26.2 96.36,26.68 96.57,26.89 97,26.89 97.08,26.82 97.08,26.72 v2(96.79,26.42)
  BOTTOM w0.152: v2(314.57,25.5) 314.45,25.62 314.45,25.99 314.63,26.17 318.29,26.17 319.13,27.01 319.13,27.47 CI7.1
USB3RP1_C: length 1.8
  BOTTOM w0.14: UI3.22 319.41,29.95 319.23,29.76 319.23,28.84 CI7.2
USB3RP1_D+: length 9.5
  TOP w0.152: JUSB2.6 335.82,75.53 335.57,75.78 335.19,75.78 334.53,75.12 334.53,73.45 333.96,72.88 333.67,72.88 333.58,72.8 DI9.8 DI9.2 331.61,72.8 331.32,73.09 331.32,73.5 331.89,74.06 332.04,74.06 332.23,74.25 RI39.2
USB3RP1_RE: length 50.6
  TOP w0.152: v2(331.34,76.2) 331.5,76.35 331.52,76.35 331.62,76.45 332.56,76.45 332.86,76.16 332.86,76.01 332.36,75.52 RI39.1
  IN2 w0.107: v2(331.34,76.2) 331.03,76.51 330.83,76.51 330.72,76.41 330.72,52.31 319.08,40.67 319.08,35.75 v2(319.46,35.37)
  BOTTOM w0.152: UI3.9 319.41,34.76 319.24,34.93 319.24,35.12 319.46,35.34 v2(319.46,35.37)
USB3RP2: length 146.4
  TOP w0.152: RI43.1 20,96.18 19.65,95.83 19.22,95.83 v2(19.17,95.78)
  IN3 w0.099: v2(19.17,95.78) 19.17,95.79 19.55,96.17 19.68,96.17 22.16,93.69 22.16,93.04 23.69,91.51 25.53,91.51 28.55,88.49 28.55,83.69 26.23,81.37 26.23,77.4 27.09,76.53 27.09,68.2 28.36,66.93 28.36,53.44 32.97,48.83 32.97,47.35 33.66,46.67 33.66,45.17 34.34,44.49 34.34,41.4 34.15,41.21 34.15,37.03 39.99,31.19 41.2,31.19 41.65,30.73 41.77,30.62 41.77,30.09 42.16,29.69 43.47,29.69 45.83,27.33 45.83,26.69 47.13,25.4 50.33,25.4 50.56,25.18 56.71,25.18 57.62,24.27 75.59,24.27 76.24,23.62 77.37,23.62 78,24.25 79.48,24.25 79.59,24.14 80.61,24.14 80.94,23.81 82.81,23.81 84.1,25.1 86.64,25.1 89.36,27.82 94.93,27.82 95.37,27.39 95.86,27.39 96.14,27.11 96.14,26.52 96.04,26.42 95.85,26.42 95.54,26.73 v2(95.54,26.86)
  BOTTOM w0.089: UH2.B8 95.78,25.45 95.91,25.59 95.91,26.49 v2(95.54,26.86)
USB3RP2_D+: length 7.4
  TOP w0.152: RI43.2 20,100.02 20.69,100.71 20.69,101.16 20.36,101.49 DI7.2 DI7.8 18.4,101.49 18.3,101.39 17.89,101.39 17.57,101.07 17.57,100.67 17.32,100.43 16.95,100.43 JUSB1.6
USB3T_N1: length 38.1
  TOP w0.152: RI37.1 332.49,68.39 332.49,66.16 332.35,66.02 332.35,65.76 v2(332.19,65.6)
  IN2 w0.107: v2(332.19,65.6) 332.42,65.38 332.42,64.85 333.5,63.77 333.5,62.21 332.74,61.45 332.74,59.44 331.66,58.37 331.66,52.3 320.5,41.14 320.5,37.96 v2(320.38,37.85)
  BOTTOM w0.152: CI16.2 320.49,37.23 320.49,37.75 v2(320.38,37.85)
USB3T_N2: length 1.9
  TOP w0.152: RI41.1 20,105.62 20.31,105.93 v2(20.31,106.16)
  BOTTOM w0.152: CI9.2 20.19,105.69 20.19,106.03 v2(20.31,106.16)
USB3T_P1: length 38.2
  TOP w0.152: v2(332.78,65.6) 332.68,65.7 332.68,65.88 332.82,66.02 332.82,68.46 RI38.1
  IN2 w0.107: v2(332.78,65.6) 332.63,65.45 332.63,64.93 333.71,63.85 333.71,62.12 332.94,61.36 332.94,59.36 331.86,58.28 331.86,52.22 320.7,41.06 320.7,38.11 v2(320.97,37.85)
  BOTTOM w0.152: CI20.2 321.11,37.04 320.82,37.33 320.82,37.7 v2(320.97,37.85)
USB3T_P2: length 2
  TOP w0.152: RI42.1 19.73,105.98 v2(19.73,106.16)
  BOTTOM w0.152: CI10.2 19.86,105.67 19.86,106.03 v2(19.73,106.16)
USB3TN1: length 243
  IN3 w0.099: v2(94.38,26.2) 94.38,26.27 94.57,26.45 94.85,26.45 94.98,26.32 94.98,25.85 95.64,25.19 98.74,25.19 99.56,24.38 99.56,23.72 101.78,21.5 101.98,21.5 104.7,18.78 125.3,18.78 126.22,17.85 161.91,17.85 164.7,15.06 231.39,15.06 231.89,15.57 244.62,15.57 245.21,14.98 249.82,14.98 253.14,18.3 254.83,18.3 255.14,18.61 256.11,18.61 256.72,19.23 259.91,19.23 261.24,17.9 270.77,17.9 273.07,20.2 279.22,20.2 281.78,22.76 288.76,22.76 289.84,23.85 314.2,23.85 314.33,23.72 314.33,23.55 v2(314.06,23.29)
  BOTTOM w0.089: v2(94.38,26.2) 94.52,26.2 94.68,26.04 94.68,25.89 94.5,25.71 94.5,25.56 94.46,25.52 94.46,25.21 94.73,24.94 UH2.C11
  BOTTOM w0.152: CI6.1 320.57,27.47 v5(320.57,26.26) 320.57,25.8 319.06,24.29 314.55,24.29 314.2,23.94 314.2,23.43 v2(314.06,23.29)
USB3TN1_C: length 1.8
  BOTTOM w0.152: CI6.2 320.52,28.89 320.52,29.82 320.41,29.93 UI3.20
USB3TN1_D-: length 8.5
  TOP w0.152: RI37.2 332.11,70.05 331.19,70.96 331.19,71.45 331.54,71.8 DI9.4 DI9.7 333.79,71.8 333.87,71.71 334.19,71.71 334.6,71.31 334.6,70.72 335.22,70.1 335.33,70.1 335.82,70.59 JUSB2.8
USB3TN1_RE: length 1.8
  BOTTOM w0.152: UI3.11 320.41,34.86 320.54,34.98 320.54,35.89 CI16.1
USB3TN2: length 157.5
  IN3 w0.099: v2(23.67,103.72) 18.5,98.55 18.5,95.34 20.11,93.74 20.11,92.28 20.75,91.64 21.34,91.64 22.86,90.12 24.45,90.12 27.31,87.26 27.31,83.34 25.59,81.62 25.59,77.02 26.35,76.26 26.35,68.09 27.76,66.68 27.76,51.99 29.39,50.36 30.34,50.36 31.21,49.5 31.21,48.48 31.44,48.24 31.44,45.13 32.56,44.01 33.01,44.01 33.75,43.27 33.75,41.81 33.56,41.62 33.56,36.78 39.77,30.57 40.04,30.57 41.53,29.08 42.95,29.08 44.34,27.7 44.34,27.16 46.69,24.81 50.09,24.81 50.31,24.58 56.37,24.58 57.42,23.54 65.71,23.54 66.22,23.03 71.44,23.03 72.08,23.67 75.18,23.67 76.77,22.08 80.13,22.08 80.7,21.51 81.95,21.51 82.14,21.32 83.17,21.32 83.55,21.7 83.55,23.08 84.24,23.77 84.7,23.77 84.99,24.06 87.49,24.06 89.36,25.93 89.36,26.73 89.86,27.23 92.46,27.23 92.9,26.79 92.9,26.26 93.13,26.03 93.31,26.03 v2(93.52,25.82)
  BOTTOM w0.089: v2(93.52,25.82) 93.61,25.82 94.11,25.31 UH2.B12
  BOTTOM w0.152: v2(23.67,103.72) 23.8,103.59 23.8,103.31 23.34,102.85 20.86,102.85 19.99,103.72 19.99,103.94 CI9.1
USB3TN2_D-: length 10.3
  TOP w0.152: RI41.2 20,104.08 20.75,103.33 20.75,102.84 20.41,102.5 19.83,102.5 19.82,102.49 DI7.4 DI7.7 18.37,102.49 18.3,102.56 17.99,102.56 17.63,102.92 17.63,103.43 17.81,103.61 v5(17.81,103.97) 17.81,104.76 17.63,104.94 17.63,105.76 17.37,106.02 17.01,106.02 JUSB1.8
USB3TP1: length 243
  IN3 w0.099: v2(314.64,23.29) 314.52,23.41 314.52,23.47 314.52,23.8 314.28,24.04 289.76,24.04 288.68,22.96 281.7,22.96 279.14,20.39 272.99,20.39 270.69,18.09 261.32,18.09 259.99,19.42 256.65,19.42 256.03,18.8 255.07,18.8 254.75,18.49 253.06,18.49 249.74,15.17 245.29,15.17 244.7,15.76 231.81,15.76 231.31,15.25 164.78,15.25 161.99,18.04 126.3,18.04 125.37,18.97 104.78,18.97 102.06,21.69 101.86,21.69 99.75,23.8 99.75,24.46 98.82,25.38 95.72,25.38 95.17,25.93 95.17,26.4 94.92,26.65 94.69,26.65 v2(94.51,26.83)
  BOTTOM w0.089: v2(94.51,26.83) 94.88,26.46 94.88,26.22 94.95,26.15 94.95,25.78 94.76,25.6 94.76,25.58 94.73,25.54 UH2.B11
  BOTTOM w0.152: v2(314.64,23.29) 314.53,23.4 314.53,23.8 314.69,23.96 319.2,23.96 320.9,25.67 320.9,27.47 CI5.1
USB3TP1_C: length 1.8
  BOTTOM w0.152: CI5.2 320.85,28.99 320.85,29.85 320.91,29.91 UI3.19
USB3TP1_D+: length 8.4
  TOP w0.152: RI38.2 332.94,69.68 331.52,71.1 331.52,71.31 331.67,71.47 331.81,71.47 331.98,71.3 DI9.5 DI9.6 333.73,71.3 333.82,71.38 334.05,71.38 334.27,71.17 334.27,70.59 335.08,69.77 335.37,69.77 335.82,69.32 JUSB2.9
