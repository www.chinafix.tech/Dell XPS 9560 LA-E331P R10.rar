# Allegro board Dell XPS 9560 LA-E331P R10.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ILIM_SEL_R: length 27.7
  TOP w0.14: RI30.2 321.96,43.57 DI12.2 323.74,45.28 324.11,44.92 RI35.2 v1(324.74,46.15) 324.46,46.43 RI34.1 323.55,47.19 RI32.1 v2(324.62,47.37)
  BOTTOM w0.14: v2(324.62,47.37) 326.25,47.37 330.25,51.37 330.25,56.04 330.25,56.04 330.25,56.24 328.51,57.98 328.51,60.77 329.07,61.32 UI2.4
ILMT_0.95V: length 5.1
  TOP w0.14: v3(107.19,63.36) 108.04,63.36 108.48,63.81 v2(108.51,63.81)
  TOP w0.254: PR812.1 107.81,64.51 v2(108.51,63.81)
  BOTTOM w0.254: PR811.2 108.1,64.51 108.51,64.11 v2(108.51,63.81) 108.51,63.81 PU800.3
ILMT_1V: length 4.3
  TOP w0.14: PR510.2 133.05,2.59 v3(133.64,2.59)
  TOP w0.254: v2(132.34,3.82) 132.46,3.69 PR510.2
  BOTTOM w0.254: PR512.1 132.94,2.97 132.34,3.57 v2(132.34,3.82) 132.34,4.09 132.43,4.18 PU500.3
ILMT_1VSP: length 5
  TOP w0.254: v2(240.23,112.66) 240.23,112.85 240.6,113.23 241.05,113.23 v1(241.62,112.66) v2(241.62,112.09) 241.64,112.09 PR909.2
  BOTTOM w0.254: v2(240.23,112.66) 240.25,112.68 PU900.3 ; v2(241.62,112.09) 241.63,112.09 241.75,111.97 241.75,111.97 241.9,111.82 241.9,111.82 PR910.1
IMVP_VR_ON: length 143.2
  TOP w0.14: v2(295.43,9.19) 295.27,9.35 UE3.A1 ; v3(168.8,6.31) 168.8,5.83 168.47,5.5 UZ21.1 169.15,4.98 169.93,4.2 v2(171.49,4.2)
  IN3 w0.091: v2(295.43,9.19) 294.91,9.71 294.45,9.71 294.08,9.34 294.08,3.69 v2(293.83,3.44)
  IN6 w0.099: v2(171.49,4.2) 171.9,3.79 174.13,3.79 176.35,6.01 179.17,6.01 180.14,6.98 201.85,6.98 202.85,7.98 205.46,7.98 206.08,8.6 210.52,8.6 213.66,5.46 226.53,5.46 227.71,4.27 239.55,4.27 240.33,3.49 243.01,3.49 243.71,4.19 244.84,4.19 245.64,4.99 258.08,4.99 258.85,4.23 261.99,4.23 263.54,5.77 267.01,5.77 268.49,4.3 270.32,4.3 270.87,4.85 272.47,4.85 274.1,3.22 293.7,3.22 293.83,3.35 v2(293.83,3.44)
IMVP_VR_PG: length 157.1
  TOP w0.127: v2(115.1,50.22) v3(116.16,49.17) 116.94,48.38 116.94,39.02 107.38,29.45 102.36,29.45 100.42,27.51 100.42,27.22 100.41,27.21 100.41,26.01 101.19,25.23 101.19,24.83 102.2,23.83 103.26,23.83 104.89,22.2 104.89,22.13 106.03,20.99 106.05,20.99 108.26,18.78 109.07,18.78 109.66,18.19 114.44,18.19 115.78,16.85 115.78,12.64 113.41,10.27 113.41,6.69 113.2,6.47 UH14.1
  TOP w0.254: PR1119.1 v2(112.97,112.72)
  IN6 w0.099: v2(115.1,50.22) 115.37,50.5 115.37,54.7 117.34,56.66 117.34,62.02 121.31,65.99 123.83,65.99 124.3,66.47 124.3,69.42 126.2,71.32 126.2,76.58 128.44,78.81 128.44,83.03 128.23,83.23 126.74,83.23 122.53,87.45 122.53,95.71 121.14,97.09 119.58,97.09 119.11,97.56 116.32,97.56 115.82,98.06 115.4,98.47 113.48,98.47 113.32,98.31 111.77,98.31 109.53,100.54 109.08,100.54 108.73,100.9 108.73,102.57 108.56,102.73 108.56,107.35 107.06,108.85 107.06,109.78 107.44,110.16 112.02,110.16 112.97,111.11 v2(112.97,112.72)
INTRUDER#: length 5.2
  TOP w0.089: v1(94.19,1.56) 94.19,1.67 v2(94.59,2.07) 94.5,2.15 94.5,3.32 RH531.1
  BOTTOM w0.089: UH2.BE11 94.29,3.89 94.46,3.72 94.46,2.55 94.5,2.51 94.5,2.15 v2(94.59,2.07)
INV_PWM: length 14.4
  TOP w0.127: RV109.1 52.64,28.41 v3(52.64,30.46) 52.64,31.22 53.59,32.16 59.09,32.16 v2(59.54,31.72)
  TOP w0.14: DV2.1 50.61,27.19 RV109.1
  BOTTOM w0.127: JEDP1.25 59.55,31.73 v2(59.54,31.72)
IRQ_SERIRQ: length 281.8
  TOP w0.14: v2(305.77,16.56) 305.77,16.87 305.52,17.13 UE3.A28 ; v2(65.75,10.33) 66.28,10.87 67.5,10.87 67.68,10.69 RH111.1 67.68,9.61 v1(68.2,9.09)
  IN2 w0.089: v2(92.16,6.01) 92.16,6 92.67,5.49 95.05,5.49 95.71,6.15 95.71,7.1 95.94,7.32 97.4,7.32 97.59,7.51 100.05,7.51 100.92,8.38 101.98,8.38
  IN2 w0.099: 101.98,8.38 102.15,8.38 102.72,8.95 106.81,8.95 107.05,9.19 114.68,9.19 116.43,10.93 146.56,10.93 147.02,10.46 149.6,10.46 151.79,8.27 151.79,7.32 152.55,6.56 159.34,6.56 159.86,6.04 163.33,6.04 163.65,5.71 171.98,5.71 172.29,6.02 175.3,6.02 176.27,6.99 205.51,6.99 206.58,8.06 210.12,8.06 212.71,5.46 225.38,5.46 226.8,4.04 244.62,4.04 246.08,5.5 270.84,5.5 272.71,3.63 288.7,3.63 289.43,4.35 296.12,4.35 296.28,4.51 300.75,4.51 301.61,5.37 302.86,5.37 303.78,4.45 306.89,4.45 307.54,5.1 308.12,5.1 308.28,4.94 v2(308.63,4.94)
  IN6 w0.089: 75.06,6.52 77.85,6.52 78.02,6.69 78.94,6.69 79.65,7.39 80.11,7.39 80.23,7.27 80.23,7.27 80.97,6.53 81.46,6.53 82.22,5.77 82.22,5.16 82.83,4.55 85.73,4.55 86.05,4.87 86.66,4.87 87.12,4.42 87.78,4.42 88.45,5.09 88.99,5.09 89.52,5.61 90.22,5.61 90.43,5.41 91.31,5.41 91.91,6.01 v2(92.16,6.01)
  IN6 w0.099: 75.06,6.52 72.5,6.52 71.24,7.77 71.24,8.2 70.92,8.52 69.55,8.52 67.27,10.8 66.22,10.8 v2(65.75,10.33)
  BOTTOM w0.089: v2(92.16,6.01) 92.14,5.99 UH2.BA17
  BOTTOM w0.14: v2(305.77,16.56) 305.77,16.46 305.36,16.05 305.04,16.05 304.72,15.73 304.72,14.05 304.93,13.85 307.02,13.85 307.96,12.92 307.96,11.47 307.7,11.21 307.7,8.19 307.06,7.55 307.06,6.54 307.49,6.1 307.49,5.72 308.28,4.94 v2(308.63,4.94)
ISEN1_GT: length 16.5
  TOP w0.14: v2(105.98,104.34) v1(105.98,106.45)
  TOP w0.203: PC1125.2 112.12,103.42 112.12,103.56 112.78,104.23 v2(112.78,104.24) 112.8,104.24 113.44,104.89 PU1100.9
  IN1 w0.254: v2(112.78,104.24) 113.11,104.24 113.39,104.52 113.39,105.23 113.2,105.42 112.22,105.42 111.82,105.81 109.81,105.81 108.54,104.54 106.19,104.54 v2(105.98,104.34)
  BOTTOM w0.254: PR1303.2 v2(105.98,104.34)
ISEN1_VCORE: length 22.9
  TOP w0.203: PC1124.1 118.49,101.08 v2(118.47,101.1) 118.49,101.13 118.49,101.81 118.2,102.11 PU1100.21
  IN2 w0.254: v2(126.34,99.49) 126.34,99.49 127,99.49 127.41,99.89 127.41,100.66 126.81,101.26 126.58,101.26 126.18,101.67 v2(124.08,101.67) 123.62,101.22 120.12,101.22 119.66,101.67 119.06,101.67 118.49,101.1 v2(118.47,101.1)
  BOTTOM w0.254: PR1214.2 v2(124.08,101.67) v1(123.08,100.68) 123.08,97.65 123.83,96.91 124.51,96.91 PR1216.2 ; v2(126.34,99.49) 126.62,99.49 126.9,99.77 PR1201.2
ISEN2_GT: length 12.8
  TOP w0.14: v3(107.29,104.77) 107.19,104.67 v2(107.19,104.06)
  TOP w0.203: PC1122.2 112.13,102.49 112.13,102.94 113.67,104.49 PU1100.10
  TOP w0.254: v2(111.82,101.09) 111.63,101.28 PC1122.2
  IN1 w0.254: v2(111.82,101.09) 110.14,102.78 107.72,102.78 107.19,103.31 v2(107.19,104.06)
  BOTTOM w0.254: PR1306.2 v2(107.19,104.06)
ISEN2_VCORE: length 19.9
  TOP w0.203: PU1100.22 118.6,102.23 v1(119.24,101.58) 119.24,101.3 v2(119.44,101.1)
  TOP w0.254: v2(124.11,98.12) 124.11,99.51 v2(124.14,99.54) 124.61,100.02 124.61,101.22 126.05,102.65 127.99,102.65 128.4,103.06 v2(128.4,103.3) ; PC1123.1 119.44,100.52 v2(119.44,101.1)
  IN2 w0.254: v2(119.44,101.1) 119.69,100.86 122.49,100.86 123.8,99.54 v2(124.14,99.54)
  BOTTOM w0.254: PR1212.2 124.59,99.54 v2(124.14,99.54) ; PR1217.2 124.75,97.88 124.51,98.12 v2(124.11,98.12) ; v2(128.4,103.3) 128.4,102.97 PR1205.2
ISEN3_VCORE: length 14
  TOP w0.203: PC1120.1 120.27,100.91 120.57,101.22 v1(120.57,101.52) 120.24,101.85 119.52,101.85 119,102.37 PU1100.23
  TOP w0.254: PC1120.1 120.69,100.47 120.79,100.57 123.71,100.57 v2(124.09,100.19)
  BOTTOM w0.254: PR1215.2 124.28,100.19 v2(124.09,100.19) 123.61,99.7 123.61,99.12 123.91,98.81 PR1213.2 125.45,98.18 125.93,98.18 126.37,97.74 PR1209.2
ISUMN_GT: length 40.5
  TOP w0.14: v2(119.64,85.1) 119.67,85.07 v3(119.67,84.34)
  TOP w0.254: PC1112.2 PC1125.1 ; PC1125.1 110.1,102.94 109.98,102.83 PR1302.1 PR1304.2 ; PC1125.1 PC1122.1 110.72,101.43 v2(111.11,101.04)
  IN3 w0.254: v2(119.64,85.1) 119.76,85.23 121.02,85.23 122.09,86.29 122.09,97.23 121.59,97.72 119.76,97.72 119.43,98.05 115.83,98.05 115.32,97.54 114.36,97.54 113.48,98.43 112.6,98.43 111.11,99.92 v2(111.11,101.04)
  BOTTOM w0.254: PC1133.2 110.22,103.96 PR1127.1 ; PC1133.2 PR1130.1 ; PC1133.2 PR1123.2 111.13,102 PC1119.1 v2(111.11,101.04) ; v2(119.64,85.1) 119.99,85.1 PH1102.2
ISUMN_SA: length 35
  TOP w0.254: PC1110.1 PR1117.1 124.83,108.91 v2(124.14,108.91) PR1115.2
  IN1 w0.254: v2(124.14,108.91) 123.51,108.28 123.51,107.51 121.92,105.93 121.41,105.93 120.52,105.04 120.52,103.48 120.3,103.25 120.3,102.07 120.45,101.91 120.45,96.05 120.26,95.86 120.26,95.24 119.71,94.69 119.71,94.69 117.68,92.66 115.91,92.66 v2(115.63,92.38)
  IN6 w0.254: v2(111.74,89.48) 112.46,89.48 115.36,92.38 v2(115.63,92.38)
  BOTTOM w0.14: v2(124.14,108.91) v1(124.73,108.91)
  BOTTOM w0.254: v2(111.74,89.48) 111.74,89.01 111.98,88.77 PL1306.3 ; PC1111.1 124.03,109.03 v2(124.14,108.91) ; PC1111.1 PC1136.1 ; PC1111.1 PR1120.1 ; PH1101.1 115.43,92.17 v2(115.63,92.38)
ISUMN_VCORE: length 68.6
  TOP w0.14: v2(149.07,97.96) 148.16,97.96 v3(148.03,98.09)
  TOP w0.254: PC1120.2 PC1123.2 PC1124.2 v2(118.49,98.94) 118.49,98.37 PC1126.1 PC1127.1
  IN1 w0.254: v2(126.7,101.88) 124.98,101.88 123.25,100.15 123.25,96.05 123.71,95.59 124.38,95.59 124.65,95.86 124.65,96.16 125,96.5 126.39,96.5 v2(126.71,96.18)
  IN2 w0.254: v2(118.49,98.94) 118.49,99.65 119.34,100.5 122.34,100.5 123,99.84 123,97.7 123.67,97.02 124.51,97.02 126.49,99.01 v2(126.71,99.01) 127.12,99.01 127.76,99.65 127.76,100.81 v2(126.7,101.88) 126.9,102.08 130.33,102.08 133.62,98.79 146.43,98.79 147.12,98.1 148.93,98.1 v2(149.07,97.96)
  BOTTOM w0.254: PH1103.1 149.2,100.8 148.5,100.1 148.5,98.54 v2(149.07,97.96) ; v2(126.71,96.18) 126.71,96.39 PR1211.1 ; PR1134.1 119.72,98.14 PC1135.1 118.12,98.14 PR1135.2 118.11,98.48 118.42,98.79 v2(118.49,98.94) PC1124.2 ; PR1203.1 127.19,99.01 v2(126.71,99.01) ; PR1207.1 126.99,100.97 126.7,101.27 v2(126.7,101.88)
ISUMP_GT: length 44.8
  TOP w0.14: 105.92,103.39 105.33,103.97 v3(105.33,104.64)
  TOP w0.203: v2(112.14,104.66) 112.14,105.03 112.49,105.37 112.72,105.37 113.03,105.69 PU1100.7
  TOP w0.254: v2(112.14,104.66) 112.14,104.47 PC1112.1 ; 105.92,103.39 107.89,103.39 v2(108.14,103.64)
  IN1 w0.254: v2(108.14,103.64) 109.16,104.66 v2(112.14,104.66)
  IN3 w0.254: v2(108.14,103.64) 108.4,103.64 110.56,101.48 110.56,99.98 112.45,98.08 113.33,98.08 114.26,97.15 115.43,97.15 115.98,97.7 119.28,97.7 119.69,97.29 121.29,97.29 121.62,96.96 121.62,86.46 120.89,85.73 119.8,85.73 v2(119.64,85.9)
  BOTTOM w0.254: v2(112.14,104.66) 112.04,104.56 PC1133.1 PR1123.1 ; v2(119.64,85.9) 120.16,86.43 PR1122.1
ISUMP_SA: length 35.7
  TOP w0.203: v2(121.11,106.38) 121.01,106.49 PU1100.32
  TOP w0.254: PR1309.2 126.37,105.61 v2(125.86,106.12)
  IN1 w0.254: v2(121.11,106.38) 121.11,106.19 120.17,105.25 120.17,103.63 119.94,103.4 119.94,101.92 120.09,101.77 120.09,96.2 119.9,96.01 119.9,95.39 117.55,93.04 115.76,93.04 v2(115.67,93.13)
  IN6 w0.254: v2(121.11,106.38) 120.49,107.01 120.49,108.94 121.16,109.61 124.25,109.61 125.86,108 v2(125.86,106.12)
  BOTTOM w0.14: PR1120.2 v1(122.49,111.03)
  BOTTOM w0.254: PR1120.2 PC1111.2 PC1136.2 122.49,107.98 121.11,106.6 v2(121.11,106.38) ; PR1121.2 115.6,93.05 v2(115.67,93.13)
ISUMP_VCORE: length 64.6
  TOP w0.14: v3(149.66,99.13) 149.24,98.71 v2(149.06,98.71)
  TOP w0.203: v2(117.4,101.71) 117.4,101.71 PU1100.19
  TOP w0.254: PC1127.2 119.58,97.27 118.9,96.58 v2(118.78,96.58)
  IN2 w0.254: v2(117.4,101.71) 117.87,102.18 119.66,102.18 120.26,101.58 123.18,101.58 124.03,102.43 130.48,102.43 133.77,99.14 146.62,99.14 147.24,98.52 148.87,98.52 v2(149.06,98.71)
  BOTTOM w0.254: PR1210.2 130.38,99.03 PR1202.2 130.59,100.5 PR1206.2 130.6,101.79 128.6,103.78 127.45,103.78 126.29,102.62 124.13,102.62 123.01,101.51 119.97,101.51 ; PR1136.2 149.2,99.36 149.06,99.22 v2(149.06,98.71) ; 119.97,101.51 119.76,101.71 v2(117.4,101.71) ; 119.97,101.51 119.98,101.49 119.98,99.25 120.4,98.83 120.4,97.9 PR1134.2 119.72,97.23 PC1135.2 118.78,97.02 v2(118.78,96.58)
JTAG_CLK: length 30.3
  TOP w0.14: v2(295.18,17.17) 294.98,17.38 UE3.B56 ; RP20.3 310.71,29.13 310.47,29.37 310.47,29.69 v2(309.87,30.29)
  IN4 w0.091: v2(309.87,30.29) 309.69,30.46 307.18,30.46 305.86,29.14 302.74,29.14 301.95,29.94 299.88,29.94 297.57,27.62 297.57,25.72 295.91,24.06 295.91,20.58 294.49,19.16 294.49,17.29 294.61,17.17 v2(295.18,17.17)
  BOTTOM w0.14: v2(309.87,30.29) 309.61,30.54 JDEG1.4
JTAG_RST#: length 9.7
  TOP w0.14: v1(296.88,27.69) 297.1,27.47 RE59.2 297.1,26.26 296.95,26.11 JTAG1.1 296.95,24.98 297.1,24.82 RE61.1 CE44.1 297.1,22.96 v2(296.5,22.35) ; UE3.B47 297.02,19.55 v2(296.83,19.35)
  BOTTOM w0.14: v2(296.5,22.35) 296.5,19.67 v2(296.83,19.35)
JTAG_TDI: length 33.8
  TOP w0.14: RP20.1 311.71,29.45 v2(310.99,30.17) 310.99,30.36 v3(311.44,30.82) ; v2(292.33,18.3) 292.5,18.13 UE3.A51
  IN6 w0.099: v2(310.99,30.17) 312.22,28.93 312.22,24.31 309.93,22.02 308.79,22.02 307.93,21.16 304.38,21.16 303.58,20.36 295.14,20.36 293.08,18.3 v2(292.33,18.3)
  BOTTOM w0.14: JDEG1.2 310.61,30.54 v2(310.99,30.17)
JTAG_TDO: length 28.9
  TOP w0.14: v3(308.26,30.69) 309.42,29.52 v2(309.92,29.52) 310.21,29.23 RP20.4 ; v2(295.86,17.16) 295.32,17.7 294.84,17.7 294.67,17.88 UE3.B55
  IN4 w0.091: v2(309.92,29.52) 308.14,27.75 305.77,27.75 303.42,25.4 303.42,21.49 302.89,20.95 302.27,20.95 300.98,19.66 300.98,18.5 300.31,17.83 296.53,17.83 v2(295.86,17.16)
  BOTTOM w0.14: v2(309.92,29.52) 309.11,30.33 JDEG1.5
JTAG_TMS: length 42.8
  TOP w0.14: v2(310.99,29.55) 311.21,29.32 RP20.2 ; UE3.A53 293.25,17.13 293.05,17.32 292.48,17.32 292.22,17.05 v2(292.22,16.86) ; v2(314.82,28.05) 314.82,27.66 v3(315.85,26.63)
  IN3 w0.091: v2(310.99,29.55) 311.42,29.12 313.75,29.12 v2(314.82,28.05)
  IN6 w0.099: v2(292.22,16.86) 292.61,16.47 293.7,16.47 293.89,16.65 296.02,16.65 296.93,17.56 301.42,17.56 301.9,18.04 303.63,18.04 304.54,18.96 312.71,18.96 315.15,21.4 315.15,27.72 v2(314.82,28.05)
  BOTTOM w0.14: JDEG1.3 310.11,30.76 310.31,30.57 310.31,30.22 v2(310.99,29.55)
KB_DET#: length 124.6
  TOP w0.14: RH557.1 59.12,6.87 58.68,7.31 58.68,7.74 v2(58.98,8.04) ; v2(161.04,11.15) 161.05,11.15 162.36,9.84 162.78,9.84 163.5,9.12 v3(163.5,7.63) 163.5,7.15 162.31,5.95 v2(162.31,4.33)
  IN5 w0.089: 90.49,1.41 89.97,1.93 89.97,3.26 89.72,3.51 v2(89.31,3.51) 88.87,3.95 87,3.95 86.36,4.59 82.48,4.59 82.29,4.78 79.7,4.78 79.51,4.59 76.94,4.59 76.44,5.09 76.43,5.09 75.89,5.63 75.06,5.63
  IN5 w0.099: v2(58.98,8.04) 58.71,7.78 58.71,7.31 59.35,6.67 64.87,6.67 65.67,5.87 69.64,5.87 69.88,5.63 75.06,5.63 ; v2(162.31,4.33) 159.69,4.33 159.21,4.81 147.39,4.81 144.69,7.52 138.57,7.52 137.79,6.74 136.24,6.74 135.82,7.16 122.05,7.16 116.43,1.54 114.07,1.54 109.5,1.54 109.14,1.9 106.78,1.9 106.1,1.22 90.68,1.22 90.49,1.41
  BOTTOM w0.089: v2(89.31,3.51) 89.31,3.88 89.13,4.06 UH2.BD22
  BOTTOM w0.14: v2(161.04,11.15) 161.27,10.92 JKB.5
LAN_WAKE#: length 248.9
  TOP w0.14: v1(308.98,4.1) 309.46,4.58 v2(309.46,5) ; UE3.B27 303.62,15.87 303,15.87 v2(302.87,15.74)
  IN2 w0.089: v2(94.1,3.55) 94.62,3.03 94.89,3.03 95.2,2.72 99.01,2.72 99.75,3.46 99.75,4.66 99.98,4.89 100.61,4.89 100.99,5.27 100.99,5.55 101.22,5.77 101.98,5.77
  IN2 w0.099: 101.98,5.77 104.65,5.77 105.02,5.4 107.09,5.4 107.77,4.72 112.81,4.72 112.93,4.83 v2(113.09,4.83) 113.85,4.83 115.38,6.37 116.27,6.37 116.77,6.87 118.05,6.87 119.35,8.17 136.1,8.17 136.25,8.32 145.06,8.32 147.64,5.74 149.28,5.74 150.48,4.54 156.16,4.54 156.66,5.04 159.16,5.04 159.41,4.79 162.67,4.79 163.2,4.26 169.71,4.26 171.2,2.77 183.79,2.77 185.23,4.21 v2(185.23,4.59)
  IN3 w0.091: v2(309.46,5) 309.46,5.42 309.95,5.9 309.95,8.79 308.49,10.24 308.49,14.23 308.18,14.54 304.17,14.54 302.97,15.74 v2(302.87,15.74)
  IN5 w0.099: v2(309.46,5) 308.41,3.95 300.99,3.95 300.67,4.27 297.52,4.27 297.28,4.51 295.63,4.51 295.62,4.5 291.18,4.5 290.94,4.27 285.51,4.27 285.25,4.52 285.19,4.52 285.04,4.67 282.61,4.67 281.83,5.45 274.72,5.45 272.84,7.33 262.81,7.33 262.56,7.57 236.14,7.57 234.93,6.36 227.45,6.36 226.16,7.66 219.28,7.66 219.07,7.44 211.35,7.44 210.26,8.53 206.53,8.53 205.89,7.89 203.45,7.89 200.55,4.99 185.64,4.99 v2(185.23,4.59)
  BOTTOM w0.089: UH2.BD11 94.04,4.38 94.04,4.01 94.1,3.95 v2(94.1,3.55)
  BOTTOM w0.14: RH545.1 112.95,4.97 v2(113.09,4.83)
LCD_DBC: length 5.9
  TOP w0.089: v3(80.55,20.3) 80.87,20.3 81.2,19.97 81.97,19.97 83.09,18.85 v2(83.09,18.58) 82.82,18.31 RH527.1 RH528.1
  BOTTOM w0.089: UH2.U35 v2(83.09,18.58)
LCD_TST: length 270
  TOP w0.127: v2(68.36,15.95) 67.78,16.53 67.78,17.3 66.46,18.62 66.46,19.89 v3(66.76,20.18) 66.96,20.38 66.96,21.59 66.18,22.36 63.5,22.36 62.23,23.63 62.23,27.44 62.73,27.94 63.69,27.94 63.96,28.22 RV110.1
  TOP w0.14: UE3.A38 300.27,21.3 v2(300.49,21.52) ; v2(300.99,24.85) RE32.2
  IN1 w0.099: v2(68.36,15.95) 68.64,15.67 70.89,15.67 71.18,15.96 74.6,15.96 76.22,14.34 77.08,14.34 78.49,15.75 83.46,15.75 83.64,15.93 85.03,15.93 85.56,16.47 91.25,16.47 92.41,15.31 95.52,15.31 96.51,14.32 96.51,13.52 96.78,13.25 98.75,13.25 99,13.49 101.97,13.49 103.16,14.69 104.74,14.69 105.35,15.3 128.64,15.3 130.83,13.11 149.9,13.11 150.05,12.96 154.26,12.96 154.94,12.27 177.76,12.27 178.88,11.15 188.15,11.15 188.4,10.9 196.76,10.9 196.86,11.01 200.8,11.01 201.79,12 213.78,12 215.51,10.27 233.5,10.27 233.71,10.48 248.19,10.48 249.04,9.64 261.64,9.64 264.49,12.48 266.41,12.48 270.94,17.01 277.85,17.01 278.95,18.11 280.29,18.11 281.24,19.06 283.7,19.06 284.94,20.31 289.6,20.31 291.94,22.64 295.5,22.64 297.16,20.99 299.96,20.99 v2(300.49,21.52)
  IN4 w0.091: v2(300.99,24.85) 301.18,24.66 301.18,22.04 300.65,21.52 v2(300.49,21.52)
LCD_VCC_TEST_EN: length 298
  TOP w0.14: DV7.2 38.29,30.83 38.73,31.27 38.73,31.64 38.4,31.97 38.4,32.98 39.26,33.84 40.96,33.84 41.26,33.54 v2(41.26,33.23) ; v1(300.91,22.34) 300.72,22.14 v2(300.38,22.14) 300.27,22.14 299.77,21.65 UE3.A39
  IN2 w0.099: v2(41.26,33.23) 41.67,32.82 45.55,32.82 47.64,30.74 50.02,30.74 50.79,31.5 52.68,31.5 53.7,30.47 70.01,30.47 70.98,29.5 73.67,29.5 74.41,30.23 77.47,30.23 78.42,31.19 84.68,31.19 88.05,34.55 96.55,34.55 99.62,37.62 110.92,37.62 115.56,32.98 139.69,32.98 143.74,28.94 152.15,28.94 152.64,28.44 152.64,27.29 153.2,26.74 154.02,26.74 155.7,25.06 157.03,25.06 157.38,24.72 157.38,19.9 158.83,18.45 172.93,18.45 173.16,18.23 175.51,18.23 175.97,17.77 253.9,17.77 254.08,17.59 259.56,17.59 261.05,19.07 264.32,19.07 264.53,19.28 267.36,19.28 268.41,20.34 273.64,20.34 274.19,19.79 278.32,19.79 278.93,20.4 280.17,20.4 281.57,21.8 290.08,21.8 290.88,22.6 290.88,22.78 293.51,25.41 294.02,25.41 295.73,27.11 296.98,27.11 297.73,27.86 299.01,27.86 299.19,27.68 299.19,27.02 299.46,26.75 300.41,26.75 v2(300.76,27.11)
  IN4 w0.091: v2(300.38,22.14) 300.74,22.14 300.99,22.39 300.99,23 300.56,23.43 300.56,26.07 300.76,26.27 v2(300.76,27.11)
LCD_VDD: length 1.1
  TOP w0.14: RV1104.2 230.18,41.39 T208.1
LDO_EN: length 14.7
  TOP w0.14: PD203.1 v1(33.21,27.54)
  TOP w0.508: PD203.1 32.89,26.11 PD202.1 30.35,24.27 29.78,23.69 PR272.2 29.22,23.48 28.72,22.98 28.15,22.98 27.67,22.5 27.67,21.58 27.22,21.13 27.22,19.02 PC219.1 27.93,19.3 27.93,19.88 28.39,20.34 PU203.1
LG_3V: length 2.7
  IN1 w1.016: 337.95,21.41 338.2,21.66 340.55,21.66
  vias: v1(338.25,20.15) v2(337.5,20.71) v2(338.2,20.71) v2(341.69,21.79) v2(342.2,21.47)
LG_5V: length 11
  IN1 w1.016: 332.61,18.11 333.57,19.06 340.38,19.06
  BOTTOM w0.14: v1(344.92,19.07) 344.77,19.22 v2(342.1,19.22)
  vias: v2(331.98,15.25) v2(332.61,15.25) v2(341.5,19.22)
LID_CL_SIO#: length 5.9
  TOP w0.14: v1(309.13,11.88) 309.12,11.9 RE41.2 RE45.2 CE31.1 305.86,12.37 305.86,13.31 305.54,13.63 UE3.A21
LID_SW_IN#: length 133.5
  TOP w0.14: UE2.3 349.18,120.73 348.34,119.89 348.34,118.64 348.03,118.33 RE15.2 348.04,117.6 CE16.1 347.97,116.73 347.66,117.04 v2(347.28,117.04) ; v3(310.5,10.69) 310.2,10.99 v2(309.75,10.99) 309.29,10.53 307.66,10.53 RE45.1
  IN6 w0.099: v2(347.28,117.04) 347.28,117.03 346.46,117.03 343.9,114.47 343.9,93.92 335.58,85.6 335.58,82.56 333.96,80.94 333.96,65.19 334.39,64.76 334.39,62.87 333,61.48 333,60.51 333.35,60.16 333.35,55.25 331.29,53.2 331.29,51.63 327.41,47.75 327.41,45.86 325.34,43.79 325.34,39.5 323.8,37.96 323.8,35.83 323.25,35.28 323.25,33.85 321.64,32.24 321.64,30.09 318.2,26.66 318.2,25.2 317.71,24.72 317.71,20.53 313.76,16.58 313.76,13.41 311.35,10.99 v2(309.75,10.99)
LINE1-VREFO: length 7.1
  TOP w0.406: RA27.1 12.59,41.49 12.76,41.66 DA14.2 v2(13.35,42.36) DA7.2
  IN3 w0.508: v2(10.79,43.5) 12.21,43.5 v2(13.35,42.36)
  BOTTOM w0.203: UA1.40 10.44,42.35 10.27,42.52 10.27,43.03 10.75,43.5 v2(10.79,43.5)
LINE1_L: length 3.9
  TOP w0.508: v2(7.88,44.1) 8.03,43.95 8.03,43.41 8.18,43.25 CA45.1
  BOTTOM w0.203: v2(7.88,44.1) 8.03,43.95 v1(8.03,43.6) 8.03,43.47 8.44,43.06 UA1.35
LINE1_L_C: length 2.1
  TOP w0.102: v1(8.78,40.93) 8.78,41.6 CA119.2
  TOP w0.508: RA31.1 9.54,41.47 CA119.2
LINE1_R: length 4.7
  TOP w0.508: CA119.1 7.27,41.92 v1(6.93,42.26) 6.93,42.98 v2(7.33,43.38)
  BOTTOM w0.203: v2(7.33,43.38) 7.69,43.38 8.04,43.03 UA1.34
LINE1_R_C: length 1.2
  TOP w0.508: RA30.1 9.94,43.27 9.48,42.81 CA45.2
LPC_AD0: length 270.9
  TOP w0.14: v2(312.36,4.46) v3(312.36,5.08) ; v2(305.28,18.54) 304.87,18.13 UE3.A30
  IN1 w0.076: v2(89.71,8.33) 89.74,8.35 90.99,8.35 91.76,9.12 93.76,9.12 94.85,10.21 96.45,10.21 96.85,9.81 99.76,9.81 100.28,10.33 101.98,10.33
  IN1 w0.099: v2(312.36,4.46) 312.35,4.45 311.18,4.45 310.8,4.08 307.44,4.08 307,4.52 303.56,4.52 303.1,4.99 301,4.99 300.82,4.81 273.05,4.81 272.49,5.37 267.76,5.37 267.06,6.07 262.84,6.07 262.37,5.6 258.7,5.6 257.98,4.88 250.95,4.88 250.17,5.66 239.86,5.66 238.72,4.52 227.32,4.52 226.28,5.56 212.15,5.56 210,7.72 206.65,7.72 204.58,5.64 181.37,5.64 181.21,5.81 179.34,5.81 179.13,6.02 175.81,6.02 175.32,5.53 173.04,5.53 172.66,5.91 172.34,5.91 171.96,5.53 163.64,5.53 162.82,6.36 157.12,6.36 156.74,6.74 147.71,6.74 145.07,9.38 134.48,9.38 133.98,8.87 116.08,8.87 115.16,9.8 113.82,9.8 113.21,10.4 106.53,10.4 106.46,10.33 101.98,10.33
  IN3 w0.091: v2(305.28,18.54) 305.62,18.88 306.06,18.88 306.51,19.33 307.67,19.33 309.49,17.51 310.57,17.51 310.96,17.12 310.96,15.09 311.52,14.53 311.52,11.86 311.6,11.79 311.6,7.49 311.97,7.11 311.97,4.84 v2(312.36,4.46)
  BOTTOM w0.089: v2(89.71,8.33) 89.24,8.33 UH2.AT22
  BOTTOM w0.14: JLPDE1.3 299.7,30.76 301,29.45 301,28.71 301.48,28.24 301.48,27.97 302.11,27.34 302.11,27.11 302.54,26.68 302.82,26.68 303.81,25.69 305.12,25.69 305.72,25.09 305.72,23.57 306.39,22.91 306.39,19.4 305.52,18.54 v2(305.28,18.54)
LPC_AD1: length 274.9
  TOP w0.14: v2(302.08,17.64) 302.44,17.99 302.58,17.99 302.96,18.38 UE3.B32 ; v2(311.07,3.58) 310.55,4.1 v3(310.55,4.44)
  IN1 w0.076: 101.98,9.85 101.69,9.85 101.67,9.86 100.23,9.86 100.01,9.64 96.78,9.64 96.38,10.04 94.92,10.04 93.83,8.95 92.69,8.95 92.11,8.38 91.65,8.38 90.89,7.62 89.86,7.62 v2(89.72,7.76)
  IN1 w0.099: 101.98,9.85 106.29,9.85 106.7,9.44 107.45,9.44 107.93,9.92 113.01,9.92 113.62,9.32 114.96,9.32 116.01,8.26 134.05,8.26 134.68,8.9 144.52,8.9 147.16,6.26 155.86,6.26 156.17,5.94 156.86,5.94 156.92,5.88 162.34,5.88 163.39,4.83 171.2,4.83 171.43,4.61 175.11,4.61 175.2,4.69 176.2,4.69 176.59,5.09 177.17,5.09 177.48,4.77 181.5,4.77 181.9,5.16 204.95,5.16 207.03,7.24 209.59,7.24 212.2,4.62 226.36,4.62 227.04,3.95 238.82,3.95 240.06,5.18 249.97,5.18 250.75,4.4 258.21,4.4 258.85,5.04 262.49,5.04 262.86,5.41 266.66,5.41 268.49,3.58 285.33,3.58 286.08,4.33 300.68,4.33 300.97,4.04 306.8,4.04 307.26,3.58 v2(311.07,3.58)
  IN3 w0.091: v2(302.08,17.64) 302.11,17.64 302.73,17.01 303.09,17.01 304.17,15.93 306.81,15.93 306.99,15.76 308.96,15.76 310.58,14.14 310.58,11.47 310.63,11.42 310.63,7.11 311.03,6.71 311.03,3.63 v2(311.07,3.58)
  BOTTOM w0.089: v2(89.72,7.76) 89.43,7.76 UH2.AV22
  BOTTOM w0.14: v2(302.08,17.64) 302.6,17.12 303.16,17.12 305.41,19.36 305.54,19.36 305.84,19.67 305.84,21.09 304.6,22.34 304.6,22.67 303.61,23.66 303.61,25.16 302.61,26.16 302.32,26.16 300.42,28.07 300.42,29.3 299.2,30.52 JLPDE1.4
LPC_AD2: length 273.9
  TOP w0.089: v2(90.75,8.71) 91.02,8.98 v3(91.02,9.44)
  TOP w0.14: v2(305.31,19.88) 305.31,19.2 304.74,18.63 UE3.A31
  IN1 w0.076: 101.98,10.81 101.58,10.81 101.34,10.57 100.29,10.57 99.73,10.01 97.71,10.01 97.15,10.56 95.09,10.56 94.97,10.45 94.73,10.45 94.16,9.89 92.29,9.89 91.12,8.71 v2(90.75,8.71)
  IN1 w0.099: v2(313.32,4.85) 312.23,5.94 307.95,5.94 307.04,5.02 304.56,5.02 304.25,5.33 303.73,5.33 303.59,5.47 300.8,5.47 300.62,5.29 285.75,5.29 284.81,6.23 277.26,6.23 276.87,5.85 267.96,5.85 267.26,6.55 262.6,6.55 262.13,6.08 258.5,6.08 257.83,5.41 251.1,5.41 249.78,6.73 246.52,6.73 246.16,6.36 243.34,6.36 242.95,6.75 240.02,6.75 238.66,5.39 227.28,5.39 226.51,6.17 212.22,6.17 210.2,8.2 206.28,8.2 204.93,6.85 175.85,6.85 175.21,6.21 173.12,6.21 172.37,6.95 169.93,6.95 169.2,6.23 165.42,6.23 164.81,6.84 161.7,6.84 160.95,7.59 157.38,7.59 157,7.22 154.94,7.22 154.53,7.63 151.8,7.63 151.6,7.42 148.48,7.42 145.87,10.03 134.46,10.03 133.78,9.35 116.29,9.35 114.5,11.14 106.05,11.14 105.72,10.81 101.98,10.81
  IN3 w0.091: v2(313.32,4.85) 312.93,5.24 312.93,18.27 312.07,19.14 309.75,19.14 308.61,20.27 305.7,20.27 v2(305.31,19.88)
  BOTTOM w0.089: v2(90.75,8.71) 90.71,8.71 90.29,8.29 UH2.AT19
  BOTTOM w0.14: JLPDE1.5 298.7,30.44 298.96,30.18 298.96,30.02 299.38,29.6 299.38,29.09 299.47,29.01 299.47,27.11 299.68,26.89 300.34,26.89 301.6,25.64 302.39,25.64 303.09,24.94 303.09,23.44 304.06,22.46 304.06,22.11 305.31,20.87 v2(305.31,19.88)
LPC_AD3: length 283.3
  TOP w0.14: UE3.B33 303.24,18.88 302.97,19.15 v2(302.97,19.29) ; v2(313.06,3.65) v3(314.58,3.65)
  IN1 w0.076: v2(91.26,1.93) 91.83,2.5 91.83,2.76 91.85,2.78 93.14,4.07 94.43,4.07 94.78,3.72 94.78,3.37 95.4,2.75 95.48,2.75 95.67,2.56 99,2.56 100.59,4.15 101.07,4.15 101.14,4.22 101.14,4.86 100.94,5.06 100.94,7.84 101.98,8.88
  IN1 w0.099: 101.98,8.88 102.46,9.36 106.09,9.36 106.5,8.96 107.65,8.96 108.13,9.44 112.56,9.44 113.16,8.84 114.76,8.84 115.83,7.76 118.92,7.76 119.38,7.3 133.76,7.3 134.88,8.42 144.32,8.42 147.45,5.29 149.77,5.29 150,5.06 151.5,5.06 151.84,5.41 156.03,5.41 156.08,5.36 161.86,5.36 163.08,4.13 170.89,4.13 171.48,3.54 188.22,3.54 188.73,3.03 205.24,3.03 206.47,1.8 212.49,1.8 214.7,4.02 226.11,4.02 226.8,3.34 238.89,3.34 239.5,3.95 245.38,3.95 246.06,4.62 249.85,4.62 250.56,3.92 262.14,3.92 263.15,4.93 266.36,4.93 268.19,3.1 285.9,3.1 286.65,3.85 300.48,3.85 300.77,3.56 302.78,3.56 303.25,3.1 311.7,3.1 311.76,3.16 311.77,3.16 312.06,3.46 312.06,3.46 312.26,3.65 v2(313.06,3.65)
  IN3 w0.091: v2(302.97,19.29) 305.38,19.29 305.58,19.49 306,19.49 306.31,19.8 308.41,19.8 309.55,18.66 311.87,18.66 312.45,18.08 312.45,12.48 312.08,12.1 312.08,7.71 312.45,7.33 312.45,5.05 313.06,4.45 v2(313.06,3.65)
  BOTTOM w0.089: UH2.BD16 92.02,4.54 91.7,4.22 91.7,2.91 91.64,2.86 91.64,2.28 91.29,1.93 v2(91.26,1.93)
  BOTTOM w0.14: v2(302.97,19.29) 302.97,20.38 303.45,20.86 303.45,22.34 301.44,24.35 301.44,25.04 300.12,26.36 299.48,26.36 298.93,26.91 298.93,28.6 298.43,29.1 298.43,30.18 298.2,30.41 JLPDE1.6
LPC_FRAME#: length 278
  TOP w0.14: v2(312.42,3.14) 312.64,2.93 v3(312.94,2.93) ; UE3.B31 303.11,17.88 302.88,17.65 v2(302.88,17.64)
  IN1 w0.076: v2(91.81,1.93) 92,2.12 92,2.7 93.21,3.91 94.36,3.91 94.62,3.65 94.62,3.3 95.33,2.58 95.42,2.58 95.6,2.4 99.07,2.4 100.64,3.97 101.58,3.97 101.86,4.26 101.86,8.09 101.98,8.2
  IN1 w0.099: 101.98,8.2 102.66,8.88 105.23,8.88 106.2,7.92 109.74,7.92 110.79,8.96 112.36,8.96 114.37,6.95 119,6.95 119.41,6.55 133.69,6.55 134.96,7.82 144.24,7.82 147.25,4.81 149.4,4.81 149.66,4.56 151.72,4.56 152.09,4.93 155.83,4.93 155.88,4.88 160.46,4.88 162.59,2.75 170.13,2.75 170.37,2.99 188.09,2.99 188.53,2.55 205.04,2.55 206.27,1.32 212.69,1.32 214.9,3.54 225.73,3.54 226.41,2.86 239.09,2.86 239.7,3.47 245.58,3.47 246.25,4.14 249.49,4.14 250.19,3.44 262.34,3.44 263.31,4.4 266.21,4.4 267.99,2.62 311.9,2.62 v2(312.42,3.14)
  IN3 w0.091: v2(302.88,17.64) 302.88,17.54 302.93,17.49 303.28,17.49 303.53,17.24 306.98,17.24 307.94,16.28 309.11,16.28 311.05,14.33 311.05,11.67 311.11,11.61 311.11,7.3 311.5,6.91 311.5,4.62 312.42,3.7 v2(312.42,3.14)
  BOTTOM w0.089: UH2.BE16 91.88,3.98 91.88,2.84 91.82,2.78 91.82,1.94 v2(91.81,1.93)
  BOTTOM w0.14: JLPDE1.7 297.7,30.43 297.89,30.23 297.89,27.77 297.71,27.59 297.71,27.03 298.22,26.53 298.58,26.53 299.26,25.84 299.9,25.84 300.57,25.18 300.57,24.26 302.01,22.82 302.01,21.4 302.38,21.03 302.38,19.27 302.88,18.77 v2(302.88,17.64)
LX1_NVVDD: length 10.1
  TOP w0.14: v2(166.75,112.4) v1(167.56,112.4)
  IN6 w0.762: 165.99,111.58 165.71,111.58 164.75,110.61 164.75,105.71 166.69,103.77
  vias: v2(166.37,111.96) v2(167.41,103.76) v2(168,103.76)
LX1_NVVDDS: length 10.4
  TOP w0.14: v2(192.36,109.58) v1(191.73,109.58)
  IN4 w0.762: 191.58,110.75 191.19,110.75 190.42,111.51 189.55,111.51 189.1,111.07 184.9,111.07 184.41,111.57 184.41,112.56 183.73,113.23
  vias: v2(182.75,114.12) v2(183.33,113.8) v2(192.36,110.18)
LX2_NVVDD:
  vias: v1(170.46,110.27)
LX_0.95V: length 0.9
  TOP w0.14: v1(110.92,60) 110.62,60.31 v2(110.62,60.78)
  vias: v2(110.62,61.41)
LX_1.8V:
  vias: v1(246.13,104.95) v2(245.68,103.83) v2(246.13,103.39) v2(246.19,104.21) v2(246.57,103.77)
LX_1V: length 1.5
  TOP w0.254: PC505.2 v1(130.61,5.03) v2(130.61,4.52)
LX_1VSP:
  vias: v1(237.62,115.27) v2(234.06,115.39) v2(234.06,114.75) v2(238,114.63) v2(238.63,114.63)
LX_3V: length 0.7
  TOP w0.203: 344.4,21.79 344.4,22.49
  vias: v2(338.38,28.38) v2(339.01,28.38) v2(344.36,23.53) v2(344.36,22.93) v3(338.84,29.66)
LX_5V: length 20.7
  TOP w0.14: v3(341.17,9.37) 339.87,10.68 PR414.1
  IN1 w1.016: 348.43,16.46 349.31,15.57 349.31,11.38 345.76,7.82 338.96,7.82 338.27,8.52
  vias: v2(336.61,9.22) v2(337.25,9.22) v2(346.65,17.47) v2(347.03,17.03)
M_CLK_DDR0: length 55.4
  IN6 w0.079: v2(156.29,53.28) 156.29,53.25 156.12,53.09 155.76,53.09 155.61,52.94 155.61,51.89 156.09,51.41 156.09,50.58 155.89,50.38 155.89,49.92 155.82,49.85 155.68,49.85 155.47,49.65 155.47,49.35 155.68,49.15 155.84,49.15 155.95,49.03 155.95,48.87 155.84,48.75 155.68,48.75 155.47,48.55 155.47,48.26 155.68,48.05 155.84,48.05 155.95,47.94 155.95,47.77 155.84,47.66 155.68,47.66 155.47,47.45 155.47,47.16 155.68,46.95 155.72,46.95 155.79,46.89 155.79,46.72 154.66,45.59 154.66,43.55 144.5,33.4 144.5,33.16 144.64,33.03 144.64,32.86 144.52,32.75 144.36,32.75 144.23,32.88 143.99,32.88 143.73,32.62 143.73,32.38 144.12,31.99 144.12,31.83 144,31.71 143.84,31.71 143.45,32.1 143.21,32.1 142.95,31.85 142.95,31.61 143.34,31.21 143.34,31.03 143.22,30.91 143.04,30.91 142.79,31.15 142.5,31.15 142.29,30.95 142.29,30.66 142.54,30.4 142.54,30.3 142.29,30.05 142.29,27.28 141.88,26.87 141.88,24.51 141.69,24.33 141.69,23.28 141.89,23.08 142.13,23.08 142.3,22.91 v2(142.3,22.89)
  BOTTOM w0.076: v2(156.29,53.28) 156.45,53.12 157.22,53.12 158.93,54.83 158.93,57.05 159.22,57.33 159.22,59.45 159.33,59.56 159.33,59.9 159.25,59.98 159.11,59.98 159.03,59.91 UH1.AG1
  BOTTOM w0.102: v2(142.3,22.89) 142.11,23.08 141.88,23.08 141.53,23.43 141.53,25.34 141.39,25.48 JDIMM1.137
M_CLK_DDR1: length 57.9
  IN6 w0.079: v2(142.3,20.35) 142.5,20.15 142.93,20.15 143.06,20.28 143.06,24.63 142.95,24.73 142.75,24.73 142.53,24.95 142.53,25.27 142.75,25.49 143.92,25.49 144.04,25.61 144.04,25.8 143.92,25.93 142.69,25.93 142.52,26.1 142.52,26.46 142.69,26.63 143.92,26.63 144.04,26.76 144.04,27.03 143.92,27.16 143.47,27.16 143.25,27.38 143.25,27.73 143.47,27.95 143.9,27.95 144.03,28.08 144.03,28.28 143.9,28.41 143.49,28.41 143.25,28.64 143.25,30.04 145.28,32.06 145.28,33.27 155.3,43.29 155.3,45.33 156.59,46.62 156.59,50.06 157.03,50.5 157.03,53.43 156.68,53.77 156.68,54.25 156.31,54.62 156.31,55.59 156.8,56.08 156.8,57.41 156.71,57.5 156.33,57.5 v2(156.14,57.31)
  BOTTOM w0.089: UH1.AK2 156.52,60.27 156.11,59.86 156.11,59.55 155.39,58.84 155.39,57.78 155.62,57.55 155.9,57.55 v2(156.14,57.31)
  BOTTOM w0.14: v2(142.3,20.35) 142.13,20.18 141.87,20.18 141.62,19.92 141.62,19.34 141.79,19.17 141.79,19.11 141.63,18.94 JDIMM1.138
M_CLK_DDR2: length 98.2
  IN3 w0.081: v2(218.15,22.89) 218.15,22.97 218.01,23.11 217.79,23.11 217.58,23.33 217.58,29.76 210.17,37.18 195.61,37.18 193.95,38.84 167.54,38.84 157.65,48.74 157.65,51.8 157.37,52.08 157.37,52.42 157.65,52.7 157.65,52.96 156.85,53.76 156.85,59.66 156.44,60.06 156.44,61.02 157.26,61.85 157.26,62.15 156.92,62.5 156.82,62.5 156.27,63.04 155.53,63.04 155.23,63.33 155.23,64.26 154.86,64.63 v2(154.85,64.63)
  BOTTOM w0.076: UH1.AM9 155.17,64.95 v2(154.85,64.63)
  BOTTOM w0.14: JDIMM2.137 217.69,25.55 217.39,25.26 217.39,23.35 217.71,23.04 218,23.04 v2(218.15,22.89)
M_CLK_DDR3: length 99.2
  IN3 w0.081: v2(218.15,20.35) 218.15,20.24 218.31,20.07 218.5,20.07 218.76,20.33 218.76,24.91 218.24,25.43 218.24,30.16 210.57,37.83 195.88,37.83 194.22,39.49 167.81,39.49 158.31,49 158.31,50.89 158.09,51.1 158.09,53.11 157.9,53.31 157.9,59.25 157.32,59.83 157.32,60.91 157.66,61.26 157.66,62.63 156.91,63.38 156.41,63.38 156.17,63.62 156.17,64.18 156.09,64.26 155.78,64.26 155.69,64.17 155.69,64.05 v2(155.76,63.97)
  BOTTOM w0.076: UH1.AM7 v2(155.76,63.97)
  BOTTOM w0.14: v2(218.15,20.35) 217.67,19.87 217.67,19.52 217.93,19.26 JDIMM2.138
M_CLK_DDR#0: length 55.4
  IN6 w0.079: v2(142.3,23.52) 142.02,23.24 141.95,23.24 141.85,23.34 141.85,24.26 142.03,24.45 142.03,26.8 142.44,27.21 142.44,29.98 142.7,30.23 142.7,30.47 142.44,30.72 142.44,30.88 142.56,31 142.72,31 142.97,30.75 143.28,30.75 143.5,30.97 143.5,31.28 143.11,31.67 143.11,31.78 143.27,31.95 143.38,31.95 143.77,31.56 144.06,31.56 144.27,31.77 144.27,32.06 143.88,32.45 143.88,32.56 144.05,32.73 144.16,32.73 144.3,32.59 144.59,32.59 144.79,32.8 144.79,33.09 144.66,33.22 144.66,33.34 154.81,43.49 154.81,45.53 155.94,46.66 155.94,46.95 155.78,47.11 155.74,47.11 155.63,47.22 155.63,47.39 155.74,47.5 155.9,47.5 156.11,47.71 156.11,48 155.9,48.21 155.74,48.21 155.63,48.32 155.63,48.48 155.74,48.6 155.9,48.6 156.11,48.81 156.11,49.1 155.9,49.3 155.74,49.3 155.63,49.42 155.63,49.58 155.74,49.7 155.89,49.7 156.05,49.86 156.05,50.31 156.25,50.52 156.25,51.47 155.77,51.95 155.77,52.88 155.82,52.93 156.16,52.93 156.16,52.93 156.23,52.93 156.29,52.87 v2(156.29,52.65)
  BOTTOM w0.076: UH1.AG2 159.03,60.29 159.12,60.2 159.34,60.2 159.55,59.99 159.55,59.47 159.46,59.39 159.46,57.23 159.17,56.95 159.17,54.73 157.32,52.88 156.52,52.88 v2(156.29,52.65)
  BOTTOM w0.102: v2(142.3,23.52) 142.09,23.31 141.98,23.31 141.76,23.53 141.76,25.32 141.89,25.45 141.89,26.35 JDIMM1.139
M_CLK_DDR#1: length 57.8
  IN6 w0.079: v2(142.3,19.71) 142.3,19.82 142.47,19.99 142.49,19.99 142.5,20 142.99,20 143.21,20.21 143.21,24.69 143.02,24.89 142.81,24.89 142.69,25.02 142.69,25.2 142.81,25.33 143.98,25.33 144.2,25.55 144.2,25.87 143.98,26.08 142.75,26.08 142.68,26.16 142.68,26.4 142.75,26.48 143.98,26.48 144.2,26.7 144.2,27.1 143.98,27.31 143.54,27.31 143.41,27.44 143.41,27.67 143.54,27.8 143.97,27.8 144.19,28.01 144.19,28.34 143.97,28.56 143.55,28.56 143.41,28.7 143.41,29.97 145.43,32 145.43,33.2 155.45,43.22 155.45,45.26 156.75,46.56 156.75,50 157.19,50.44 157.19,53.49 156.84,53.84 156.84,54.31 156.47,54.69 156.47,55.53 156.96,56.02 156.96,57.47 156.77,57.66 156.23,57.66 156.14,57.75 v2(156.14,57.95)
  BOTTOM w0.089: v2(156.14,57.95) 156,57.81 155.72,57.81 155.65,57.88 155.65,58.73 156.26,59.34 156.4,59.34 156.58,59.17 156.73,59.17 156.84,59.28 156.84,59.67 156.78,59.74 UH1.AK1
  BOTTOM w0.14: JDIMM1.140 142.12,19.07 142.03,19.16 142.03,19.29 141.87,19.45 141.87,19.75 142,19.87 142.14,19.87 v2(142.3,19.71)
M_CLK_DDR#2: length 98.2
  IN3 w0.081: v2(218.15,23.52) 218.15,23.44 217.98,23.28 217.86,23.28 217.74,23.39 217.74,29.83 210.24,37.34 195.68,37.34 194.02,39 167.61,39 157.81,48.8 157.81,51.87 157.53,52.15 157.53,52.35 157.81,52.63 157.81,53.03 157.01,53.83 157.01,59.72 156.6,60.13 156.6,60.96 157.43,61.78 157.43,62.22 156.99,62.66 156.89,62.66 156.34,63.2 155.59,63.2 155.4,63.4 155.4,64.71 v2(154.85,65.26)
  BOTTOM w0.076: v2(154.85,65.26) 154.53,64.95 UH1.AN9
  BOTTOM w0.14: v2(218.15,23.52) 217.96,23.34 217.84,23.34 217.7,23.48 217.7,25.13 218.19,25.62 JDIMM2.139
M_CLK_DDR#3: length 99.1
  IN3 w0.081: v2(155.76,64.62) 155.96,64.43 156.16,64.43 156.33,64.25 156.33,63.69 156.47,63.55 156.98,63.55 157.83,62.7 157.83,61.19 157.49,60.85 157.49,59.9 158.06,59.32 158.06,53.38 158.26,53.18 158.26,51.17 158.47,50.95 158.47,49.07 167.88,39.66 194.29,39.66 195.95,37.99 210.63,37.99 218.4,30.22 218.4,25.5 218.92,24.98 218.92,20.27 218.57,19.91 218.34,19.91 v2(218.15,19.71)
  BOTTOM w0.076: UH1.AM8 v2(155.76,64.62)
  BOTTOM w0.14: v2(218.15,19.71) 218.27,19.83 218.48,19.83 218.62,19.69 218.62,19.53 218.32,19.23 218.32,19.1 218.43,18.99 JDIMM2.140
M_ODT0: length 57.4
  IN6 w0.089: 161.84,50 159.36,52.48 159.36,54.58 159.52,54.74 v2(159.92,54.74)
  IN6 w0.117: v2(149.18,23.25) 149.48,23.25 149.69,23.04 149.69,21.49 149.82,21.37 150.1,21.37 150.23,21.49 150.23,23.32 150.1,23.44 149.83,23.44 149.71,23.57 149.71,23.77 149.83,23.9 149.97,23.9 150.08,24.01 150.08,25.6 150.21,25.73 150.79,25.73 150.92,25.85 150.92,26.07 150.79,26.2 150.21,26.2 150.08,26.32 150.08,26.56 150.21,26.69 150.76,26.69 150.92,26.84 150.92,27.07 150.76,27.22 150.21,27.22 150.08,27.35 150.08,28.73 152.05,30.7 152.05,32.61 160.59,41.15 160.59,43.19 161.84,44.45 161.84,50
  BOTTOM w0.076: UH1.AD3 161.32,61.04 161.27,60.98 161.27,59.41 161.53,59.14 161.53,55.42 160.86,54.74 v2(159.92,54.74)
  BOTTOM w0.221: v2(149.18,23.25) 148.81,23.25 148.15,23.91 148.15,24.46 148,24.6 148,24.81 147.87,24.94 JDIMM1.155
M_ODT1: length 56.4
  IN6 w0.117: v2(150.74,24.49) 150.63,24.49 150.5,24.61 150.5,25.22 150.59,25.3 151.2,25.3 151.34,25.44 151.34,27.54 151.22,27.65 151.02,27.65 150.89,27.78 150.89,27.99 151.02,28.12 151.21,28.12 151.34,28.25 151.34,28.46 151.21,28.59 151.01,28.59 150.88,28.72 150.88,28.93 151.01,29.06 151.22,29.06 151.34,29.17 152.47,30.31 152.47,31.09 152.57,31.2 153.43,31.2 153.55,31.32 153.55,31.56 153.43,31.68 152.6,31.68 152.47,31.81 152.47,32.03 152.6,32.15 153.83,32.15 153.96,32.28 153.96,32.5 153.83,32.62 153.22,32.62 153.09,32.75 153.09,32.93 153.22,33.05 153.83,33.05 153.96,33.18 153.96,33.92 161.01,40.98 161.01,43.02 162.27,44.27 162.27,45.18 162.38,45.3 162.52,45.3 162.64,45.41 162.64,45.65 162.52,45.76 162.38,45.76 162.27,45.88 162.27,46.11 162.38,46.23 162.52,46.23 162.64,46.35 162.64,46.58 162.52,46.7 162.38,46.7 162.27,46.82 162.27,47.05 162.38,47.17 162.52,47.17 162.64,47.28 162.64,47.52 162.52,47.63 162.38,47.63 162.27,47.75 162.27,47.98 162.38,48.1 162.52,48.1 162.64,48.22 162.64,48.45 162.52,48.57 162.38,48.57 162.27,48.68 162.27,48.92 162.38,49.04 162.52,49.04 162.64,49.15 162.64,49.39 162.52,49.5 162.38,49.5 162.27,49.62 162.27,50.84 160.53,52.58 v2(160.13,52.58)
  BOTTOM w0.076: v2(160.13,52.58) 160.05,52.5 159.49,52.5 159.34,52.65 159.34,56.8 160.3,57.76 160.3,58.55 160.48,58.74 160.48,59.4 160.37,59.52 160.37,61.44 160.62,61.69 UH1.AE4
  BOTTOM w0.221: JDIMM1.161 149.37,24.72 149.99,24.1 150.18,24.1 150.57,24.49 v2(150.74,24.49)
M_ODT2: length 100.5
  IN3 w0.122: v2(226.26,21.79) 225.39,22.66 225.39,27.46 225.71,27.77 225.71,31.4 213.66,43.44 213.66,43.44 212.55,44.56 210.83,44.56 210.26,43.99 202.48,43.99 200.51,45.96 198.67,45.96 197.72,46.9 182.69,46.9 182.57,47.02 182.57,47.37 182.44,47.49 182.2,47.49 182.08,47.37 182.08,47.02 181.96,46.9 181.71,46.9 181.59,47.02 181.59,47.37 181.47,47.49 181.23,47.49 181.1,47.37 181.1,47.02 180.98,46.9 174.75,46.9 171.01,50.64 169.34,50.64 163.47,56.5 162.25,56.5 161.9,56.85 161.9,59.81 160.8,60.91 160.8,63.53 v2(160.33,64)
  BOTTOM w0.076: v2(160.33,64) 159.98,63.65 UH1.AF7
  BOTTOM w0.221: JDIMM2.155 224.18,23.87 v2(226.26,21.79)
M_ODT3: length 99.8
  IN3 w0.122: v2(226.26,24.84) 227.14,25.72 227.14,31.17 212.85,45.46 203.28,45.46 200.94,47.8 198.13,47.8 198.01,47.92 198.01,48.31 197.88,48.43 197.64,48.43 197.52,48.31 197.52,47.92 197.4,47.8 197.15,47.8 197.03,47.92 197.03,48.31 196.91,48.43 196.67,48.43 196.54,48.31 196.54,47.92 196.42,47.8 196.18,47.8 196.06,47.92 196.06,48.31 195.93,48.43 195.69,48.43 195.57,48.31 195.57,47.92 195.45,47.8 195.2,47.8 195.08,47.92 195.08,48.31 194.96,48.43 194.71,48.43 194.59,48.31 194.59,47.92 194.47,47.8 194.23,47.8 194.11,47.92 194.11,48.31 193.98,48.43 193.74,48.43 193.62,48.31 193.62,47.92 193.5,47.8 193.25,47.8 193.13,47.92 193.13,48.31 193.01,48.43 192.76,48.43 192.64,48.31 192.64,47.92 192.52,47.8 192.21,47.8 192.09,47.92 192.09,48.29 191.97,48.41 191.73,48.41 191.6,48.29 191.6,47.92 191.48,47.8 191.24,47.8 191.12,47.92 191.12,48.29 190.99,48.41 190.68,48.41 190.56,48.29 190.56,47.9 190.44,47.77 190.2,47.77 190.08,47.9 190.08,48.29 189.95,48.41 189.71,48.41 189.59,48.29 189.59,47.9 189.47,47.77 189.22,47.77 189.1,47.9 189.1,48.29 188.98,48.41 174.45,48.41 171.37,51.49 169.68,51.49 163.32,57.84 163.32,59.89 162.37,60.84 162.37,62.47 161.57,63.27 161.57,63.52 v2(161.22,63.87)
  BOTTOM w0.076: UH1.AE8 v2(161.22,63.87)
  BOTTOM w0.221: JDIMM2.161 225.67,25.42 v2(226.26,24.84)
MCARD_PCIE#_SATA: length 198.1
  TOP w0.089: 81.91,13.18 v1(81.92,13.18) ; 81.91,13.18 81.75,13.34 78.12,13.34 77.27,14.19 76.33,14.19 RH508.1 ; 81.91,13.18 82.22,12.87 v2(82.22,12.7)
  IN2 w0.089: 101.98,10.98 99.88,10.98 99.26,10.36 97.82,10.36 96.63,11.55 92.92,11.55 92.7,11.34 92.7,10.83 91.54,9.67 90.38,9.67 90.13,9.42 89.03,9.42 88.76,9.15 87.71,9.15 87.21,9.65 86.07,9.65 83.46,12.25 82.67,12.25 v2(82.22,12.7)
  IN2 w0.099: v2(253.58,8.2) 253.04,8.73 240.42,8.73 238.87,7.18 235.91,7.18 235.26,6.54 227.8,6.54 226.37,7.97 214.82,7.97 211.55,11.24 202.24,11.24 201.39,10.4 200,10.4 199.81,10.2 197.12,10.2 197.06,10.15 188.13,10.15 187.8,10.48 183.91,10.48 183.75,10.64 178.67,10.64 177.84,11.48 163.88,11.48 163.15,10.75 160.14,10.75 159.43,11.46 155.27,11.46 153.64,13.09 149.41,13.09 148.42,14.08 129.7,14.08 128.98,14.79 120.47,14.79 120.23,14.55 116.08,14.55 115.95,14.42 115.95,13.55 115.63,13.23 114.44,13.23 113.32,12.12 104.28,12.12 103.14,10.98 101.98,10.98
  BOTTOM w0.089: UH2.AG36 81.87,13.06 v2(82.22,12.7)
  BOTTOM w0.127: UD2.4 255.32,4.95 254.5,4.12 RD58.1
  BOTTOM w0.14: v2(253.58,8.2) 253.39,8.01 253.39,4.62 254.19,3.82 RD58.1
MCARD_PCIE_SATA#: length 10.1
  BOTTOM w0.127: JNGFF2.61 259.2,5.54 259.14,5.6 257.46,5.6 257.19,5.33 257.19,4.82 257.49,4.52 257.49,4.12 RD10.2
  BOTTOM w0.14: RD10.2 256.62,4.39 255.98,4.39 RD58.2 255.41,3.46 255.28,3.34 253.65,3.34 253.44,3.54 v1(253.44,3.77)
ME_EN: length 3.8
  TOP w0.14: v1(116.08,6.61) 116.7,5.99 RH487.1 116.22,5.52 116.12,5.62 RH454.1 115.75,5.32 115.84,5.23 115.84,4.4 SW4.2
ME_FWP_EC: length 190.8
  TOP w0.14: v2(294.06,10.41) 294.86,10.41 295.02,10.58 UE3.B1 ; SW4.3 117.62,4.48 RH487.2 117.62,5.84 v2(116.99,6.46) 116.99,6.47 v1(117.43,6.9)
  IN5 w0.099: v2(116.99,6.46) 117.4,6.87 118.18,6.87 119.54,8.23 125.76,8.23 126.36,8.83 144.79,8.83 147.07,6.55 158.89,6.55 159.88,5.57 165.56,5.57 166.22,4.9 169.86,4.9 170.98,3.78 178.86,3.78 179.48,4.39 180.29,4.39 183.38,7.48 191.76,7.48 193.36,9.08 195.45,9.08 196.39,10.01 203.57,10.01 203.89,10.34 214.79,10.34 215.11,10.01 233.18,10.01 234.37,8.82 251.68,8.82 252.57,9.71 264.77,9.71 265.9,8.58 275.15,8.58 276.74,6.99 290.64,6.99 v2(294.06,10.41)
ME_SUS_PWR_ACK: length 245.3
  TOP w0.127: v2(76.01,3.31) 75.97,3.36 75.97,3.83 v1(75.87,3.93) 75.72,4.07 75.19,4.07 74.81,4.45 74.56,4.45 RH506.1
  TOP w0.14: UE3.A8 298.77,9.46 298.67,9.36 298.67,8.94 v2(298.2,8.47)
  IN1 w0.076: v2(90.58,3.22) 89.75,4.05 82.41,4.05 82.17,4.29 78.46,4.29 78.32,4.43 77.06,4.43 76.01,3.38 v2(76.01,3.31)
  IN2 w0.089: v2(90.58,3.22) 90.62,3.26 91.9,3.26 92.83,4.19 97.38,4.19 97.44,4.13 97.54,4.03 98.19,4.03 99.39,5.23 99.39,5.47 100.1,6.18 101.98,6.18
  IN2 w0.099: v2(183.96,4.59) 183.96,4.58 183.53,5.02 182.81,5.02 182.18,4.39 177.55,4.39 177.04,4.9 176.63,4.9 175.2,3.46 171.07,3.46 169.87,4.66 163.36,4.66 162.84,5.19 159.57,5.19 159.32,5.44 156.49,5.44 155.99,4.94 150.65,4.94 149.13,6.46 147.49,6.46 145.16,8.78 136.03,8.78 135.82,8.57 117.9,8.57 116.1,6.77 114.2,6.77 113.36,5.93 105.06,5.93 104.81,6.18 101.98,6.18
  IN3 w0.091: v2(298.2,8.47) 298.42,8.24 298.42,4.43 298.32,4.33 296.93,4.33 v2(296.04,3.43)
  IN5 w0.099: v2(183.96,4.59) 183.96,4.58 185.23,3.31 201.66,3.31 205.64,7.28 206.14,7.28 206.78,7.93 210.01,7.93 211.1,6.84 219.32,6.84 219.52,7.05 225.76,7.05 227.1,5.7 268.29,5.7 268.45,5.86 272.68,5.86 273.76,4.78 281.65,4.78 282.78,3.65 291.23,3.65 291.48,3.9 295.57,3.9 v2(296.04,3.43)
  BOTTOM w0.089: v2(90.58,3.22) 90.53,3.27 90.53,4.38 UH2.BD19
MEC_XTAL1: length 6.7
  TOP w0.14: YE1.1 288.38,12.82 288.48,12.91 CE42.1 289.62,12.91 290.13,13.41 292.25,13.41 v1(292.28,13.45) 292.46,13.45 292.78,13.13 UE3.A61
MEC_XTAL2: length 5.4
  TOP w0.14: v3(285.23,10.91) 285.82,10.32 YE1.2 287.37,10.22 CE43.1 289.26,10.55 RE51.2
MEC_XTAL2_R: length 3.5
  TOP w0.14: RE51.1 291.42,10.55 v1(292.28,11.41) 292.28,11.57 293,12.29 293,12.48 293.15,12.63 UE3.A62
MEDIACARD_IRQ#: length 295.5
  TOP w0.089: v2(80.71,10.42) 81.09,10.8 82.68,10.8 82.92,10.56 RH546.1
  TOP w0.14: v2(322.71,32.17) v3(322.71,31.54)
  IN3 w0.091: v2(322.71,32.17) 323.51,32.17 324.27,31.4 330.49,31.4 331.7,32.6 338.85,32.6 339.66,33.41 342.01,33.41 v2(342.7,34.1)
  IN6 w0.089: v2(80.71,10.42) 80.71,10.69 81.09,11.07 81.09,11.44 81.55,11.9 83.78,11.9 83.92,11.75 84.79,11.75 85.67,12.63 91.73,12.63 92.11,13.02 95.84,13.02 96.31,12.55 98.74,12.55 99.34,11.95 101.59,11.95 101.98,12.34
  IN6 w0.099: 101.98,12.34 102.11,12.46 107.7,12.46 108.54,11.62 112.34,11.62 113.15,12.43 115.87,12.43 116.47,11.83 124.52,11.83 125.62,12.93 128.46,12.93 129.26,12.13 145.66,12.13 146.13,11.65 147.22,11.65 147.87,11 148.76,11 149.57,11.81 151.91,11.81 151.96,11.75 156.26,11.75 157.31,10.7 163.22,10.7 163.92,11.39 175.85,11.39 175.88,11.42 185.34,11.42 187.01,13.1 228.03,13.1 230.6,10.52 231.1,10.52 234.28,10.52 234.67,10.13 236.33,10.13 236.56,9.9 249.84,9.9 250.34,9.41 261.8,9.41 262.74,10.34 269.98,10.34 270.89,9.43 270.89,9.08 271.27,8.69 274.68,8.69 275.2,8.18 278.21,8.18 279.81,9.77 283.78,9.77 284.86,8.7 287.86,8.7 288.8,9.63 288.8,10.02 289.21,10.43 292.5,10.43 293.3,11.23 294.43,11.23 295.21,10.45 303.6,10.45 303.94,10.1 311.31,10.1 314.37,13.16 314.37,16.33 318.32,20.28 318.32,24.47 318.8,24.95 318.8,26.41 322.53,30.14 322.53,31.99 v2(322.71,32.17)
  BOTTOM w0.089: UH2.AL39 80.37,10.76 v2(80.71,10.42)
  BOTTOM w0.14: RR10.1 v2(342.7,34.1)
MEM_VDD_CTL: length 113.1
  TOP w0.14: RV1124.2 213.09,43.85 212.83,43.58 212.83,41.86 212.46,41.49 197.54,41.49 195.16,43.86 195.16,53.11 v2(197.44,55.38) ; RV1086.2 199.83,105.21 v1(199.83,105.88) 199.83,106.45 PR728.1 199.4,106.94 200.32,107.86 200.32,107.88 201.65,109.21 201.65,110.91 v2(201.63,110.93)
  IN2 w0.099: v2(201.63,110.93) 201.34,110.93 200.62,110.21 200.62,109.57 198.91,107.86 198.91,105.97 198.72,105.78 198.72,102.55 197.85,101.68 197.85,97.63 196.77,96.55 192.94,96.55 190.46,94.07 190.46,84.84 190.25,84.63 190.25,81.74 192.48,79.51 192.48,70.81 193.56,69.73 196.33,69.73 v2(196.65,70.05)
  IN6 w0.099: v2(196.65,70.05) 196.65,69.94 197.74,68.84 199.24,68.84 199.44,68.64 199.44,68.25 199.61,68.08 200.11,68.08 200.32,67.88 200.32,67.4 200.11,67.19 199.4,67.19 199.1,66.89 199.1,64.36 198.4,63.66 198.4,56.35 v2(197.44,55.38)
MEM_VREF: length 128.5
  TOP w0.508: QV95.2 221.44,104.65 v2(220.53,105.55) ; v2(219.37,107.92) 218.84,107.39 QV101.2 ; QV96.2 v2(242.4,96.28) 242.25,96.28 241.81,95.84 241.81,92.5 v1(241.83,92.48) 241.85,92.46 242.86,92.46 QV102.2
  IN2 w0.508: v2(214.86,55.72) 217.4,55.72 219.28,53.84 219.8,53.84 223.72,49.92 233.77,49.92 v2(234.13,50.28)
  IN4 w0.508: v2(242.4,96.28) 241.19,95.07 235.9,95.07 232.7,91.86 232.7,54.46 234.13,53.03 v2(234.13,50.28)
  IN6 w0.508: v2(220.53,105.55) 220.53,106.34 219.37,107.5 v2(219.37,107.92) 219.37,108.29 220.56,109.48 224.92,109.48 226.91,111.47 240.08,111.47 240.54,111.01 240.54,108.85 241.43,107.96 241.43,100.85 242.81,99.46 242.81,96.69 v2(242.4,96.28)
  BOTTOM w0.356: v2(214.86,55.72) 214.69,55.89 RV1103.2 214.03,55.5 RV567.1
MIC1-VREFO_L: length 24.4
  TOP w0.508: v2(12.64,58.97) 12.8,58.97 RA21.1 RA20.1
  IN3 w0.508: v2(9.92,44.23) 9.92,44.45 10.58,45.1 14.09,45.1 15.23,46.24 15.23,52.23 14.24,53.22 14.24,57.64 12.91,58.97 v2(12.64,58.97)
  BOTTOM w0.203: v2(9.92,44.23) 9.78,44.09 9.78,43.4 9.64,43.26 UA1.38
MIC1-VREFO_R: length 5.4
  TOP w0.102: v1(9.98,45.92) RA19.1
  TOP w0.508: v2(10.57,44.23) 10.91,44.57 RA75.1 RA19.1
  BOTTOM w0.203: UA1.39 10.04,42.33 9.97,42.39 9.97,43.15 10.1,43.28 10.1,43.76 v2(10.57,44.23)
MONO_IN: length 2.4
  BOTTOM w0.14: CA16.2 3.95,38.81 4.05,38.71 4.5,38.71 4.51,38.72 4.52,38.72 4.72,38.92 UA1.23
MSATA_DEVSLP: length 214
  TOP w0.14: RD7.2 v3(267.51,12.14) 267.51,12.07 266.85,11.41 v2(266.85,11.28)
  IN5 w0.089: v2(79.31,12.65) 79.91,13.24 84.06,13.24 84.12,13.17 90.39,13.17 92.05,14.83 96.32,14.83 96.72,14.42 100.59,14.42 100.89,14.12 101.98,14.12
  IN5 w0.099: v2(266.85,11.28) 266.72,11.28 265.93,12.07 262.13,12.07 261.63,11.58 252.22,11.58 251.36,12.44 235.44,12.44 235.23,12.23 230.46,12.23 230.38,12.32 229.54,13.15 223.89,13.15 219.02,18.02 219.02,24.42 218.11,25.33 186.7,25.33 186.43,25.61 182.62,25.61 179.66,22.65 179.66,18.79 175.1,14.23 125.35,14.23 124.78,13.66 122.66,13.66 121.77,12.78 117.1,12.78 116.22,13.66 116.08,13.66 115.95,13.79 115.95,14.35 115.83,14.47 106.22,14.47 105.87,14.12 101.98,14.12
  BOTTOM w0.089: UH2.AG42 v2(79.31,12.65)
  BOTTOM w0.14: JNGFF2.38 267.03,13.29 266.64,12.9 266.64,11.5 v2(266.85,11.28)
MSCLK: length 7.5
  TOP w0.14: RE63.2 309.06,29.15 v2(308.15,30.06) 308.04,30.17 v3(306.36,30.17) 305.73,30.17 304.47,28.91 RE103.1
  BOTTOM w0.14: v2(308.15,30.06) 308.61,30.53 JDEG1.6
MSCLK_R: length 18.5
  TOP w0.14: v2(303.51,26.86) 303.51,27.97 ; 303.51,27.97 RE119.2 RE103.2 ; 303.51,27.97 303.35,27.82 v1(302.57,27.82) ; UE3.B43 299.02,18.91 v2(298.5,18.39)
  IN4 w0.091: v2(298.5,18.39) 298.97,18.86 298.97,19.92 298.63,20.27 298.63,21.34 298.98,21.7 298.98,23.73 300.03,24.77 300.03,25.95 300.33,26.26 300.33,27.34 300.65,27.66 302.71,27.66 v2(303.51,26.86)
MSDATA: length 17.1
  TOP w0.14: v3(308.29,26.55) 307.66,27.19 307.66,28.15 RE65.2 308.17,29.36 v2(308.11,29.41) ; v2(301.65,29.32) 300.91,28.58 299.9,28.58 RE27.1 299.39,27.09 RE102.1
  IN4 w0.091: v2(301.65,29.32) 301.91,29.32 302.49,28.74 307.44,28.74 v2(308.11,29.41)
  BOTTOM w0.14: JDEG1.7 308.11,30.72 307.72,30.32 307.72,29.8 v2(308.11,29.41)
MSDATA_R: length 5.6
  TOP w0.14: UE3.A40 299.27,21.73 v1(299.42,21.88) 299.52,21.98 299.59,21.98 299.98,22.36 RE118.2 300.15,23.3 300.51,23.66 300.51,24.72 299.98,25.26 RE102.2
NB_MUTE#: length 344.9
  TOP w0.14: v2(271.3,9.27) 270.9,9.67 v3(270.9,12.61) 270.9,15.76 274.08,18.94 275.67,18.94 276.11,18.5 276.11,18.03 276.58,17.56 UE4.20 ; JAUDIO.4 4.8,13.72 v2(5.23,13.29)
  IN2 w0.099: v2(13.27,37.03) 12.96,37.35 10.14,37.35 8.05,35.26 8.05,33.52 7.62,33.09 5.88,33.09 5.27,32.48 5.27,31.44 4.65,30.82 4.65,28.49 8.09,25.04 8.09,22.76 7.45,21.22 6.18,19.95 6.18,18.14 5.26,17.22 5.26,13.32 v2(5.23,13.29)
  IN6 w0.099: v2(5.23,13.29) 5.89,13.29 6.29,12.89 7,12.89 8,13.89 8,18.15 9.69,19.84 14.34,19.84 16.67,22.17 21.44,22.17 23.36,24.09 26.88,24.09 27.09,23.88 37.33,23.88 37.97,24.52 44.95,24.52 46.52,22.95 46.74,22.95 47.3,22.39 51.76,22.39 51.97,22.18 54.26,22.18 55.08,21.36 55.08,20.62 57.24,18.46 57.24,14.97 58.48,13.72 64.29,13.72 65.65,15.09 69.96,15.09 72.54,12.51 72.54,10.42 73.15,9.81 75.04,9.81 75.26,10.02 77.77,10.02 79.82,12.08 83.85,12.08 84,11.94 84.71,11.94 85.64,12.86 91.7,12.86 92.04,13.2 95.92,13.2 96.38,12.73 98.88,12.73 99.48,12.14 101.47,12.14 102,12.67 107.78,12.67 108.62,11.82 112.26,11.82 113.07,12.63 115.95,12.63 116.55,12.03 124.44,12.03 125.53,13.13 128.54,13.13 129.34,12.33 145.74,12.33 146.19,11.87 149.25,11.87 149.39,12.01 151.99,12.01 152.05,11.95 160.57,11.95 160.93,11.6 175.77,11.6 175.79,11.62 185.25,11.62 186.93,13.3 228.11,13.3 230.69,10.72 231.02,10.72 234.42,10.72 234.81,10.33 236.42,10.33 236.64,10.11 249.92,10.11 250.42,9.61 261.72,9.61 262.65,10.54 270.09,10.54 271.3,9.33 v2(271.3,9.27)
  BOTTOM w0.14: UA1.52 12.98,37.32 v2(13.27,37.03) 13.57,36.73 RA68.1 13.94,36.78 14.4,36.78 14.91,36.27 RA12.2
