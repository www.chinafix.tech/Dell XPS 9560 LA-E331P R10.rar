# Allegro board Dell XPS 9560 LA-E331P R10.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DL1_NVVDDS: length 15.7
  TOP w0.14: v2(183.48,114.54) 183.48,114.89 v1(183.19,115.19)
  IN1 w0.762: 184.42,113.69 185.01,113.1 187.33,113.1 187.64,112.78 189.1,112.78 191.45,110.44 191.45,109.43 192.3,108.58 192.3,105.57 191.39,104.66
  vias: v2(183.96,114.13) v2(191.58,103.58) v2(191.58,102.94)
DL2_NVVDD: length 6.4
  TOP w0.14: v2(169.51,111.38) 169.51,110.96 v1(169.93,110.54)
  IN4 w0.762: 173.1,109.93 172.21,110.82 169.94,110.82 169.51,111.25
  BOTTOM w0.203: PU1001.17 168.61,112.21 168.99,111.83 v2(169.05,111.83)
  vias: v2(174.18,109.95) v2(174.18,109.36)
DL_1.2V: length 12
  TOP w0.14: v2(274.32,26.62) v3(273.5,26.62)
  IN6 w1.016: 275.78,26.55 276.89,26.55 278.09,27.76 279.92,27.76 281.24,26.44 285.67,26.44 285.87,26.63
  vias: v2(274.96,26.62) v2(286.45,27.31) v2(286.96,27.76)
DMI_CRX_PTX_N0: length 131.4
  IN3 w0.099: v2(175.81,64.45) 175.96,64.61 175.96,64.81 176.31,65.16 177.5,65.16 178.37,64.29 178.37,63.51 178.94,62.94 181.61,62.94 182.5,62.05 182.5,61.35 183.33,60.52 183.33,59.24 181.99,57.91 181.99,54.38 182.82,53.55 182.82,52.75 182.66,52.59 v2(182.66,52.29)
  BOTTOM w0.076: v2(175.81,64.45) 175.48,64.12 UH1.E8
  BOTTOM w0.089: UH2.C27 86.73,24.95 86.93,25.15 86.93,25.48 87.05,25.59 87.05,26.22 87.89,27.07 87.89,27.45
  BOTTOM w0.152: v2(182.66,52.29) 182.16,52.29 180.47,50.6 179.73,50.6 176.51,47.38 176.51,45.13 170.03,38.64 120.29,38.64 110.65,29 102.49,29 101.92,28.43 92.77,28.43 91.58,29.61 89.23,29.61 87.89,28.28 87.89,27.45
DMI_CRX_PTX_N1: length 124.7
  IN3 w0.089: 179.77,57.6 179.75,57.62 179.75,57.63 177.05,60.33 176.7,60.33 175.25,61.78 175.25,63.07 175.32,63.15 175.32,63.49 v2(175.16,63.66)
  IN3 w0.099: 179.77,57.6 180.72,56.65 180.72,53.9 180.92,53.7 v2(180.92,53.46)
  BOTTOM w0.076: v2(175.16,63.66) 174.81,63.32 UH1.F6
  BOTTOM w0.089: UH2.B28 86.15,25.47 85.99,25.63 85.99,25.94 85.99,25.95 85.99,26.24 86.18,26.43 86.18,26.82 86.68,27.31
  BOTTOM w0.152: 86.68,27.31 86.68,29.08 88.36,30.76 92.12,30.76 93.31,29.57 101.45,29.57 102,30.12 110.16,30.12 120.1,40.05 169.54,40.05 175.08,45.6 175.08,47.58 179.24,51.74 179.98,51.74 181.03,52.79 181.03,53.36 v2(180.92,53.46)
DMI_CRX_PTX_N2: length 127.2
  IN3 w0.099: v2(181.45,60.46) 181.67,60.69 181.67,61.52 181.15,62.05 176.43,62.05 176.07,62.41 176.07,62.57 v2(175.79,62.85)
  BOTTOM w0.076: UH1.E5 175.48,62.54 v2(175.79,62.85)
  BOTTOM w0.089: UH2.B29 85.64,25.27 85.58,25.22 85.41,25.22 85.35,25.28 85.35,25.41 85.6,25.66 85.6,26.46 85.7,26.56 85.7,28.22 85.54,28.37
  BOTTOM w0.152: 85.54,28.37 85.54,29.72 87.53,31.71 92.59,31.71 93.82,30.48 101.25,30.48 101.67,30.91 109.63,30.91 119.78,41.06 169.16,41.06 174.04,45.94 174.04,47.66 180.59,54.21 180.59,58.4 181.6,59.4 181.6,60.31 v2(181.45,60.46)
DMI_CRX_PTX_N3: length 127.5
  IN3 w0.099: v2(180.08,54.36) 180,54.45 180,54.63 180.1,54.74 180.1,55.25 179.66,55.7 178.9,55.7 177.36,57.24 177.36,58.58 175.27,60.67 175.27,61.33 174.51,62.09 174.51,64.7 174.11,65.1 173.94,65.1 v2(173.79,65.24)
  BOTTOM w0.076: v2(173.79,65.24) 173.68,65.24 UH1.J9
  BOTTOM w0.089: UH2.B30 85.02,25.36 85.36,25.69 85.36,25.79 85.42,25.85 85.42,26.54 85.43,26.55 85.43,26.95 85.43,26.95 85.43,27.28 85.43,27.28 85.43,27.5 85.43,27.8 85.36,27.87 85.36,27.96 84.96,28.36 84.96,28.36 84.78,28.53 84.78,28.54
  BOTTOM w0.152: v2(180.08,54.36) 179.83,54.36 179.27,53.81 179.27,53.54 173.31,47.58 173.31,46.19 168.92,41.8 119.53,41.8 109.09,31.37 101.48,31.37 101.06,30.94 94.61,30.94 93.12,32.43 87.06,32.43 84.78,30.16 84.78,28.54
DMI_CRX_PTX_P0: length 131.4
  IN3 w0.099: v2(182.06,52.84) 182.06,52.65 182.2,52.5 182.31,52.5 182.63,52.83 182.63,53.48 181.8,54.3 181.8,57.98 183.14,59.32 183.14,60.45 182.31,61.27 182.31,61.97 181.53,62.75 178.87,62.75 178.18,63.43 178.18,64.21 177.42,64.97 176.39,64.97 176.15,64.73 176.15,64.57 176.27,64.45 v2(176.46,64.45)
  BOTTOM w0.076: v2(176.46,64.45) 176.13,64.12 UH1.D8
  BOTTOM w0.089: 87.56,27.45 87.56,27.44 87.6,27.41 87.6,27.15 86.78,26.33 86.78,25.7 86.7,25.62 86.54,25.62 86.4,25.48 86.4,25.36 86.51,25.24 86.59,25.24 86.63,25.29 UH2.B27
  BOTTOM w0.152: v2(182.06,52.84) 182.06,52.65 180.33,50.93 179.59,50.93 176.18,47.51 176.18,45.26 169.89,38.97 120.15,38.97 110.52,29.33 102.35,29.33 101.78,28.76 92.9,28.76 91.72,29.94 89.09,29.94 87.56,28.42 87.56,27.45
DMI_CRX_PTX_P1: length 124.6
  IN3 w0.089: 179.9,57.74 179.89,57.75 179.88,57.75 177.12,60.51 176.77,60.51 175.43,61.85 175.43,63 175.5,63.07 175.5,63.36 v2(175.81,63.66)
  IN3 w0.099: v2(181.36,53.86) 181.04,53.86 180.91,53.98 180.91,56.73 179.9,57.74
  BOTTOM w0.076: UH1.E6 175.48,63.37 175.77,63.66 v2(175.81,63.66)
  BOTTOM w0.089: 87.01,27.31 87.01,27.3 86.98,27.27 86.98,27.23 86.45,26.71 86.45,26.32 86.26,26.13 86.26,26.06 86.3,26.01 86.37,26.01 86.42,25.95 86.42,25.83 86.34,25.75 UH2.A28
  BOTTOM w0.152: 87.01,27.31 87.01,28.94 88.49,30.43 91.99,30.43 93.17,29.24 101.59,29.24 102.14,29.79 110.3,29.79 120.23,39.72 169.67,39.72 175.41,45.46 175.41,47.45 179.38,51.41 180.12,51.41 181.36,52.65 v2(181.36,53.86)
DMI_CRX_PTX_P2: length 127.2
  IN3 w0.099: v2(176.44,62.85) 176.26,62.67 176.26,62.48 176.51,62.24 181.23,62.24 181.87,61.6 181.87,60.71 v2(182.12,60.46)
  BOTTOM w0.076: v2(176.44,62.85) 176.13,62.54 UH1.D5
  BOTTOM w0.089: 85.87,28.37 85.9,28.34 85.9,26.42 85.79,26.31 85.79,25.54 85.89,25.43 85.89,25.21 85.64,24.95 UH2.C29
  BOTTOM w0.152: 85.87,28.37 85.87,29.58 87.67,31.38 92.46,31.38 93.68,30.15 101.38,30.15 101.81,30.58 109.77,30.58 119.92,40.73 169.29,40.73 174.37,45.8 174.37,47.52 180.92,54.08 180.92,58.26 181.93,59.27 181.93,60.27 v2(182.12,60.46)
DMI_CRX_PTX_P3: length 127.6
  IN3 w0.099: v2(179.45,54.94) 179.67,54.71 179.82,54.71 179.91,54.82 179.91,55.18 179.58,55.51 178.82,55.51 177.17,57.16 177.17,58.5 175.08,60.59 175.08,61.25 174.32,62.01 174.32,64.62 174.03,64.91 173.96,64.91 173.86,64.81 v2(173.86,64.45)
  BOTTOM w0.076: UH1.J8 173.54,64.45 v2(173.86,64.45)
  BOTTOM w0.089: 84.45,28.54 84.45,28.53 84.49,28.5 84.49,28.42 84.66,28.25 84.69,28.25 85.09,27.85 85.09,27.76 85.17,27.69 85.17,27.39 85.17,27.17 85.17,27.17 85.17,27.06 85.17,26.07 85.1,26.01 84.96,26.01 84.89,25.93 84.89,25.82 84.96,25.75 UH2.A30
  BOTTOM w0.152: v2(179.45,54.94) 179.45,54.94 179.45,54.44 178.94,53.94 178.94,53.68 172.98,47.71 172.98,46.33 168.79,42.13 119.39,42.13 108.95,31.7 101.35,31.7 100.92,31.27 94.75,31.27 93.26,32.76 86.92,32.76 84.45,30.3 84.45,28.54
DMI_CTX_PRX_N0: length 128.8
  IN2 w0.107: v2(103.95,32.45) 104.14,32.25 104.14,31.79 103.85,31.5 103.23,31.5 100.82,29.09 91.2,29.09 89.05,26.94 89.05,23.68 88.51,23.14 88.51,22.28 87.09,20.87 86.22,20.87 86.12,20.96 86.12,21.09 86.3,21.27 v2(86.3,21.29)
  BOTTOM w0.076: 179.93,64.16 179.8,64.16 179.75,64.21 179.48,64.21 179.29,64.4 178.48,64.4 178.39,64.31 178.2,64.31 178.11,64.4 177.85,64.4 177.72,64.27 177.72,64.12 177.77,64.07 177.77,63.97 177.82,63.92 178.04,63.92 178.08,63.96 UH1.A8
  BOTTOM w0.152: v2(103.95,32.45) 104.08,32.58 104.08,32.9 104.12,32.94 104.12,33.37 103.44,34.04 103.44,36.75 106.29,39.59 115.26,39.59 118.93,43.27 168.41,43.27 172.13,46.98 172.13,48 177.55,53.43 177.55,53.43 178.07,53.95 178.07,54.72 179.69,56.34 179.69,58.64 180.66,59.6 180.66,63.66 180.16,64.16 179.93,64.16 ; UH2.L27 86.75,21.02 86.48,21.29 v2(86.3,21.29)
DMI_CTX_PRX_N1: length 123.2
  IN2 w0.107: v2(87.33,23.51) 87.24,23.42 87.24,23.24 87.34,23.14 87.67,23.14 87.89,23.35 87.89,27.08 90.68,29.88 100.7,29.88 102.72,31.9 102.72,32.71 v2(102.5,32.93)
  BOTTOM w0.076: UH1.B6 177.43,63.11 177.39,63.06 177.11,63.06 177.06,63.12 177.06,63.46 177.18,63.59 178.25,63.59 178.41,63.43 178.62,63.43 178.72,63.53 178.9,63.53 178.99,63.45 179.15,63.45
  BOTTOM w0.101: UH2.E24 v2(87.33,23.51)
  BOTTOM w0.152: v2(102.5,32.93) 102.66,33.08 102.66,37.22 105.94,40.51 115.02,40.51 118.72,44.22 161.86,44.22 167.64,50 173,50 177.28,54.28 177.28,55.04 178.87,56.63 178.87,58.92 179.83,59.89 179.83,62.84 179.4,63.28 179.23,63.45 179.15,63.45
DMI_CTX_PRX_N2: length 122.3
  IN2 w0.107: v2(86.29,22.75) 86.29,22.9 86.41,23.02 86.63,23.02 86.91,23.3 86.91,25.42 87.08,25.6 87.08,27.03 90.5,30.45 100.55,30.45 101.64,31.54 101.64,32.15 100.98,32.81 100.98,33.32 101.11,33.45 101.25,33.45 v2(101.45,33.24)
  BOTTOM w0.076: UH1.A5 178.08,62.62 178.2,62.75 178.35,62.75 178.42,62.68 178.42,62.43 178.47,62.38 178.63,62.38 178.69,62.44 178.69,62.65 178.76,62.72 178.82,62.72 178.95,62.59 178.98,62.62 178.98,62.6
  BOTTOM w0.101: UH2.G27 v2(86.29,22.75)
  BOTTOM w0.152: v2(101.45,33.24) 101.2,33.24 100.95,33.49 100.84,33.6 100.71,33.73 100.71,36.52 105.53,41.33 114.55,41.33 118.32,45.11 161.34,45.11 167.25,51.01 172.9,51.01 176.39,54.5 176.39,54.96 177.99,56.56 177.99,58.95 179.18,60.14 179.18,62.18 178.98,62.38 178.98,62.6
DMI_CTX_PRX_N3: length 125.2
  IN2 w0.107: v2(85.02,20.53) 84.83,20.72 84.63,20.72 84.39,20.95 84.39,22.78 84.05,23.12 84.05,24.74 84.59,25.28 84.98,25.28 85.95,26.26 85.95,27.27 90.12,31.44 100.17,31.44 100.33,31.6 100.33,31.81 v2(100.18,31.96)
  BOTTOM w0.076: UH1.B4 177.05,61.83 176.91,61.83 176.79,61.72 176.79,61.54 176.91,61.43 177.25,61.43 177.31,61.49 177.51,61.49 177.58,61.57 177.58,61.95 177.67,62.04 178.25,62.04 178.61,61.68
  BOTTOM w0.089: UH2.L29 85.31,20.82 v2(85.02,20.53)
  BOTTOM w0.152: 178.61,61.68 178.61,60.38 177.42,59.19 177.42,58.26 177.34,58.18 177.34,56.72 172.58,51.96 166.91,51.96 161,46.06 117.85,46.06 114.09,42.3 105.03,42.3 99.79,37.06 99.79,33.36 100.36,32.79 100.36,32.14 v2(100.18,31.96)
DMI_CTX_PRX_P0: length 128.8
  IN2 w0.107: v2(104.55,32.43) 104.45,32.43 104.34,32.33 104.34,31.71 103.94,31.3 103.32,31.3 100.9,28.89 91.28,28.89 89.25,26.86 89.25,23.6 88.71,23.06 88.71,22.2 87.17,20.66 86.5,20.66 v2(86.3,20.47)
  BOTTOM w0.076: UH1.B8 177.49,64.11 177.49,64.3 177.62,64.42 177.62,64.42 177.76,64.56 179.44,64.56 179.53,64.47 179.89,64.47 179.92,64.49 179.93,64.49
  BOTTOM w0.152: UH2.N27 86.71,20.06 v2(86.3,20.47) ; v2(104.55,32.43) 104.54,32.43 104.41,32.56 104.41,32.77 104.45,32.8 104.45,33.51 103.77,34.18 103.77,36.61 106.42,39.26 115.4,39.26 119.07,42.93 168.55,42.93 172.46,46.84 172.46,47.87 177.88,53.29 177.88,53.29 178.4,53.81 178.4,54.58 180.02,56.21 180.02,58.5 180.99,59.46 180.99,63.8 180.3,64.49 179.93,64.49
DMI_CTX_PRX_P1: length 123.1
  IN2 w0.107: v2(87.33,22.75) 87.51,22.93 87.76,22.93 88.09,23.26 88.09,27 90.77,29.68 100.79,29.68 102.93,31.81 102.93,32.77 v2(103.09,32.93)
  BOTTOM w0.076: UH1.C6 176.88,63.37 176.88,63.54 177.09,63.75 179.32,63.75 179.34,63.74 179.35,63.74 179.48,63.61 179.53,63.61 179.63,63.51
  BOTTOM w0.101: UH2.G24 v2(87.33,22.75)
  BOTTOM w0.152: v2(103.09,32.93) 102.99,33.03 102.99,37.08 106.08,40.18 115.15,40.18 118.86,43.89 162,43.89 167.78,49.67 173.14,49.67 177.61,54.14 177.61,54.91 179.2,56.49 179.2,58.79 180.16,59.75 180.16,62.98 179.63,63.51
DMI_CTX_PRX_P2: length 122.3
  IN2 w0.107: v2(101.45,33.83) 101.45,33.83 101.27,33.65 101.02,33.65 100.78,33.41 100.78,32.72 101.44,32.06 101.44,31.63 100.46,30.65 90.42,30.65 86.88,27.12 86.88,25.68 86.7,25.51 86.7,23.39 86.54,23.22 86.39,23.22 86.29,23.32 v2(86.29,23.51)
  BOTTOM w0.076: UH1.B5 177.6,62.48 177.72,62.59 178.1,62.98 178.93,62.98 179.31,62.6
  BOTTOM w0.101: UH2.E26 v2(86.29,23.51)
  BOTTOM w0.152: v2(101.45,33.83) 101.35,33.73 101.18,33.73 101.07,33.84 101.04,33.87 101.04,36.38 105.66,41 114.68,41 118.45,44.78 161.48,44.78 167.38,50.68 173.04,50.68 176.72,54.37 176.72,54.83 178.32,56.43 178.32,58.82 179.51,60 179.51,62.32 179.31,62.52 179.31,62.6
DMI_CTX_PRX_P3: length 125.2
  IN2 w0.107: v2(85.02,21.29) 85.16,21.15 85.16,21.01 85.07,20.92 84.71,20.92 84.6,21.04 84.6,22.86 84.25,23.21 84.25,24.66 84.67,25.08 85.07,25.08 86.16,26.17 86.16,27.19 90.21,31.24 100.25,31.24 100.53,31.52 100.53,31.73 v2(100.76,31.96)
  BOTTOM w0.076: 178.94,61.68 178.94,61.69 178.9,61.73 178.9,61.8 178.78,61.92 178.7,61.92 178.42,62.2 177.54,62.2 177.44,62.1 176.9,62.1 UH1.D4
  BOTTOM w0.089: v2(85.02,21.29) 85.31,21.58 UH2.K29
  BOTTOM w0.152: 178.94,61.68 178.94,60.24 177.75,59.05 177.75,58.12 177.67,58.05 177.67,56.59 172.72,51.63 167.04,51.63 161.14,45.73 117.98,45.73 114.22,41.97 105.17,41.97 100.12,36.92 100.12,33.49 100.69,32.93 100.69,32.04 v2(100.76,31.96)
DMIC_CLK_CODEC: length 217.7
  TOP w0.14: DE9.2 10.66,11.7 v2(10.99,11.38)
  IN1 w0.099: v2(151.89,9.47) 151.06,9.47 149.99,10.54 146.89,10.54 146.16,11.27 115.9,11.27 114.67,12.5 110.22,12.5 109.41,13.31 108.58,13.31 107.77,12.5 104.3,12.5 103.7,11.9 101.69,11.9 101.12,11.33 99.98,11.33 99.58,10.93 98.09,10.93 97.47,11.56 95.34,11.56 94.99,11.91 91.97,11.91 91.39,11.33 88.3,11.33 87.57,10.59 86.93,10.59 86.62,10.91 84.47,10.91 83.58,10.02 79.8,10.02 79.56,9.78 75.85,9.78 75.62,10.01 72.93,10.01 72.47,10.47 68.68,10.47 67.71,11.44 60.93,11.44 59.05,9.56 55.86,9.56 55.53,9.89 v2(54.88,9.89) ; v2(13.84,35.76) 13.79,35.76 13.25,36.31 11.13,36.31 10.43,35.6 5.08,35.6 4.12,34.64 4.12,32.56 3.52,31.96 3.13,31.96 2.38,31.22 2.38,27.27 2.99,26.66 5.91,26.66 7.78,24.79 7.78,19.31 8.2,18.89 8.2,15.53 9.48,14.25 9.96,14.25 10.57,13.64 10.57,11.79 v2(10.99,11.38)
  IN2 w0.099: v2(54.88,9.89) 54.88,10.42 55.16,10.7 55.33,10.7 55.71,11.08 55.71,11.81 56.63,12.73 56.63,14.77 57.11,15.24 57.11,18.5 55.13,20.48 55.13,21.28 53.57,22.83 48.2,22.83 46.78,24.26 44.69,24.26 43.18,25.77 37.03,25.77 36.49,25.22 31.81,25.22 30.73,24.14 28.8,24.14 26.79,22.13 23.31,22.13 22.76,21.58 19.71,21.58 18.27,20.14 18.27,17.23 17.24,16.2 15.81,16.2 12.09,12.48 10.69,12.48 10.49,12.27 10.49,11.87 v2(10.99,11.38)
  BOTTOM w0.108: UA1.53 12.8,36.92 13.25,36.47 13.25,36.42 13.84,35.83 v2(13.84,35.76) 13.84,35.71 14.42,35.13 14.57,34.98 14.57,34.97 CA35.1
  BOTTOM w0.14: v2(151.89,9.47) v1(152.31,9.06) 153.21,8.15 RE116.1
DMIC_CLK_CODEC_C: length 7.9
  BOTTOM w0.14: JKB.12 157.77,9.31 157.48,9.03 CE73.1 RE116.2 154.38,8.02 154.03,7.67 v1(152.12,7.67)
DMIC_DAT_CODEC: length 209.1
  TOP w0.14: v2(10.99,12.9) 10.79,12.7 DE9.3
  IN1 w0.099: v2(13.27,35.62) 12.79,36.1 11.21,36.1 10.51,35.4 5.16,35.4 4.32,34.56 4.32,32.48 3.6,31.76 3.21,31.76 2.58,31.13 2.58,27.35 3.07,26.86 5.99,26.86 7.98,24.87 7.98,19.39 8.4,18.97 8.4,15.62 9.56,14.45 10.65,14.45 11.39,13.7 11.39,13.3 v2(10.99,12.9) ; v2(148.27,11.47) 148.18,11.57 115.89,11.57 114.71,12.75 110.27,12.75 109.5,13.51 108.5,13.51 107.73,12.75 104.26,12.75 103.61,12.1 101.62,12.1 101.04,11.52 99.9,11.52 99.51,11.12 98.17,11.12 97.55,11.75 95.42,11.75 95.07,12.09 91.89,12.09 91.31,11.51 84.49,11.51 83.88,10.91 79.3,10.91 78.36,9.97 75.95,9.97 75.71,10.21 73.02,10.21 72.56,10.67 68.77,10.67 67.8,11.64 60.85,11.64 58.97,9.76 57.09,9.76 57.09,9.76 56.37,9.76 55.91,10.21 v2(55.91,10.25)
  IN2 w0.099: v2(55.91,10.25) 55.91,10.25 55.91,11.72 56.83,12.65 56.83,14.69 57.31,15.16 57.31,18.58 55.33,20.56 55.33,21.36 53.66,23.03 50.4,23.03 49.61,23.82 47.5,23.82 46.86,24.46 44.77,24.46 43.26,25.97 39.89,25.97 39.89,25.97 36.95,25.97 36.4,25.42 31.73,25.42 30.65,24.34 28.72,24.34 26.71,22.33 23.23,22.33 22.67,21.78 19.62,21.78 18.06,20.22 18.06,17.31 17.2,16.45 15.64,16.45 12.09,12.9 v2(10.99,12.9)
  BOTTOM w0.108: UA1.54 12.83,36.52 13.27,36.08 v2(13.27,35.62) 13.27,35.12 CA36.1
  BOTTOM w0.14: RE117.1 152.08,11.45 151.98,11.56 v1(149.34,11.56) 148.36,11.56 v2(148.27,11.47)
DMIC_DAT_CODEC_C: length 6.1
  BOTTOM w0.14: RE117.2 153.73,11.45 CE74.1 154.81,10.82 v3(155.47,11.48) 155.56,11.56 157.55,11.56 158.27,10.84 JKB.11
DOCK_TNY_SMB_CLK: length 359.4
  TOP w0.14: v2(165.94,16.87) v3(165.31,17.5) ; v2(66.58,26.6) 66.75,26.43 66.75,25.64 66.01,24.89 65.52,24.89 65.32,25.1 UV17.2 ; RE109.1 295.79,5.1 v2(296.42,5.72)
  IN2 w0.089: 20.58,37.79 20.77,37.79 22.96,35.6 30.11,35.6 31.08,34.62 33.38,34.62 33.62,34.38 33.62,34.37 33.66,34.34
  IN2 w0.099: 20.58,37.79 19.9,37.79 15.87,41.83 15.87,43.97 16.64,44.75 16.64,62.24 16.82,62.42 16.82,63.85 18.52,65.55 19.1,65.55 19.32,65.33 19.32,65.13 v2(19.55,64.91) ; v2(131.35,31.99) 131.35,32 131.35,32.26 131.3,32.31 115.66,32.31 111.66,36.31 105.62,36.31 104.84,37.09 99.7,37.09 96.75,34.15 88.63,34.15 84.99,30.52 80.04,30.52 78.3,28.77 73.61,28.77 70.76,25.92 67.05,25.92 66.77,26.19 66.77,26.41 v2(66.58,26.6) 66.77,26.79 66.77,27.95 64.74,29.98 52.29,29.98 52.06,29.75 47.99,29.75 45.36,32.38 40.67,32.38 38.25,34.8 35.07,34.8 34.45,34.17 33.83,34.17 33.66,34.34
  IN3 w0.091: v2(131.35,31.99) 131.67,31.94 131.79,31.76 131.81,31.74 150.43,31.74 151.45,30.73 151.45,20.19 152.19,19.44 165.4,19.44 166.05,18.79 166.05,16.99 v2(165.94,16.87)
  IN6 w0.099: v2(279.27,18.51) 278.41,18.51 276.79,16.89 269.36,16.89 266.07,13.61 250.93,13.61 250.3,14.23 240.21,14.23 238.9,15.54 237.73,15.54 237.37,15.9 237.37,17.73 235.84,19.26 185.9,19.26 184.16,17.52 166.37,17.52 166.16,17.3 166.16,17.09 v2(165.94,16.87)
  BOTTOM w0.14: RT184.1 19.34,64.55 19.34,64.7 v2(19.55,64.91) ; v2(296.42,5.72) 296.42,5.77 295.86,6.32 289.04,6.32 287.81,5.1 285.6,5.1 280.96,9.74 280.96,16.23 279.59,17.6 279.59,18.2 v2(279.27,18.51)
DOCK_TNY_SMB_DAT: length 359.7
  TOP w0.14: RE108.1 296.61,5.31 296.84,5.55 296.84,6.12 v2(296.79,6.17) ; v2(166.52,16.91) v3(167.11,17.5) ; UV17.3 65.32,24.45 65.52,24.65 66.11,24.65 66.99,25.54 66.99,26.43 v2(67.16,26.6)
  IN2 w0.089: 20.58,37.99 20.59,37.99 20.6,37.98 20.66,37.98 20.66,37.98 20.85,37.98 23.04,35.79 30.19,35.79 31.16,34.81 33.46,34.81 33.66,34.62
  IN2 w0.099: v2(131.88,32.37) 131.53,32.37 131.39,32.51 115.74,32.51 111.74,36.51 105.71,36.51 104.92,37.29 99.61,37.29 96.67,34.35 88.54,34.35 84.91,30.72 79.96,30.72 78.21,28.98 73.53,28.98 70.67,26.12 67.13,26.12 66.97,26.27 66.97,26.41 v2(67.16,26.6) 66.97,26.79 66.97,28.03 64.82,30.18 52.21,30.18 51.98,29.95 48.07,29.95 45.44,32.58 40.75,32.58 38.34,35 34.99,35 34.36,34.37 33.91,34.37 33.76,34.52 33.76,34.52 33.66,34.62 ; 20.58,37.99 19.99,37.99 16.07,41.91 16.07,43.89 16.84,44.66 16.84,62.16 17.02,62.34 17.02,63.76 18.6,65.35 19.02,65.35 19.12,65.25 19.12,65.06 v2(18.96,64.91)
  IN3 w0.091: v2(131.88,32.37) 131.82,32.05 131.9,31.94 150.51,31.94 151.64,30.81 151.64,20.27 152.27,19.63 165.48,19.63 166.25,18.87 166.25,17.19 v2(166.52,16.91)
  IN6 w0.099: v2(279.99,18.58) 279.33,17.92 278.14,17.92 276.89,16.66 269.41,16.66 266.16,13.41 250.84,13.41 250.22,14.03 240.13,14.03 238.82,15.34 237.65,15.34 237.17,15.82 237.17,17.64 235.76,19.06 185.98,19.06 184.24,17.32 166.46,17.32 166.36,17.22 166.36,17.08 v2(166.52,16.91)
  BOTTOM w0.14: v2(18.96,64.91) 19.09,64.78 19.09,64.65 RT185.1 ; v2(279.99,18.58) 279.83,18.42 279.83,17.7 281.2,16.33 281.2,9.84 285.71,5.34 287.71,5.34 288.94,6.56 296.4,6.56 v2(296.79,6.17)
EC_PECI: length 4.5
  TOP w0.14: RE48.1 CE39.1 294.04,23.26 294.04,22.81 293.8,22.56 v1(293.8,21.84) 294.08,21.56 294.84,21.56 295.27,21.13 UE3.A48
EC_SLP_S0IX#: length 267.7
  TOP w0.089: v2(88.7,2.52) 89.18,2.05 89.8,2.05 89.97,2.22 89.97,3.43 90.58,4.04 90.58,4.68 90.47,4.79 89.42,4.79 89.21,5 89.21,5.51 89.42,5.72 90,5.72 90.34,6.06 90.34,11.18 89.75,11.77 85.64,11.77 85.31,12.1 85.31,14.88 83.55,16.63 81.01,16.63 80.7,16.95 v2(80.7,17.16) 80.7,18.74 80.32,19.12 v3(77.99,19.12) 77.69,19.42 77.02,19.42 RH535.1
  TOP w0.14: v2(298.27,22.16) 297.85,21.73 297.85,21.3 297.77,21.23 UE3.A43
  IN6 w0.089: 101.98,14.21 101.87,14.21 101.18,14.89 98.78,14.89 98.12,15.55 97.21,15.55 97.01,15.76 91.83,15.76 90.87,16.72 90.87,18.36 90.31,18.92 90.31,19.07 90.04,19.34 89.18,19.34 88.82,18.98 85.19,18.98 83.73,17.52 81.06,17.52 v2(80.7,17.16)
  IN6 w0.099: v2(298.27,22.16) 297.83,21.71 297.83,21.48 297.59,21.24 296.98,21.24 296.82,21.41 294.16,21.41 293.44,20.69 293.41,20.69 293.31,20.59 293.31,19.82 293.31,19.48 293.31,19.48 293.31,19.38 293.11,19.18 291.74,19.18 291.17,19.76 290.22,19.76 290.07,19.9 284.93,19.9 284.55,19.53 283.29,19.53 282.93,19.17 281.49,19.17 279.85,17.52 278.31,17.52 277.05,16.26 269.62,16.26 266.19,12.84 263.25,12.84 261.43,11.02 250.73,11.02 249.48,12.26 230.85,12.26 228.35,14.77 186.7,14.77 185.65,13.72 176.19,13.72 175.27,12.8 161.43,12.8 161.02,13.22 148.89,13.22 148.75,13.08 146.72,13.08 146.27,13.53 129.9,13.53 128.73,14.7 106.32,14.7 105.83,14.21 101.98,14.21
  BOTTOM w0.089: v2(88.7,2.52) 88.7,2.56 88.24,3.03 88.24,3.78 88.06,3.96 88.06,4.43 UH2.BD24
EC_SMB_CK2_PX: length 24
  TOP w0.14: QV21.1 200.8,46.15 201.11,46.46 v2(201.11,46.87) 201.11,47.21 RV326.2
  IN6 w0.099: v2(209.17,60.87) 201.6,53.31 201.6,49.89 201.5,49.79 201.01,49.79 200.92,49.69 200.92,49.5 201.01,49.4 201.5,49.4 201.6,49.3 201.6,49.1 201.5,49 201.01,49 200.92,48.9 200.92,48.7 201.01,48.6 201.5,48.6 201.6,48.5 201.6,48.31 201.5,48.21 201.01,48.21 200.92,48.11 200.92,47.91 201.01,47.81 201.5,47.81 201.6,47.71 201.6,46.99 201.48,46.87 v2(201.11,46.87)
  BOTTOM w0.14: v2(209.17,60.87) 209.21,60.87 UV18.T4
EC_SMB_DA2_PX: length 24.6
  TOP w0.14: QV21.4 199.5,44.31 199.49,44.33 199.49,44.99 198.88,45.59 198.88,46.38 v2(198.96,46.45) 199.95,46.45 RV325.2
  IN6 w0.099: v2(209.19,59.3) 208.8,58.91 207.49,58.91 201.8,53.22 201.8,46.68 201.42,46.3 199.11,46.3 v2(198.96,46.45)
  BOTTOM w0.14: UV18.T3 v2(209.19,59.3)
EDP_AUXN: length 186.8
  IN1 w0.107: v2(179.15,78.25) 179.15,78.13 179.27,78.01 179.44,78.01 179.56,78.13 179.56,78.6 180.15,79.19 180.15,80.61 181.04,81.5 181.04,90.46 179.99,91.51 177.51,91.51 176.09,92.94 174.34,92.94 173.29,93.99 170.45,93.99 170.19,94.26 158.28,94.26 156.49,92.47 135.36,92.47 131,88.11 129.92,88.11 129.1,87.28 129.1,81.14 127.4,79.44 127.4,71.99 124.54,69.12 124.54,68.38 120.82,64.66 120.82,63.77 117.92,60.87 117.92,56.38 115.91,54.37 115.91,45.75 111.51,41.35 102.44,41.35 95.81,34.72 87.66,34.72 85.18,32.24 82.23,32.24 79.87,29.88 75.85,29.88 68.66,22.69 62.63,22.69 61.79,21.85 61.79,21.39 v2(62.09,21.09)
  BOTTOM w0.076: v2(179.15,78.25) 179.46,78.25 179.52,78.18 179.52,78 179.38,77.86 178.33,77.86 178.28,77.91 177.23,77.91 177.1,78.05 177.1,78.24 177.15,78.29 177.37,78.29 UH1.B26
  BOTTOM w0.152: v2(62.09,21.09) 61.89,21.29 61.89,21.69 CV166.1
EDP_AUXN_C: length 1.7
  BOTTOM w0.152: CV166.2 62.04,23.14 62.04,24.13 RV528.1
EDP_AUXN_R: length 8.7
  BOTTOM w0.152: RV528.2 61.99,25.73 v5(61.99,26.55) 61.99,27.05 62.97,28.03 62.97,29.96 64.45,31.44 64.45,31.92 64.55,32.02 JEDP1.15
EDP_AUXP: length 186.7
  IN1 w0.107: v2(61.51,21.09) 61.58,21.16 61.58,21.94 62.54,22.9 68.57,22.9 75.76,30.08 79.79,30.08 82.15,32.44 85.09,32.44 87.57,34.92 95.72,34.92 102.36,41.56 111.42,41.56 115.7,45.84 115.7,54.46 117.72,56.47 117.72,60.96 120.62,63.86 120.62,64.75 124.33,68.46 124.33,69.21 127.2,72.08 127.2,79.53 128.89,81.22 128.89,87.37 129.84,88.31 130.92,88.31 135.28,92.67 156.41,92.67 158.2,94.46 170.27,94.46 170.54,94.19 173.38,94.19 174.43,93.14 176.17,93.14 177.6,91.72 180.07,91.72 181.24,90.55 181.24,81.41 180.35,80.53 180.35,79.11 179.77,78.52 179.77,78.37 v2(179.94,78.19)
  BOTTOM w0.076: v2(179.94,78.19) 179.78,78.03 179.78,77.89 179.49,77.61 178.33,77.61 178.2,77.73 177.18,77.73 176.93,77.97 176.93,78.07 UH1.C26
  BOTTOM w0.152: CV167.1 61.56,21.81 61.56,21.14 v2(61.51,21.09)
EDP_AUXP_C: length 1.8
  BOTTOM w0.152: CV167.2 61.71,23.31 61.71,24.08 RV529.1
EDP_AUXP_R: length 8.6
  BOTTOM w0.152: RV529.2 61.66,25.68 61.66,27.19 v5(62.29,27.82) 62.64,28.16 62.64,30.1 64.12,31.58 64.12,31.92 64.05,31.99 JEDP1.16
EDP_COMP: length 2.1
  TOP w0.254: v2(176.16,85.84) 176.12,85.88 176.12,86.32 v1(176.18,86.37) 176.2,86.39 RH30.1
  BOTTOM w0.305: UH1.D37 176.1,85.78 v2(176.16,85.84)
EDP_CTRL_EN: length 8.2
  TOP w0.14: v2(295.87,18.13) 295.45,18.55 295.03,18.55 294.71,18.88 UE3.B53 ; RE107.2 291.16,19.43 291.43,19.16 v1(291.76,19.16) v2(292.24,19.64)
  BOTTOM w0.14: v2(295.87,18.13) 295.39,18.61 293.05,18.61 292.24,19.43 v2(292.24,19.64)
EDP_CTRL_EN_C: length 242.4
  TOP w0.14: v2(72.58,28.6) 72.58,24.08 71.69,23.19 70.36,23.19 69.75,23.8 UV17.5 ; v2(292.1,21.04) 292.09,21.04 RE107.1
  IN2 w0.099: v2(93.94,27.31) 94.83,28.2 100.9,28.2 103.06,30.36 114.96,30.36 115.18,30.15 139.75,30.15 142.79,27.11 144.23,27.11 146.25,25.09 153.1,25.09 154.51,23.68 154.51,21.03 158.02,17.52 172.73,17.52 172.97,17.28 175.32,17.28 175.72,16.88 180.3,16.88 181.1,16.08 247.38,16.08 248.18,15.28 250.47,15.28 251.89,16.7 259.95,16.7 261.51,18.26 264.64,18.26 264.86,18.48 268.76,18.48 269.92,17.32 277.62,17.32 278.31,18.01 280,18.01 281.24,19.25 282.74,19.25 283.68,20.19 289.93,20.19 290.54,20.8 291.86,20.8 v2(292.1,21.04)
  IN6 w0.089: v2(93.94,27.31) 93.93,27.31 ; 89.03,28.47 82.93,28.47
  IN6 w0.099: v2(72.58,28.6) 72.71,28.47 82.93,28.47 ; 89.03,28.47 92.77,28.47 93.61,27.63 93.93,27.31
EDP_DISP_UTIL: length 7.7
  BOTTOM w0.076: UH1.A33 177.74,83.74 177.74,85.2 177.92,85.38
  BOTTOM w0.14: 177.92,85.38 177.92,85.38 178.22,85.38 179.45,86.62 180.28,86.62 180.68,86.22 RH456.1 181.62,86.22 v1(182.41,87)
EDP_HPD: length 69.1
  TOP w0.127: 60.92,24.35 60.92,23.17 62.95,21.13 62.95,20.66 64.01,19.6 64.01,18.77 63.47,18.23 63.47,17.06 60.99,14.57 60.99,13.12 59.7,11.83 59.7,11.33 59.38,11 59.15,11 58.36,10.21 v2(58.36,9.15)
  TOP w0.14: 60.92,24.35 v1(60.71,24.56) 60.31,24.95 RV114.1 RV113.1 58.24,24.95 58.03,25.16 QV9.3
  IN5 w0.089: 75.06,6.85 75.33,6.85 75.61,6.57 78.5,6.57 78.53,6.59 79.08,6.59 79.36,6.31 81.59,6.31 82.19,5.7 83.08,5.7 83.52,5.26 84.13,5.26 84.55,5.68 85.34,5.68 85.88,5.14 86.56,5.14 87.22,4.49 89.5,4.49 89.78,4.2 93.96,4.2 95.55,2.61 96.71,2.61 v2(97.28,2.04)
  IN5 w0.099: v2(58.36,9.15) 58.81,9.6 59.5,9.6 61.55,7.55 67.99,7.55 68.71,8.27 72.33,8.27 73.08,7.53 73.55,7.53 73.81,7.26 73.81,7.21 74.17,6.85 75.06,6.85
  BOTTOM w0.089: v2(97.28,2.04) 97.54,2.3 97.54,3.35 97.03,3.86 96.87,3.86 96.72,4.01 96.72,4.19 96.46,4.45 UH2.BD7
EDP_HPD_S: length 12.5
  TOP w0.152: v2(61.59,28.3) 61.59,27.99 v3(61,27.4) 60.6,27.01 58.8,27.01 58.68,26.88 RV113.2 58.22,25.87 57.79,26.3 57.02,26.3 56.9,26.42 QV9.1
  BOTTOM w0.152: JEDP1.23 60.55,32.25 60.35,32.05 60.35,30.6 61.59,29.37 v2(61.59,28.3)
EDP_PANEL_CLK: length 14.5
  TOP w0.14: RV546.2 64.82,27.94 v3(65.38,28.5) 65.38,28.9 64.93,29.36 63.72,29.36 62.92,30.16 v2(62.92,31.7) ; RV546.2 64.82,27.01 65.09,26.74 65.98,26.74 66.3,27.06 67.31,27.06 67.63,26.74 67.63,25.22 67.75,25.1 UV17.7 ; RV546.2 RV549.1
  BOTTOM w0.14: v2(62.92,31.7) 62.92,32.06 63.05,32.2 JEDP1.18
EDP_PANEL_CLK_PCH: length 35.7
  TOP w0.14: v3(67.79,22.27) 67.43,22.63 v2(67.43,23.72) 66.37,22.66 63.71,22.66 63.04,23.33 RV549.2
  IN2 w0.089: 75.06,10.22 75.29,9.99 77.4,9.99 77.65,10.24 77.65,10.64 76.69,11.6 v2(76.69,11.7)
  IN2 w0.099: 75.06,10.22 74.08,11.2 73.46,11.2 72.53,12.13 72.53,21.59 71.8,22.32 68.84,22.32 v2(67.43,23.72)
  BOTTOM w0.089: v2(76.69,11.7) 76.98,11.98 78.06,11.98 UH2.AJ44
EDP_PANEL_DAT: length 22.3
  TOP w0.14: v2(71.12,30.55) 71.71,29.96 71.71,26.3 RV545.2 71.12,25.49 RV548.1 69.79,24.65 69.59,24.45 UV17.6
  IN2 w0.099: v2(71.12,30.55) 70.59,31.08 59.48,31.08 v2(58.85,31.71)
  BOTTOM w0.14: JEDP1.26 59.05,31.91 v2(58.85,31.71)
EDP_PANEL_DAT_PCH: length 19
  TOP w0.14: v2(71.2,23.63) RV548.2
  IN2 w0.089: 75.06,12.04 76.67,10.43 v2(76.69,10.43)
  IN2 w0.099: 75.06,12.04 74.83,12.27 73.65,12.27 72.73,13.19 72.73,22.1 v2(71.2,23.63)
  BOTTOM w0.089: UH2.AM44 78.03,10.29 77.79,10.05 77.07,10.05 v2(76.69,10.43)
EDP_TXN0: length 175.2
  IN1 w0.107: v2(175.77,80.2) 175.87,80.1 175.96,80.1 176.12,80.26 176.12,80.86 175.97,81.01 174.49,81.01 173.96,81.53 173.96,82.08 175.35,83.46 176.83,83.46 177.17,83.8 177.17,84.68 176.77,85.08 176.77,87.75 175.93,88.59 174.99,88.59 174.25,89.33 171.05,89.33 170.69,89.68 137.25,89.68 133.87,86.31 133.87,84.18 132.3,82.61 132.3,79.81 129.86,77.38 129.86,70.83 128.31,69.27 128.31,65.88 121.23,58.81 121.23,54.63 120.48,53.88 120.48,46.5 111.91,37.93 103.04,37.93 97.05,31.94 89.17,31.94 86.75,29.52 83.03,29.52 80.7,27.19 80.2,27.19 80.01,27 78.49,27 78.14,26.65 78.14,25.85 76.47,24.18 76.47,22.38 74.19,20.1 65.34,20.1 64.7,20.73 64.7,21.39 64.09,22.01 63.7,22.01 63.62,21.92 63.62,21.77 63.63,21.76 v2(64,21.39)
  BOTTOM w0.076: UH1.E29 175.64,80.59 175.77,80.46 v2(175.77,80.2)
  BOTTOM w0.152: v2(64,21.39) 63.79,21.59 63.79,21.69 CV159.1
EDP_TXN0_C: length 1.7
  BOTTOM w0.152: RV521.1 63.92,24.1 63.92,23.16 CV159.2
EDP_TXN0_R: length 8.5
  BOTTOM w0.152: JEDP1.12 66.05,32.02 65.95,31.92 65.95,31.33 64.26,29.64 64.26,26.73 v5(64.1,26.57) 63.91,26.37 63.91,25.71 RV521.2
EDP_TXN1: length 173.5
  IN1 w0.089: v2(175.82,79.39) 175.82,79.11 175.92,79.02 176.02,79.02 176.39,79.39 177.2,79.39 177.72,79.9 177.72,80.34 177.72,80.35
  IN1 w0.107: v2(65.9,21.39) 65.71,21.2 65.71,21.04 65.84,20.91 73.66,20.91 75.19,22.44 75.19,25.95 77.24,28 80.35,28 82.73,30.39 86.43,30.39 88.94,32.9 96.85,32.9 102.93,38.97 111.79,38.97 119.65,46.83 119.65,59.06 126.85,66.26 126.85,69.01 129.05,71.2 129.05,77.72 131.48,80.15 131.48,83.06 133,84.58 133,87.14 136.43,90.58 157.54,90.58 158.03,91.07 170.51,91.07 171.43,90.15 174.58,90.15 175.31,89.43 177.25,89.43 177.75,88.93 177.75,85.31 177.94,85.12 177.94,82.76 177.72,82.54 177.72,80.35
  BOTTOM w0.076: v2(175.82,79.39) 175.48,79.73 UH1.E28
  BOTTOM w0.152: v2(65.9,21.39) 65.76,21.53 65.76,21.75 CV161.1
EDP_TXN1_C: length 1.7
  BOTTOM w0.152: RV523.1 65.83,24.1 65.83,23.16 CV161.2
EDP_TXN1_R: length 8.4
  BOTTOM w0.152: RV523.2 65.84,25.69 v5(65.84,26.6) 65.84,27.35 65.7,27.49 65.7,29.33 67.45,31.09 67.45,31.92 67.55,32.02 JEDP1.9
EDP_TXN2: length 172.9
  IN1 w0.107: v2(70.22,21.39) 70.17,21.44 70.17,23.18 76.24,29.25 80.13,29.25 82.48,31.61 85.92,31.61 88.34,34.02 96.22,34.02 102.5,40.3 111.33,40.3 117.33,46.29 117.33,54.7 118.58,55.96 118.58,59.94 122.64,64 122.64,64.84 125.16,67.36 125.16,68.84 128.02,71.7 128.02,78.14 130.37,80.49 130.37,86.6 135.58,91.81 156.86,91.81 158.66,93.61 169.8,93.61 170.2,93.21 173.14,93.21 173.79,92.57 173.79,91.68 174.16,91.31 175.27,91.31 176.1,90.48 178.07,90.48 178.37,90.18 179.28,90.18 179.98,89.48 179.98,87.01 180.26,86.73 180.26,82.14 179.03,80.9 179.03,80.37 v2(179.52,79.88)
  BOTTOM w0.076: UH1.B29 177.57,80.45 177.57,80.3 177.77,80.09 178.24,80.09 178.42,80.27 179.12,80.27 v2(179.52,79.88)
  BOTTOM w0.152: v2(70.22,21.39) 70.08,21.53 70.08,21.75 CV163.1
EDP_TXN2_C: length 1.7
  BOTTOM w0.152: CV163.2 70.14,23.16 70.14,24.1 RV525.1
EDP_TXN2_R: length 8.5
  BOTTOM w0.152: RV525.2 70.13,25.71 70.13,26.02 69.79,26.36 69.79,26.76 70.17,27.14 v5(70.17,27.98) 70.17,29.41 68.95,30.63 68.95,31.92 69.05,32.02 JEDP1.6
EDP_TXN3: length 170.1
  IN1 w0.107: v2(178.89,79.13) 179.03,78.99 179.03,78.81 178.91,78.7 178.69,78.7 178.39,78.99 178.39,79.57 178.28,79.68 178.28,80.83 179.21,81.77 179.21,85.1 178.21,86.1 178.21,89.16 177.53,89.84 175.6,89.84 174.81,90.64 171.58,90.64 170.69,91.53 157.9,91.53 157.36,90.99 135.91,90.99 132.4,87.49 132.4,86.33 131.07,85 131.07,80.32 128.63,77.89 128.63,71.41 125.8,68.57 125.8,65.83 119.22,59.25 119.22,47.14 111.5,39.43 102.57,39.43 96.54,33.4 88.58,33.4 86.02,30.83 82.58,30.83 80.17,28.42 76.4,28.42 71.92,23.93 71.92,21.59 v2(72.12,21.39)
  BOTTOM w0.076: v2(178.89,79.13) 179,79.13 179.19,79.32 179.19,79.43 179.11,79.52 178.71,79.52 178.55,79.36 178.41,79.36 178.28,79.49 177.27,79.49 177.11,79.65 177.11,79.78 177.21,79.88 177.35,79.88 UH1.B28
  BOTTOM w0.152: CV165.1 71.98,21.75 71.98,21.53 v2(72.12,21.39)
EDP_TXN3_C: length 1.7
  BOTTOM w0.152: CV165.2 72.04,23.17 72.04,24.09 RV527.1
EDP_TXN3_R: length 8.3
  BOTTOM w0.152: RV527.2 72.05,25.7 v5(72.05,27.92) 72.05,28.94 70.45,30.54 70.45,31.91 70.55,32.01 70.55,32.08 JEDP1.3
EDP_TXP0: length 175.2
  IN1 w0.107: v2(63.41,21.39) 63.41,22 63.62,22.21 64.17,22.21 64.91,21.48 64.91,20.82 65.42,20.3 74.1,20.3 76.26,22.46 76.26,24.26 77.94,25.94 77.94,26.74 78.4,27.2 79.93,27.2 80.12,27.39 80.61,27.39 82.95,29.73 86.67,29.73 89.08,32.14 96.96,32.14 102.96,38.13 111.82,38.13 120.28,46.59 120.28,53.96 121.02,54.71 121.02,58.89 128.1,65.97 128.1,69.36 129.66,70.91 129.66,77.46 132.09,79.89 132.09,82.69 133.67,84.27 133.67,86.39 137.17,89.89 170.78,89.89 171.13,89.53 174.33,89.53 175.07,88.79 176.01,88.79 176.98,87.83 176.98,85.16 177.37,84.77 177.37,83.71 176.91,83.26 175.43,83.26 174.17,81.99 174.17,81.62 174.57,81.21 176.05,81.21 176.32,80.94 176.32,80.39 v2(176.5,80.21)
  BOTTOM w0.076: UH1.D29 176.14,80.59 176.5,80.23 v2(176.5,80.21)
  BOTTOM w0.152: CV158.1 63.46,21.81 63.46,21.44 v2(63.41,21.39)
EDP_TXP0_C: length 1.8
  BOTTOM w0.152: RV520.1 63.59,24.1 63.59,23.29 CV158.2
EDP_TXP0_R: length 8.5
  BOTTOM w0.152: RV520.2 63.58,25.69 63.58,26.51 63.93,26.86 v5(63.93,27.89) 63.93,29.78 65.62,31.47 65.62,31.92 65.55,31.99 JEDP1.13
EDP_TXP1: length 173.6
  IN1 w0.089: v2(175.17,79.39) 175.54,79.75 175.97,79.75 176.15,79.57 177.12,79.57 177.53,79.98 177.53,80.32 177.52,80.33 177.52,80.35
  IN1 w0.107: v2(65.32,21.39) 65.51,21.2 65.51,20.96 65.75,20.71 73.75,20.71 75.39,22.35 75.39,25.87 77.32,27.8 80.43,27.8 82.81,30.18 86.51,30.18 89.02,32.69 96.93,32.69 103.01,38.77 111.88,38.77 119.85,46.74 119.85,58.98 127.05,66.18 127.05,68.92 129.25,71.12 129.25,77.63 131.68,80.07 131.68,82.98 133.2,84.49 133.2,87.06 136.52,90.38 157.63,90.38 158.11,90.86 170.43,90.86 171.34,89.95 174.5,89.95 175.22,89.23 177.17,89.23 177.55,88.85 177.55,85.23 177.74,85.04 177.74,82.84 177.52,82.63 177.52,80.35
  BOTTOM w0.076: UH1.F28 174.83,79.73 v2(175.17,79.39)
  BOTTOM w0.152: CV160.1 65.43,21.75 65.43,21.5 v2(65.32,21.39)
EDP_TXP1_C: length 1.8
  BOTTOM w0.152: CV160.2 65.49,23.29 65.49,24.1 RV522.1
EDP_TXP1_R: length 8.4
  BOTTOM w0.152: JEDP1.10 67.05,31.99 67.12,31.92 67.12,31.22 65.37,29.47 65.37,27.35 65.51,27.22 65.51,25.71 RV522.2
EDP_TXP2: length 172.8
  IN1 w0.107: v2(179.46,80.5) 179.27,80.69 179.27,80.86 180.47,82.05 180.47,86.81 180.18,87.1 180.18,89.56 179.36,90.38 178.46,90.38 178.15,90.68 176.19,90.68 175.36,91.51 174.25,91.51 173.99,91.77 173.99,92.66 173.23,93.42 170.28,93.42 169.89,93.81 158.57,93.81 156.77,92.01 135.49,92.01 130.16,86.68 130.16,80.57 127.82,78.23 127.82,71.78 124.96,68.92 124.96,67.45 122.44,64.93 122.44,64.08 118.38,60.02 118.38,56.04 117.13,54.79 117.13,46.38 111.25,40.5 102.42,40.5 96.14,34.22 88.25,34.22 85.84,31.81 82.4,31.81 80.04,29.45 76.16,29.45 69.97,23.26 69.97,21.72 v2(69.64,21.39)
  BOTTOM w0.076: UH1.A29 177.97,80.7 177.84,80.7 177.75,80.62 177.75,80.36 177.84,80.27 178.19,80.27 178.38,80.46 179.42,80.46 v2(179.46,80.5)
  BOTTOM w0.152: v2(69.64,21.39) 69.75,21.5 69.75,21.75 CV162.1
EDP_TXP2_C: length 1.8
  BOTTOM w0.152: RV524.1 69.81,24.1 69.81,23.29 CV162.2
EDP_TXP2_R: length 8.4
  BOTTOM w0.152: JEDP1.7 68.55,31.99 68.62,31.92 68.62,30.49 69.84,29.27 69.84,27.28 69.46,26.9 v5(69.46,26.56) 69.46,26.22 69.8,25.88 69.8,25.69 RV524.2
EDP_TXP3: length 170.2
  IN1 w0.107: v2(179.54,79.12) 179.14,79.51 178.74,79.51 178.48,79.76 178.48,80.75 179.42,81.68 179.42,85.18 178.41,86.18 178.41,89.25 177.62,90.04 175.69,90.04 174.89,90.84 171.67,90.84 170.78,91.73 157.81,91.73 157.28,91.2 135.82,91.2 132.2,87.57 132.2,86.42 130.86,85.08 130.86,80.4 128.43,77.97 128.43,71.49 125.6,68.66 125.6,65.91 119.01,59.33 119.01,47.23 111.42,39.63 102.49,39.63 96.46,33.6 88.5,33.6 85.93,31.03 82.5,31.03 80.08,28.62 76.32,28.62 71.72,24.02 71.72,21.57 v2(71.54,21.39)
  BOTTOM w0.076: v2(179.54,79.12) 179.19,78.77 178.74,78.77 178.2,79.31 177.19,79.31 176.9,79.6 176.9,79.69 UH1.C28
  BOTTOM w0.152: v2(71.54,21.39) 71.65,21.5 71.65,21.75 CV164.1
EDP_TXP3_C: length 1.8
  BOTTOM w0.152: RV526.1 71.71,24.11 71.71,23.28 CV164.2
EDP_TXP3_R: length 8.3
  BOTTOM w0.152: RV526.2 71.72,25.7 v5(71.72,26.58) 71.72,28.8 70.12,30.4 70.12,31.92 70.05,31.99 JEDP1.4
EN_INVPWR: length 299.7
  TOP w0.14: UE3.A25 304.72,15.63 304.9,15.44 v2(305.22,15.44) ; v3(310.53,24.41) 310.53,24.09 v2(309.77,23.33)
  IN1 w0.099: v2(309.77,23.33) 309.3,23.33 306.68,20.71 301.11,20.71 300.59,20.18 296.31,20.18 296.15,20.34 294.65,20.34 294.44,20.55 290.67,20.55 290.2,20.07 285.88,20.07 283.89,18.09 282.02,18.09 281.39,17.46 278.87,17.46 277.68,16.28 270.81,16.28 266.62,12.08 266.13,12.08 263.92,9.87 262.44,9.87 261.81,9.24 248.87,9.24 248.04,10.07 233.87,10.07 233.65,9.85 215.36,9.85 213.63,11.58 201.95,11.58 200.91,10.54 196.99,10.54 196.91,10.46 188.05,10.46 187.97,10.38 183.94,10.38 183.57,10.75 178.71,10.75 177.62,11.85 154.61,11.85 154.13,12.33 149.58,12.33 149.23,12.68 130.61,12.68 128.39,14.9 105.51,14.9 104.9,14.29 103.33,14.29 102.15,13.1 99.23,13.1 99,12.88 96.62,12.88 96.13,13.36 96.13,14.1 95.48,14.75 92.32,14.75 91.18,13.61 84.95,13.61 84.64,13.31 78.61,13.31 78.17,13.75 71.12,13.75 69.81,12.44 59.4,12.44 57.46,14.38 54.08,14.38 53.38,15.09 53.38,18.39 53.94,18.95 53.94,19.54 53.16,20.32 v2(52.12,20.32)
  BOTTOM w0.14: v2(305.22,15.44) 305.22,15.57 305.73,16.07 310.38,16.07 310.91,16.61 310.91,22.18 v2(309.77,23.33) ; v2(52.12,20.32) 52.12,20.8 53.22,21.9 53.98,21.9 RV135.1 53.39,23 52.29,23 51.8,23.48 QV12.2
EN_PD_HV: length 79
  TOP w0.254: PU204.1 v2(10.86,2.75) ; v2(10.86,2.75) 10.93,2.75 11.52,2.17 12.57,2.17 12.83,2.42 PR234.1 ; v2(10.86,2.75) 11.23,3.12 PR270.1
  IN5 w0.099: v2(19.88,52.8) 19.86,52.8 18.4,51.34 18.4,40.19 19.18,39.42 19.18,35.57 18.67,35.06 18.67,32.36 19.96,31.07 19.96,29.58 15.06,24.68 15.06,22.36 16.12,21.3 16.66,21.3 18.8,19.16 20.86,19.16 22.8,17.22 22.8,3.31 22.04,2.55 16,2.55 15.75,2.29 15.18,2.29 14.92,2.55 11.47,2.55 11.26,2.75 v2(10.86,2.75)
  BOTTOM w0.14: v2(19.88,52.8) 19.85,52.83 18.37,52.83 v1(17.34,53.86) RT178.2
ENVDD: length 7.1
  TOP w0.14: DV7.1 36.39,28.72 37.05,28.06 38.65,28.06 RZ40.1 39.28,29.83 v3(39.45,30) 39.73,30.28 40.23,30.28 40.73,29.78 UZ8.4
ENVDD_PCH: length 298.9
  TOP w0.089: v1(78.5,16.95) 78.5,16.46 v2(78.78,16.18)
  TOP w0.14: UE3.A7 298.27,9.22 v2(298.21,9.15) ; v2(36.06,32.18) 35.74,31.86 DV7.3
  IN5 w0.099: v2(61.33,18.78) 61.33,18.78 62.97,17.14 65.56,17.14 65.56,17.14 65.95,17.14 65.96,17.14 66.5,16.6 74.28,16.6 74.36,16.68 77.61,16.68 78.11,16.18 v2(78.78,16.18)
  IN6 w0.089: v2(78.78,16.18) 79.12,16.51 83.69,16.51 84.21,17.04 84.21,17.55 85.28,18.61 90.23,18.61 90.69,18.16 90.69,16.64 91.76,15.58 96.93,15.58 97.14,15.37 98.05,15.37 98.71,14.72 100.94,14.72 101.64,14.01 101.98,14.01
  IN6 w0.099: v2(281.05,17.92) 280.45,17.32 278.6,17.32 277.35,16.06 269.7,16.06 266.2,12.56 263.25,12.56 261.51,10.82 250.64,10.82 249.67,11.8 236.94,11.8 236.51,11.36 235.2,11.36 234.57,11.99 230.84,11.99 228.26,14.56 186.78,14.56 185.73,13.52 176.27,13.52 175.35,12.6 161.35,12.6 160.93,13.01 148.97,13.01 148.84,12.88 146.64,12.88 146.19,13.33 129.81,13.33 128.64,14.5 106.4,14.5 105.91,14.01 101.98,14.01 ; v2(61.33,18.78) 60.35,19.76 60.35,21.83 59.28,22.91 57.22,22.91 55.01,25.12 48.27,25.12 47.36,26.03 46.35,26.03 v2(44.95,27.44)
  BOTTOM w0.089: v2(78.78,16.18) 79.12,16.51 UH2.W42
  BOTTOM w0.14: v2(36.06,32.18) 36.06,32.22 36.62,32.77 43.13,32.77 44.98,30.93 44.98,27.47 v2(44.95,27.44) ; v2(298.21,9.15) 298.63,8.73 298.63,7.71 298.2,7.27 296.01,7.27 295.54,6.81 289.28,6.81 289.17,6.92 284.47,6.92 281.44,9.94 281.44,17.52 v2(281.05,17.92)
FAN1_PWM: length 246.9
  TOP w0.14: RE100.2 99.42,32.53 v2(99.78,32.53) 100.88,32.53 101.51,31.9 v3(101.96,31.9) ; UE3.A24 304.86,15.13 305,14.98 305.41,14.98 v2(305.84,15.41)
  IN2 w0.099: v2(305.88,27.14) 305.88,26.43 305.32,25.87 299.11,25.87 298.49,25.25 297.83,25.25 296.8,24.22 293.96,24.22 292.25,22.51 292.08,22.51 291.72,22.15 290.99,22.15 290.22,21.37 282.34,21.37 280.97,20 279.2,20 278.31,19.11 274.3,19.11 273.47,19.94 268.59,19.94 267.54,18.88 264.7,18.88 264.48,18.66 261.35,18.66 259.78,17.1 251.72,17.1 250.41,15.79 248.24,15.79 246.75,17.28 175.89,17.28 175.4,17.77 173.05,17.77 172.85,17.97 158.74,17.97 156.96,19.75 156.96,24.31 156.61,24.66 154.95,24.66 153.63,25.98 146.39,25.98 144.87,27.5 144.6,27.5 140.82,31.29 116.08,31.29 113.55,33.81 102.98,33.81 102.38,34.42 101.1,34.42 99.78,33.1 v2(99.78,32.53)
  IN4 w0.091: v2(305.88,27.14) 305.78,27.03 305.78,24.8 305.18,24.2 304.55,24.2 304.17,23.82 304.17,21.09 304,20.93 304,15.46 304.43,15.04 305.47,15.04 v2(305.84,15.41)
  BOTTOM w0.127: JFAN1.1 99.03,35.2 99.16,35.07 99.16,33.16 v2(99.78,32.53)
FAN1_TACH: length 247.5
  TOP w0.14: DE7.2 100.03,34.81 CE66.1 RE81.2 102.1,33.99 v2(102.12,33.99) 102.48,33.99 v3(103.06,34.58) ; UE3.B22 302.59,13.38 v2(302.15,12.94)
  IN2 w0.099: v2(102.12,33.99) 102.5,33.61 113.42,33.61 115.95,31.08 140.74,31.08 144.52,27.3 144.61,27.3 146.63,25.29 153.95,25.29 154.88,24.37 155.19,24.37 155.78,23.78 155.78,20.07 158.09,17.77 172.77,17.77 173,17.54 175.35,17.54 175.81,17.08 180.48,17.08 181.24,16.32 247.43,16.32 248.17,15.58 250.48,15.58 251.8,16.9 259.87,16.9 261.43,18.46 264.56,18.46 264.78,18.68 267.62,18.68 268.67,19.74 273.39,19.74 274.21,18.91 278.39,18.91 279.28,19.8 281.05,19.8 282.4,21.14 291.62,21.14 291.93,21.45 292.27,21.45 292.48,21.23 292.8,21.23 295.01,23.45 296.76,23.45 297.57,24.27 299.44,24.27 300.8,25.63 305.54,25.63 306.57,26.67 308.28,26.67 v2(308.74,27.12)
  BOTTOM w0.14: v2(308.74,27.12) 308.52,26.91 308.52,25 308.03,24.51 308.03,19.66 308.24,19.44 308.24,17.9 307.76,17.43 305.04,17.43 303.91,16.3 303.91,14.22 303.09,13.39 302.45,13.39 302.15,13.09 v2(302.15,12.94)
FAN2_PWM: length 52.6
  TOP w0.14: RE101.2 319.76,40.15 v2(319.74,40.18) 319.13,40.18 318.62,39.67 318.62,38.94 318.76,38.8 v3(318.76,37.02) 318.76,36.72 319.52,35.96 324.63,35.96 325.49,36.83 v2(326.09,36.83) ; UE3.A23 305.69,14.63 v2(306.45,15.39)
  IN1 w0.099: v2(306.45,15.39) 307.26,16.2 307.28,16.2 307.63,16.56 307.63,17.16 309.11,18.64 313.2,18.64 318.99,24.42 318.99,27.51 323.28,31.8 323.28,34.21 325.9,36.83 v2(326.09,36.83)
  BOTTOM w0.14: v2(319.74,40.18) 320.98,38.94 321.75,38.94 321.95,38.74 323.36,38.74 323.5,38.88 JFAN2.1
FAN2_TACH: length 40.6
  TOP w0.102: v1(323.85,38.31) CE67.1
  TOP w0.14: UE3.B23 302.97,13.88 v2(302.95,13.85) ; DE8.2 322.84,39.06 CE67.1 v2(322.2,38.31) 321.88,37.99 RE83.2
  IN6 w0.099: v2(302.95,13.85) 303.8,13.85 304.67,14.72 306.64,14.72 307.85,15.93 311.8,15.93 312.57,16.7 312.57,17.2 316.36,20.99 316.36,24.94 316.82,25.39 316.82,27.32 320.19,30.69 320.19,34.58 321.08,35.47 321.08,37.19 v2(322.2,38.31)
FB_1.8V: length 4.8
  BOTTOM w0.14: PR1405.1 243.75,107.12 243.13,107.12 v1(242.93,107.32)
  BOTTOM w0.254: PC1401.2 PR1402.2 243.98,107.45 PR1405.1 244.59,106.84 245.01,106.84 245.17,107.01 PU1400.1
FB_3V: length 6
  TOP w0.14: v1(348.46,24.08) 347.97,23.58 v2(347.97,23.55)
  TOP w0.203: PR403.2 347.83,22.11 347.12,22.11 346.84,21.83 346.84,21.13 346.41,20.7 PU400.4
  TOP w0.254: PR403.2 PR401.2 347.96,23.54 v2(347.97,23.55)
  BOTTOM w0.254: PC401.2 v2(347.97,23.55)
FB_5V: length 4.1
  TOP w0.203: PU400.2 346.53,19.9 346.78,19.65 v2(347.06,19.65) 347.23,19.82 PR404.1
  TOP w0.254: PR404.1 PR402.1
  BOTTOM w0.254: PC402.1 347.23,19.82 v2(347.06,19.65)
FBA_ABI#_H: length 28.5
  TOP w0.102: 207.14,89.54 206.88,89.29 206.76,89.29 206.05,88.58 206.05,87.4 206.85,86.59 206.85,85.8 206.88,85.76 206.88,83.57 207.13,83.33 v2(207.13,81.45) ; 212.71,96.92 212.71,97.79 212.73,97.82 212.73,102.1 213.15,102.52 v2(213.15,103.58)
  TOP w0.221: 207.14,89.54 207.14,91.12 v1(210.5,94.48) 212.71,96.69 212.71,96.92
  BOTTOM w0.102: v2(213.15,103.58) 213.23,103.65 213.23,104.15 213.12,104.26 212.86,104.26 212.75,104.16 UV24.J4 ; UV18.Y29 206.77,81.98 207,81.98 207.14,81.84 207.14,81.47 v2(207.13,81.45)
FBA_ABI#_L: length 40.2
  TOP w0.102: v2(207.56,81.01) 207.96,81.41 207.96,82.88 208.22,83.13 208.22,86.53 208.09,86.66 208.09,86.97 210.67,89.54 210.82,89.54 ; v2(229.61,104.38) 229.23,104 228.65,104 228.41,104.24 228.41,104.52 228.17,104.76 227.85,104.76 227.63,104.53 227.63,104.26 227.12,103.75 226.77,103.75
  TOP w0.221: 226.77,103.75 226.17,103.75 v1(224.27,101.85) 221.98,99.55 221.98,94.26 220.67,92.95 216.4,92.95 215.06,91.61 212.89,91.61 210.82,89.54
  BOTTOM w0.102: UV23.J4 v2(229.61,104.38) ; UV18.V28 207.94,80.63 v2(207.56,81.01)
FBA_CAS#_H: length 32.6
  TOP w0.102: 215.98,103.97 215.03,103.97 214.22,104.78 213.55,104.78 v2(213.15,105.18) ; v2(207.53,83.51) 207.14,83.9 207.14,85.28 207.61,85.75 207.61,87.59 209.37,89.34 209.37,89.54
  TOP w0.221: 215.98,103.97 215.98,103.98 216.55,103.98 217.8,102.73 v1(217.8,99.2) 217.8,96.35 216.59,95.14 214.27,95.14 209.37,90.23 209.37,89.54
  BOTTOM w0.102: UV24.G3 213.6,105.53 213.6,105.33 213.37,105.1 213.23,105.1 v2(213.15,105.18) ; v2(207.53,83.51) 207.6,83.57 207.77,83.57 208.02,83.33 208.02,83.18 UV18.V31
FBA_CAS#_L: length 39.1
  TOP w0.102: 226.77,105.65 226.86,105.74 227.38,105.74 227.95,105.16 v2(228.79,105.16)
  TOP w0.221: v2(213.68,93.1) 214.99,94.41 219.93,94.41 220.52,94.99 220.52,100.16 225.59,105.23 226.35,105.23 226.77,105.65
  BOTTOM w0.102: 205.93,88.41 205.93,87.8 206.18,87.55 206.18,86.56 206.12,86.5 206.12,85.85 205.91,85.64 205.91,85.36 205.93,85.34 205.93,84.86 205.91,84.84 205.91,84.56 205.93,84.54 205.93,84.2 UV18.Y32 ; UV23.L3 229.2,105.58 v2(228.79,105.16)
  BOTTOM w0.221: 205.93,88.41 205.93,88.97 v1(209.07,92.11) 210.06,93.1 v2(213.68,93.1)
FBA_CKE_H: length 29.7
  TOP w0.102: 208.64,89.34 206.93,87.64 v2(206.84,87.64)
  TOP w0.221: 208.64,89.34 208.64,90.53 213.97,95.86 216.29,95.86 217.07,96.65 217.07,102.22 216.39,102.9 215.43,102.9 v2(213.95,104.38) 213.21,104.38 RV607.2
  BOTTOM w0.102: UV24.J3 v2(213.95,104.38) ; v2(206.84,87.64) 206.69,87.49 206.69,87.32 206.65,87.28 206.65,86.01 206.66,85.99 206.66,85.86 206.63,85.82 206.63,85.28 206.24,84.89 UV18.Y33
FBA_CKE_L: length 36.2
  TOP w0.102: 226.77,103.02 227.75,103.99 228.14,103.99 228.55,103.58 v2(228.81,103.58) 228.81,103.49 229.11,103.2 230.05,103.2 RV605.2 ; v2(209,87.18) 211.21,89.39 211.7,89.39 211.85,89.54
  TOP w0.221: 211.85,89.54 213.19,90.88 215.37,90.88 216.71,92.22 220.97,92.22 222.71,93.96 222.71,99.25 226.47,103.02 226.77,103.02
  BOTTOM w0.102: UV23.J3 v2(228.81,103.58) ; UV18.V33 207.56,85.08 207.56,85.67 207.79,85.91 207.79,86.64 208.33,87.18 v2(209,87.18)
FBA_CLK0: length 53.5
  TOP w0.17: v2(220.94,107.57) 221.06,107.69 221.06,107.94 RV622.1
  IN1 w0.097: v2(220.94,107.57) 220.94,98.59 214.94,92.59 214.11,92.59 209.86,88.34 209.86,86.61 209.68,86.43 209.67,86.43 209.12,85.87 209.12,84.54 208.63,84.04 208.63,83.11 209.52,82.21 210.55,82.21 v2(210.84,81.92)
  IN6 w0.097: v2(220.94,107.57) 221.04,107.68 221.04,108.09 221.27,108.32 223.08,108.32 224.65,106.75 226.77,106.75 226.77,106.75
  IN6 w0.102: v2(236.81,104.38) 236.67,104.52 236.67,104.74 236.38,105.03 235.77,105.03 235.53,104.79 234.18,104.79 232.03,106.94 231.13,106.94 230.59,106.4 228.58,106.4 228.22,106.75 226.77,106.75
  BOTTOM w0.102: UV23.J12 v2(236.81,104.38)
  BOTTOM w0.114: v2(210.84,81.92) 210.46,82.3 UV18.R30
FBA_CLK0#: length 53.4
  TOP w0.17: RV621.1 221.47,108.01 221.47,107.62 v2(221.52,107.57)
  IN1 w0.097: v2(210.82,82.7) 210.82,82.49 210.72,82.39 209.6,82.39 208.8,83.18 208.8,83.97 209.3,84.46 209.3,85.8 210.03,86.54 210.03,88.27 214.18,92.42 215.01,92.42 221.11,98.52 221.11,107.17 221.34,107.4 221.34,107.43 221.48,107.57 v2(221.52,107.57)
  IN6 w0.097: v2(221.52,107.57) 221.51,107.57 221.22,107.85 221.22,108.03 221.34,108.15 223.01,108.15 224.58,106.58 226.77,106.58 226.77,106.58
  IN6 w0.102: 226.77,106.58 228.14,106.58 228.5,106.22 230.67,106.22 231.21,106.76 231.96,106.76 234.11,104.61 235.6,104.61 235.84,104.85 236.31,104.85 236.46,104.7 236.46,104.56 236.43,104.53 236.43,104.37 236.36,104.3 236.09,104.3 v2(236.01,104.38)
  BOTTOM w0.114: v2(210.82,82.7) 210.44,83.09 UV18.R31 ; UV23.J11 v2(236.01,104.38)
FBA_CLK1: length 43.7
  TOP w0.17: v2(219.2,101.04) 219.36,101.2 219.36,102.57 RV627.1
  IN1 w0.097: v2(204.16,83.5) 204.04,83.38 204.04,83.24 204.16,83.12 204.39,83.12 206.31,85.04 206.31,86.12 208.81,88.62 208.81,89.22 213.52,93.93 215.31,93.93 219.39,98 219.39,100.85 v2(219.2,101.04)
  IN6 w0.097: v2(219.2,101.04) 219.24,101.04 219.43,101.23 219.43,101.45 218.13,102.75 213.19,102.75 212.16,103.78 211.13,103.78 210.87,104.03 207.02,104.03 206.95,103.96 206.73,103.76 v2(206.73,103.61)
  BOTTOM w0.102: v2(206.73,103.61) 206.69,103.64 206.69,103.64 UV24.J12
  BOTTOM w0.114: UV18.AB31 204.56,83.1 v2(204.16,83.5)
FBA_CLK1#: length 43.6
  TOP w0.17: v2(219.79,101.04) 219.69,101.13 219.69,102.57 RV626.1
  IN1 w0.097: v2(219.79,101.04) 219.57,100.82 219.57,97.93 215.39,93.75 213.59,93.75 208.99,89.15 208.99,88.55 206.49,86.04 206.49,84.97 v2(204.22,82.7)
  IN6 w0.097: v2(206.76,104.34) 206.87,104.21 210.95,104.21 211.2,103.95 212.23,103.95 213.26,102.92 218.2,102.92 219.61,101.52 219.61,101.22 v2(219.79,101.04)
  BOTTOM w0.114: UV18.AC31 203.82,83.1 v2(204.22,82.7) ; UV24.J11 206.79,104.34 v2(206.76,104.34)
FBA_CS#_H: length 28.2
  TOP w0.102: v2(205.01,82.69) 204.63,83.08 203.62,83.08 202.89,83.81 202.89,86.17 201.99,87.07 201.33,87.07 200.91,87.5 200.91,89.54 ; v2(206.75,102.78) 206.23,103.3 204.85,103.3 203.91,102.36
  TOP w0.221: 200.91,89.54 v1(200.91,92.62) 200.91,99.35 203.91,102.36
  BOTTOM w0.102: UV18.AA31 205.42,83.1 v2(205.01,82.69) ; UV24.L12 v2(206.75,102.78)
FBA_CS#_L: length 41.1
  TOP w0.102: 233.74,96.92 233.74,100.47 234.84,101.56 235.59,101.56 v2(236.01,101.98) ; v2(209.11,81.88) 209.53,82.31 210.96,82.31 211.27,82.61
  TOP w0.119: 215.22,85.92 214.94,85.63 213.26,85.63 212.98,85.35 212.53,85.35 212.12,84.94 212.12,83.41 211.8,83.09 211.5,83.09 211.27,82.86 211.27,82.61
  TOP w0.221: 215.22,85.92 216.43,85.92 216.57,85.78 216.95,85.78 217.12,85.61 221.21,85.61 221.74,85.08 223.53,85.08 v1(225.57,87.12) 233.74,95.29 233.74,96.92
  BOTTOM w0.102: UV18.U30 208.74,82.25 v2(209.11,81.88)
  BOTTOM w0.107: UV23.G12 v2(236.01,101.98)
FBA_D0: length 28
  IN6 w0.102: 215.66,87.39 215.29,87.02 215.29,85.85 214.82,85.38 214.82,84.17 213.59,82.94 213.59,80.79 v2(214.15,80.23) ; v2(229.7,97.04) 229.7,96.92
  IN6 w0.117: 215.66,87.39 215.66,87.47 223.27,95.08 228.38,95.08 229.7,96.39 229.7,96.92
  BOTTOM w0.102: v2(229.7,97.04) 230.01,97.36 UV23.A4 ; UV18.L28 213.82,80.6 214.15,80.27 v2(214.15,80.23)
FBA_D1: length 26.3
  IN6 w0.102: 214.31,87.1 214.31,85.73 213.73,85.16 213.73,83.69 213,82.96 213,81.51 v2(212.51,81.02)
  IN6 w0.117: 214.31,87.1 214.31,87.6 223.73,97.02 v2(228.1,97.02)
  BOTTOM w0.102: UV23.A2 228.1,97.26 v2(228.1,97.02) ; UV18.M29 v2(212.51,81.02)
FBA_D2: length 28.4
  IN6 w0.102: 216.32,87.39 215.49,86.56 215.49,85.77 215.08,85.35 215.08,84.14 213.8,82.86 213.8,81.39 v2(214.16,81.02) ; v2(229.59,97.99) 230.32,97.27 230.32,96.92
  IN6 w0.117: 230.32,96.92 230.32,96.27 228.52,94.48 223.42,94.48 216.32,87.39
  BOTTOM w0.102: UV18.L29 213.74,81.44 v2(214.16,81.02) ; v2(229.59,97.99) 229.63,97.99 UV23.B4
