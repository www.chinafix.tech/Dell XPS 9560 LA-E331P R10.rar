# Allegro board Dell XPS 9560 LA-E331P R10.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FFS_INT2_Q: length 89.9
  TOP w0.14: v2(236.86,9.39) 235.96,8.5 RD100.2 ; v2(263.22,9.07) v3(263.22,10.87) 263.22,11.57 264.36,12.72 264.36,13.13 265.06,13.82 265.06,17.92 263.35,19.63 263.35,20.63 262.23,21.74 262.23,22.86 260.41,24.69 260.41,27.91 259.96,28.36 259.96,30.99 250.33,40.62 234.06,40.62 232.93,41.75 RF2.2 233.48,42.53 233.59,42.41 QF1.3
  IN3 w0.091: v2(236.86,9.39) 237.53,8.72 242.88,8.72 244.22,7.38 256.41,7.38 258.1,9.07 v2(263.22,9.07)
  BOTTOM w0.14: v2(236.86,9.39) 236.36,9.88 JHDD.11
FRM_LCK: length 0.8
  TOP w0.14: RV564.1 214.11,48.31 RV1100.2
FWP#: length 13.9
  TOP w0.14: v2(289.55,9.81) 289.33,9.6 288.66,9.6 288.42,9.36 288.42,8.91 288.56,8.77 v1(288.56,8.44) 288.52,8.4 288.1,8.4 RE68.2 286.79,8.85 RE70.2 ; UE3.B65 295.08,12.88 v2(295.85,13.64)
  BOTTOM w0.14: v2(295.85,13.64) 295.4,13.19 294.35,13.19 291.67,10.51 290.25,10.51 v2(289.55,9.81)
GC5_MODE: length 1.2
  TOP w0.14: RV1088.2 213.27,46.82 T210.1
GC6_EVENT#_D: length 5.9
  TOP w0.14: v1(213.64,41.8) 213.64,43.04 213.44,43.24 RV1120.2 213.22,43.52 213.49,43.79 213.49,44.51 RV551.1 214.12,44.89 DV14.2 214.8,44.14 RV1097.2
GPU_CORE_PG: length 132.5
  TOP w0.254: v2(176.65,109.38) 176.65,109.86 177.09,110.31 177.09,111.07 176.9,111.26 176.9,111.32 176.53,111.69 176.53,112.33 176.15,112.71 174.52,112.71 v1(173.65,113.58) 173.18,114.05 PR1017.2 ; RV1522.2 243.86,41.78 DV16.3 246.27,41.78 v2(246.37,41.68)
  IN3 w0.254: v2(246.37,41.68) 246.23,41.68 245.14,40.58 238.94,40.58 234.86,44.66 233.93,44.66 228.5,50.1 223.58,50.1 220.18,53.5 219.33,53.5 218.58,54.25 216.7,54.25 216.45,54.5 216.45,54.54 215.95,55.04 210.08,55.04 208.23,56.89 200.29,56.89 199.6,57.58 196.13,57.58 195.52,58.19 190.75,58.19 183.68,65.26 183.68,70.39 183.29,70.79 183.29,73.46 184.31,74.48 184.31,82.62 183.04,83.89 182.26,83.89 180.92,85.22 180.92,86.54 179.99,87.48 179.99,92.88 178.3,94.57 178.3,107.73 v2(176.65,109.38)
GPU_CORE_VDDS_PG: length 71.4
  TOP w0.14: v2(242.43,109.29) 243.02,109.29 v1(243.18,109.13)
  TOP w0.254: PR986.1 v2(242.43,109.29) ; v2(183.01,119.13) 182.69,119.45 PR1518.2
  IN4 w0.254: v2(242.43,109.29) 241.39,108.25 241.2,108.25 240.51,108.94 240.51,111.1 240.26,111.34 230.72,111.34 230.23,111.83 227.95,111.83 224.92,114.86 224.92,116.7 223.88,117.74 220.17,117.74 218.66,119.24 218.66,119.47 217.68,120.45 201.42,120.45 200.18,119.21 197.8,119.21 197.63,119.03 186.04,119.03 185.46,119.62 183.49,119.62 v2(183.01,119.13)
GPU_EVENT#: length 154.6
  TOP w0.14: DV14.1 214.88,42.74 v1(215.21,43.07) v2(215.58,43.44)
  IN5 w0.089: 101.98,12.67 101.94,12.67 100.94,11.66 99.23,11.66 98.87,12.03 92.06,12.03 91.31,11.29 91.31,10.24 90.71,9.63 88.62,9.63 v2(88.49,9.51)
  IN5 w0.099: v2(182.92,20.43) 182.75,20.27 182.31,20.27 181.93,19.88 181.93,19.07 175.56,12.7 161.32,12.7 161.05,12.42 149.59,12.42 149.24,12.07 129.47,12.07 129.29,12.26 123.24,12.26 122.36,11.38 116.52,11.38 115.63,12.26 114.29,12.26 113.75,11.73 108.57,11.73 107.94,12.36 106.17,12.36 105.87,12.67 101.98,12.67
  IN6 w0.099: v2(215.58,43.44) 214.91,42.76 194.76,42.76 182.64,30.65 182.64,25.07 181.1,23.52 181.1,23.08 181.55,22.63 181.55,21.52 182.63,20.43 v2(182.92,20.43)
  BOTTOM w0.089: UH2.AR24 87.85,9.1 v2(88.49,9.51)
GPU_GC6_FB_EN: length 199.1
  TOP w0.14: DV13.3 211.01,46.04 210.25,45.28 v2(210.25,44.59) ; RV1133.1 242.36,43.07 v2(242.36,43.6) 242.67,43.91 242.67,46.79 v1(242.11,47.34) 241.61,47.85 241.61,48.79 RV1114.2 243.76,49.35 QV98.1
  IN5 w0.089: 101.98,12.14 101.97,12.14 100.96,11.13 98.05,11.13 97.63,11.55 92.09,11.55 91.67,11.13 91.67,10.09 90.85,9.27 89.69,9.27 89.39,8.97 87.7,8.97 87.59,9.08 87.14,9.08 86.6,8.53 86.6,7.52 v2(86.17,7.1)
  IN5 w0.099: 101.98,12.14 105.83,12.14 106.01,11.96 107.76,11.96 108.39,11.32 113.92,11.32 114.45,11.86 115.47,11.86 116.44,10.89 122.44,10.89 122.88,11.33 147.56,11.33 147.93,10.96 149.44,10.96 150.34,11.86 161.05,11.86 161.49,12.3 176.31,12.3 183.26,19.25 183.26,19.95 v2(183.33,20.02)
  IN6 w0.099: v2(183.33,20.02) 182.76,20.02 181.35,21.43 181.35,22.55 180.9,22.99 180.9,23.76 182.44,25.3 182.44,30.73 194.67,42.97 208.63,42.97 v2(210.25,44.59) 210.46,44.79 217.11,44.79 217.49,44.42 222.31,44.42 222.7,44.03 225.54,44.03 226.11,44.61 226.11,44.63 226.74,45.26 231.38,45.26 232.12,44.53 233.1,44.53 234.74,42.9 239.26,42.9 239.33,42.96 241.72,42.96 v2(242.36,43.6)
  BOTTOM w0.089: v2(86.17,7.1) 86.51,6.76 UH2.AW27
GPU_GC6_FB_EN_GPU: length 46.1
  TOP w0.14: QV98.3 243.73,48.43 RV1114.1 242.16,47.79 243.03,46.93 v2(243.03,43.6) ; RV1096.2 212.22,45.23 211.88,44.89 211.88,44.5 v2(212.45,43.93) RV1118.2 212.09,42.71 RV566.1 v1(210.62,42.3)
  IN6 w0.099: v2(243.03,43.6) 242.07,42.64 233.45,42.64 231.02,45.06 226.83,45.06 226.31,44.55 226.31,44.53 225.62,43.83 216.52,43.83 216.3,44.05 212.57,44.05 v2(212.45,43.93)
GPU_GPIO0: length 147.5
  TOP w0.14: RV1118.1 212.05,41.73 197.64,41.73 195.4,43.96 195.4,52.5 v2(197.85,54.94)
  IN1 w0.099: v2(197.85,54.94) 198.55,54.24 200.33,54.24 201.8,52.76 203.11,52.76 205.88,55.53 205.88,57.71 208.43,60.27 208.43,61.39 208.78,61.74 v2(209.98,61.74)
  IN2 w0.099: v2(209.98,61.74) 209.97,61.73 208.98,61.73 208.15,62.56 208.15,63.64 207.9,63.89 207.07,63.89 206.18,64.79 204.62,64.79 204.43,64.98 202.17,64.98 201.48,65.67 200.54,65.67 200.41,65.55 199.54,65.55 198.52,66.57 197.02,66.57 196.35,67.24 195.48,67.24 192.08,70.64 192.08,79.34 189.77,81.65 189.77,84.82 190.05,85.1 190.05,92.7 188.78,93.97 184.24,93.97 184.12,93.85 183.6,93.85 182.73,92.98 178.97,92.98 177.7,91.71 176.11,91.71 173.98,93.84 173.98,102.1 173.58,102.51 173.58,104.12 174.11,104.65 174.11,108.84 173.44,109.51 173.44,112.04 v2(173.83,112.43)
  IN6 w0.099: v2(164.34,118.06) 164.34,116.85 164.47,116.73 168.84,116.73 169.57,116 171.06,116 172.59,114.46 172.59,113.08 173.24,112.43 v2(173.83,112.43)
  BOTTOM w0.14: v2(209.98,61.74) 210.76,61.74 211.18,62.15 UV18.P6 ; v2(164.34,118.06) 164.21,118.18 RV1095.1
GPU_GPIO1: length 17.5
  TOP w0.14: v1(212.26,44.73) 212.52,44.99 RV1124.1 213.23,45.13 v2(213.23,46.25) RV1096.1
  IN1 w0.099: v2(213.23,46.25) 212.89,46.59 212.89,48.8 213.34,49.25 213.34,54.31 213.67,54.64 213.67,58.97 v2(213.34,59.3)
  BOTTOM w0.14: UV18.M3 v2(213.34,59.3)
GPU_GPIO2: length 19.2
  TOP w0.14: v1(215.41,46.1) 215.16,45.86 v2(215.16,45.66) 215.14,45.63 RV1097.1
  IN1 w0.099: 214.07,57.14 214.07,57.14 214.07,54.64 214.6,54.12 214.6,53.28 213.81,52.49 213.81,47.02 v2(215.16,45.66) ; 214.07,60.27 213.75,60.59 213.75,61.32 v2(213.36,61.72)
  IN1 w0.102: 214.07,57.14 214.07,60.27
  BOTTOM w0.14: v2(213.36,61.72) 213.36,61.77 UV18.L6
GPU_GPIO3: length 89.4
  TOP w0.14: v1(172.84,112.28) 172.84,112.28 v2(173.45,112.89)
  IN2 w0.099: v2(210.82,60.91) 210.44,61.29 207.27,61.29 206.68,61.87 206.68,63.9 206,64.59 204.54,64.59 204.34,64.78 202.09,64.78 201.4,65.47 200.62,65.47 200.5,65.35 199.46,65.35 198.44,66.37 196.93,66.37 196.26,67.04 195.4,67.04 191.88,70.56 191.88,79.26 189.57,81.57 189.57,84.91 189.85,85.18 189.85,92.62 188.69,93.77 184.33,93.77 184.2,93.65 183.68,93.65 182.81,92.78 179.05,92.78 177.78,91.51 174.48,91.51 174.21,91.79 174.21,93.33 173.78,93.76 173.78,102.02 173.38,102.42 173.38,104.2 173.91,104.73 173.91,108.76 173.24,109.43 173.24,112.69 v2(173.45,112.89)
  BOTTOM w0.14: UV18.P5 211.21,61.3 v2(210.82,60.91) ; v2(173.45,112.89) 174.35,112.89 RV1098.1
GPU_GPIO4: length 17
  TOP w0.14: v1(205.37,50.47) 205.37,50.43 v2(205.72,50.08) RV1099.1
  IN1 w0.099: v2(210.82,62.56) 210.82,61.92 210.42,61.52 210.42,56.44 208.41,54.43 208.41,51.51 207.36,50.46 206.09,50.46 v2(205.72,50.08)
  BOTTOM w0.14: UV18.P7 211.24,62.97 v2(210.82,62.56)
GPU_GPIO5: length 22.3
  TOP w0.14: v2(209.54,48.31) 209.27,48.04 RV1119.1 ; v2(213.3,48.54) 213.77,49.01 RV1100.1 ; v1(213.75,62.9) 213.68,62.9 v2(213.33,62.55)
  IN1 w0.099: v2(213.33,62.55) 212.93,62.15 212.93,60.64 213.08,60.49 213.54,60.49 213.75,60.27 213.75,59.38 213.87,59.27 213.87,54.56 213.54,54.23 213.54,48.78 v2(213.3,48.54)
  IN3 w0.091: v2(209.54,48.31) 210.24,49.01 212.83,49.01 v2(213.3,48.54)
  BOTTOM w0.14: UV18.L7 213.74,62.96 v2(213.33,62.55)
GPU_GPIO6: length 61
  TOP w0.14: v2(196.95,55.98) 194.92,53.94 194.92,43.76 197.44,41.25 212.56,41.25 213.22,41.91 RV1120.1
  IN1 w0.099: v2(209.17,64.27) 207.96,63.06 207.96,60.08 205.68,57.79 205.68,56.03 v2(202.84,53.19) 201.67,53.19 200.41,54.44 199,54.44 197.44,56 196.98,56 v2(196.95,55.98)
  BOTTOM w0.102: UV18.M7 212.51,63.43 211.93,63.43 211.72,63.65 211.72,63.84 210.94,64.62 209.51,64.62 v2(209.17,64.27)
  BOTTOM w0.14: RV1101.1 v1(201.97,54.05) v2(202.84,53.19)
GPU_GPIO8: length 99.4
  TOP w0.14: RV1086.1 198.62,105.39 v2(199.4,106.18) ; RV1121.1 228.84,47.11 v2(228.6,47.35)
  IN2 w0.099: v2(199.4,106.18) 198.92,105.7 198.92,102.47 198.05,101.6 198.05,97.55 196.86,96.35 193.02,96.35 190.66,93.99 190.66,84.76 190.45,84.54 190.45,81.83 192.77,79.5 192.77,72.05 193.04,71.78 199.19,71.78 199.64,72.22 200.13,72.22 200.38,71.97 200.38,69.16 200.32,69.1 200.32,67.82 202.04,66.1 204.63,66.1 205.35,65.38 207.49,65.38 209,63.87 209.24,63.87 209.55,63.56 209.55,63.25 209.84,62.96 211.55,62.96 212.92,61.59 212.92,60.48 213.32,60.08 v2(213.34,60.08)
  IN6 w0.099: v2(228.6,47.35) 228.11,47.85 222.62,47.85 220.94,49.53 220.94,50.52 220.13,51.33 214.02,51.33 213.48,51.88 213.48,58.77 213.79,59.09 213.79,59.61 213.34,60.06 v2(213.34,60.08)
  BOTTOM w0.14: v2(213.34,60.08) 213.36,60.08 UV18.L3
GPU_GPIO9: length 3.4
  BOTTOM w0.14: UV18.M2 212.95,58.9 213.23,58.62 213.23,58.37 213.23,58.36 213.32,58.26 213.32,57.94 212.83,57.44 RV1102.1
GPU_GPIO10: length 2.3
  BOTTOM w0.14: RV1103.1 213.45,57.18 213.74,57.47 UV18.L1
GPU_GPIO11: length 40.3
  TOP w0.14: RV1122.1 230.26,43.13 v2(229.98,43.13) 229.87,43.01 RV1104.1 229.93,42.27 230.25,41.96 230.25,41.91 230.41,41.75 231.1,41.75 231.47,41.39 v1(232.2,41.39)
  IN1 w0.099: v2(229.98,43.13) 229.98,43.2 227.7,45.49 222.32,45.49 221.11,46.69 220.22,46.69 219.52,45.99 218.98,45.99 218.58,46.38 217.03,46.38 215.7,45.06 213.8,45.06 212.59,46.27 212.59,50.55 212.92,50.88 212.92,60.3 212.51,60.7 v2(212.51,60.87)
  BOTTOM w0.14: UV18.M5 v2(212.51,60.87)
GPU_GPIO12: length 9.7
  TOP w0.14: v2(212.51,59.3) 213.95,57.86 v1(213.95,56.03) 213.95,55.51 214.68,54.79 214.68,51.82 RV1105.1
  BOTTOM w0.14: v2(212.51,59.3) 212.11,59.7 UV18.N3
GPU_GPIO13: length 37.3
  TOP w0.14: v2(212.51,60.1) v1(212.11,59.7) ; v2(229.39,43.15) 229.39,42.37 RV1106.1 229.08,42.29 228.84,42.05 RV1123.1
  IN1 w0.099: v2(212.51,60.1) 212.09,59.68 212.09,59 212.64,58.45 212.64,50.89 212.39,50.64 212.39,46.19 213.72,44.86 215.79,44.86 217.11,46.18 218.5,46.18 218.89,45.79 219.61,45.79 220.3,46.49 221.03,46.49 222.23,45.28 227.56,45.28 229.39,43.46 v2(229.39,43.15)
  BOTTOM w0.14: UV18.M4 212.91,60.5 v2(212.51,60.1)
GPU_GPIO16: length 44.6
  TOP w0.14: RV1107.1 230.15,43.9 230.15,44.59 v2(230.15,44.59) 230.15,44.95 v1(230.58,45.39)
  IN2 w0.099: v2(230.15,44.59) 229.74,44.18 227.95,44.18 227.8,44.03 221.84,44.03 221.21,44.67 217.52,44.67 217.19,45 216.69,45 216.35,44.65 214.7,44.65 213.84,45.51 213.84,46.5 212.44,47.9 212.44,54.42 214.19,56.16 214.19,57.04 215.52,58.38 215.52,60.3 215.42,60.4 215.42,61.9 215.16,62.15 214.35,62.15 213.52,62.98 212.97,62.98 211.73,64.21 v2(210,64.21)
  BOTTOM w0.14: v2(210,64.21) 210.41,63.8 UV18.R8
GPU_GPIO20: length 13.7
  TOP w0.14: RV1088.1 v2(211.7,48.54)
  IN1 w0.099: v2(211.7,48.54) 211.7,50.54 212.24,51.09 212.24,57.36 210.82,58.78 v2(210.82,60.08)
  BOTTOM w0.14: v2(210.82,60.08) 211.24,60.5 UV18.P4
GPU_GPIO21: length 4.1
  BOTTOM w0.14: v1(210.31,54.52) 211.32,55.52 RV1090.1 211.39,56.33 211.24,56.49 UV18.P1
GPU_GPIO23: length 31.1
  TOP w0.14: RV1091.1 221.25,47.71 v2(220.73,47.19) ; v1(209.58,63.66) 209.33,63.41 v2(209.12,63.41)
  IN1 w0.099: v2(209.12,63.41) 209.56,62.98 213.6,62.98 213.78,62.8 213.78,61.86 214.57,61.07 214.57,60.6 214.28,60.3 214.28,54.72 214.8,54.2 214.8,53.2 214.01,52.41 214.01,47.25 214.67,46.58 218.66,46.58 219.06,46.19 219.44,46.19 220.44,47.19 v2(220.73,47.19)
  BOTTOM w0.14: v2(209.12,63.41) 209.51,63.8 UV18.T8
GPU_GPIO25: length 15.6
  TOP w0.14: v2(203.35,51.13) 203.33,51.13 v1(202.95,50.75) 202.72,50.52 RV1108.1
  IN6 w0.099: v2(210.01,60.09) 210.01,59.57 209.59,59.15 209.59,58.74 208.77,57.92 208.77,56.24 207.27,54.74 206.5,54.74 204.61,52.86 204.61,52.39 v2(203.35,51.13)
  BOTTOM w0.14: UV18.R4 210.42,60.5 v2(210.01,60.09)
GPU_GPIO26: length 16.4
  TOP w0.14: v2(203.67,50.54) 203.59,50.47 v1(203.59,49.48) RV1109.1
  IN6 w0.099: v2(203.67,50.54) 204.81,51.69 204.81,52.78 206.58,54.54 207.35,54.54 208.97,56.16 208.97,57.83 209.79,58.66 209.79,59.07 210.42,59.69 210.42,60.46 v2(210.01,60.87)
  BOTTOM w0.14: v2(210.01,60.87) 210.44,61.3 UV18.R5
GPU_JTAG_TCK: length 6.1
  BOTTOM w0.102: T201.1 191.66,63.94 193.36,63.94 194.71,65.29 195.14,65.29 195.32,65.11 195.73,65.11 196.16,65.55 UV18.AM10
GPU_JTAG_TDI: length 6.2
  BOTTOM w0.102: T202.1 193.69,63.47 194.52,64.3 195.56,64.3 195.81,64.55 195.81,64.79 196.08,65.07 196.28,65.07 196.61,65.4 196.61,66.03 UV18.AM11
GPU_JTAG_TDO: length 2.1
  BOTTOM w0.14: T203.1 193.75,66.32 UV18.AP12
GPU_JTAG_TMS: length 3.3
  BOTTOM w0.102: 194.64,65.99 UV18.AP11
  BOTTOM w0.14: 194.64,65.99 193.99,65.35 T204.1
GPU_JTAG_TRST#: length 4.1
  BOTTOM w0.102: RV593.1 192.57,64.75 v1(193.17,64.75) 193.88,64.75 194.93,65.8 194.93,65.89 UV18.AN11
GPU_LEVEL: length 2.8
  TOP w0.14: v1(213.83,49.91) 214.73,49.91 RV554.1 214.76,50.05 215.08,50.37 DV15.2 RV1105.2
GPU_PEX_RST_HOLD#: length 23
  TOP w0.14: RV1091.2 221.62,46.54 UV21.2 ; RV1091.2 221.19,46.8 v2(220.47,46.08) ; RV1091.2 222.26,47.7 RV563.1
  IN1 w0.099: v2(220.47,46.08) 220.44,46.08 219.95,45.59 218.81,45.59 218.41,45.98 217.2,45.98 215.87,44.66 213.64,44.66 211.29,47 211.29,50.58 211.84,51.13 v2(211.84,53.92)
  BOTTOM w0.14: RV1090.2 211.39,54.36 v2(211.84,53.92)
GPU_PSI: length 138
  TOP w0.14: v2(228.8,43.18) 228.68,43.05 RV1123.2
  IN2 w0.099: v2(228.8,43.18) 228.75,43.23 221.44,43.23 220.84,43.82 219.05,43.82 218.77,43.54 216.05,43.54 215.75,43.85 213.1,43.85 212.61,44.34 211.71,44.34 210.64,45.4 209.37,45.4 207.6,47.18 207.6,50.19 207,50.78 205.39,50.78 203.53,52.64 202.75,52.64 200.78,54.61 v2(200.78,55.01) 200.78,55.42 199.23,56.97 198.53,56.97 196.3,59.19 196.3,59.89 195.41,60.78 195.39,60.78 194.24,61.93 194.08,61.93 193.24,62.77 193.24,62.93 187.92,68.25 186.33,68.25 182.6,71.98 182.6,79.13 179.64,82.09 179.64,82.56 178.21,83.99 175.72,83.99 175.02,84.69 174.09,84.69 173.77,85.02 171.62,85.02 171.16,85.48 171.16,85.94 170.06,87.04 170.06,89.11 169.66,89.51 166.8,89.51 164.22,92.08 164.22,98.9 166.01,100.69 166.01,103.03 165.38,103.67 165.38,108.82 164.87,109.33 164.87,112.19 v2(163.77,113.29)
  IN6 w0.099: v2(175.58,110.12) 175.32,110.38 172.65,110.38 169.8,113.23 166.07,113.23 165.74,112.9 164.16,112.9 v2(163.77,113.29)
  BOTTOM w0.14: RV1101.2 200.5,54.73 v2(200.78,55.01) 201.31,55.54 RV552.1 ; v2(175.58,110.12) 175.58,110.36 176.47,111.25 177.7,111.25 PR1501.2
  BOTTOM w0.254: PR1001.2 163.75,114.88 163.75,113.31 v2(163.77,113.29)
GPU_PWR_LEVEL: length 121.6
  TOP w0.14: DV15.1 215.08,52.82 v2(215.1,52.84) ; v1(295.94,28.79) 296.36,28.37 v2(296.36,27.72) ; UE3.B41 300.02,19.57 299.95,19.49 299.95,18.89 v2(299.49,18.44)
  IN1 w0.099: v2(296.36,27.72) 296.19,27.72 294.65,26.18 289.38,26.18 288.2,25 283.09,25 281.05,22.97 269.11,22.97 266.97,20.82 261.77,20.82 251.59,31 247.8,31 245.27,33.53 245.27,39.65 242.5,42.42 233.97,42.42 233.11,43.28 232.77,43.28 230.95,45.09 228.5,45.09 227.91,45.69 223.71,45.69 221.76,47.63 220.36,47.63 219.94,47.22 219.16,47.22 218.73,46.79 214.76,46.79 214.21,47.33 214.21,51.95 v2(215.1,52.84)
  BOTTOM w0.14: v2(299.49,18.44) 299.94,18.88 299.94,19.39 299.28,20.05 298.17,20.05 297,21.23 297,22.66 297.13,22.79 297.13,25.69 296.93,25.89 296.93,27.15 v2(296.36,27.72)
H_CATERR#: length 10.3
  BOTTOM w0.076: 134.62,80.72 135.31,80.72 135.74,81.15 137.02,81.15 137.35,80.82 139.73,80.82 UH1.BM30
  BOTTOM w0.14: 134.62,80.72 133.19,80.72 v1(133.14,80.66) 131.88,80.66 131.43,80.2 131.16,80.2 RH570.2
H_CPUPWRGD: length 98
  TOP w0.14: v2(132.76,81.76) v3(132.26,81.26)
  IN4 w0.091: v2(106.71,16.58) 106.71,16.8 109.77,19.86 109.77,26.98 109.42,27.33 109.42,34.25 123.56,48.39 123.56,57.47 122.46,58.58 122.46,61.77 122.8,62.11 123.44,62.11 126.67,65.34 126.67,68.69 128.56,70.58 128.56,77.58 132.74,81.76 v2(132.76,81.76)
  BOTTOM w0.076: UH1.BT31 135.01,81.91 134.86,81.76 134.62,81.76
  BOTTOM w0.089: 101.98,10.79 101.93,10.79 101.86,10.72 98.61,10.72 98.37,10.48 UH2.AM3
  BOTTOM w0.14: 101.98,10.79 103.34,10.79 103.38,10.75 105.38,10.75 108.34,13.71 108.34,14.41 107.03,15.72 107.03,16.26 v2(106.71,16.58) ; 134.62,81.76 v2(132.76,81.76)
H_DRAMRST#: length 73.7
  TOP w0.14: v2(140.26,7.11) 140.26,11.21 v3(140.06,11.41) 134.9,16.57 134.9,17.13 134.7,17.32 134.7,18.47 134.44,18.73 RD31.2 CD69.1 RD35.2
  IN6 w0.089: 101.98,5.9 99.98,5.9 99.42,5.34 99.42,3.64 98.66,2.88 97.84,2.88 96.84,3.89 94.32,3.89 94.22,3.98 93.33,3.98 92.83,3.49 92.83,3 92.9,2.93 92.9,2.4 v2(93.09,2.21)
  IN6 w0.099: 101.98,5.9 102.03,5.9 102.05,5.92 104.45,5.92 104.86,5.51 106.69,5.51 107.61,4.6 109.94,4.6 110.17,4.37 116.61,4.37 119.52,7.28 127.16,7.28 127.23,7.21 129.97,7.21 130.59,6.59 139.74,6.59 v2(140.26,7.11)
  BOTTOM w0.089: v2(93.09,2.21) 92.91,2.39 92.91,2.57 92.91,2.58 92.91,2.72 92.59,3.04 92.59,3.58 92.83,3.81 92.83,4.27 92.93,4.37 92.93,4.85 93.16,5.08 UH2.BC14
H_PECI: length 303.7
  TOP w0.14: RE48.2 292.63,24.7 291.15,24.7 290.42,23.96 289.02,23.96 v3(286.66,21.6) 284.87,19.81 284.87,18.6 285.75,17.72 285.75,16.39 284.94,15.57 v2(284.94,15.58)
  IN4 w0.091: v2(133.41,82.88) 133.16,82.88 128.09,77.8 128.09,70.77 125.66,68.35 125.66,65.28 122.96,62.58 122.6,62.58 121.86,61.83 121.86,56.12 123.08,54.9 123.08,48.95 108.47,34.34 108.47,27.26 109.07,26.67 109.07,20.9 107.84,19.67 107.47,19.67 106.41,20.72 105.43,20.72 105.25,20.55 105.25,20.54 v2(104.91,20.2)
  IN5 w0.099: v2(284.94,15.58) 284.4,15.58 283.16,14.33 255.65,14.33 251.51,18.48 251.51,20 250.99,20.52 250.34,20.52 249.4,21.46 249.4,24.22 248.06,25.56 223.28,25.56 221.68,27.16 187.44,27.16 187.18,27.42 181.72,27.42 177.8,23.49 177.8,19.71 175.52,17.42 129.62,17.42 129.33,17.14 107.3,17.14 106.71,17.73 105.92,17.73 104.37,19.27 104.37,19.74 104.82,20.2 v2(104.91,20.2)
  BOTTOM w0.14: v2(104.91,20.2) 105.21,19.89 105.21,18.01 105.82,17.4 105.82,15.74 105.89,15.68 105.89,12.84 105.17,12.12 104.34,12.12 104.13,11.91 RH539.2 ; v2(133.41,82.88) 132.94,83.35 RH190.1
H_PECI_R: length 3.9
  BOTTOM w0.14: UH1.BT34 137.2,83.18 v1(135.37,83.18) 134.25,83.18 RH190.2
H_PM_DOWN: length 90
  TOP w0.14: v3(104.22,20.21) 103.84,20.6 v2(103.84,20.68)
  IN4 w0.091: v2(103.84,20.68) 103.46,21.07 103.46,21.55 105.45,23.55 106.98,23.55 107.21,23.32 107.63,23.32 107.82,23.5 107.82,25.57 107.58,25.81 107.58,34.59 118.47,45.49 118.47,51.76 119.49,52.78 119.49,57.49 119.91,57.9 119.91,63.33 122.82,66.24 122.82,67.95 126.11,71.24 126.11,78.75 129.15,81.79 129.15,82.73 v2(129.52,83.1)
  BOTTOM w0.089: UH2.AH2 99.2,12.02 99.53,12.02 99.73,11.82 100.57,11.82 101.14,12.39 101.14,12.85 101.64,13.34 101.98,13.34
  BOTTOM w0.127: v2(103.84,20.68) 103.9,20.62 103.9,17.32 104.06,17.15 104.06,15.6 104.25,15.42 104.25,14.01 103.58,13.34 101.98,13.34
  BOTTOM w0.14: RH155.1 129.98,83.1 v2(129.52,83.1)
H_PM_DOWN_R: length 8.2
  BOTTOM w0.076: 134.62,82.2 135.78,82.2 135.85,82.14 136.93,82.14 136.98,82.19 137.94,82.19 137.98,82.23 138.46,82.23 UH1.BP31
  BOTTOM w0.14: 134.62,82.2 v1(134.04,82.2) 131.8,82.2 RH155.2
H_PM_SYNC_R: length 94.2
  TOP w0.089: v2(136.14,83.57) v3(135.57,83)
  IN2 w0.089: v2(136.14,83.57) 139.36,83.57 v2(139.73,83.93)
  IN4 w0.091: v2(131.67,84.73) 130.12,83.17 130.12,82.39 126.43,78.7 126.43,71.28 123.02,67.87 123.02,66.16 122.14,65.28 122.14,64.34 120.1,62.3 120.1,57.81 119.7,57.4 119.7,46.44 108.21,34.95 108.21,34.92 107.77,34.48 107.77,25.89 108.01,25.65 108.01,23.42 107.71,23.12 107.13,23.12 106.9,23.35 105.89,23.35 103.87,21.33 v2(103.87,21.27)
  BOTTOM w0.076: UH1.BM34 140.05,83.6 v2(139.73,83.93)
  BOTTOM w0.127: v2(103.87,21.27) 104.33,20.81 104.33,20.58 104.13,20.38 104.13,17.83 104.93,17.03 104.93,15.9 104.75,15.73 RH189.2
  BOTTOM w0.14: v2(136.14,83.57) 135.59,84.12 132.28,84.12 v2(131.67,84.73)
H_PROCHOT#: length 365.7
  TOP w0.14: v2(296.36,26.71) 296.36,25.89 295.78,25.31 RE96.2 ; v3(119.89,51.67) 119.9,51.66 v2(120.93,51.66) ; v2(62.74,18.97) 62.4,18.64 62.4,17.44 61.23,16.26 60.52,16.26 PR315.1
  IN3 w0.091: v2(119.97,108.97) 120.24,109.25 122.37,109.25 122.95,108.67 122.95,104.87 129.78,98.04 v2(129.78,97.82) ; v2(296.36,26.71) 296.2,26.87 292.61,26.87 291.04,25.31 289.29,25.31 288.01,24.03 281.25,24.03 279.75,22.53 277.45,22.53 276.93,22.01 270.26,22.01 268.62,20.37 260.77,20.37 260.5,20.64 257.36,20.64 256.59,21.4 255.07,21.4 253.35,19.69 252.74,19.69 251.24,18.19 231.77,18.19 231.21,17.63 230.07,17.63 229.54,17.11 229.54,16.66 229.24,16.35 177.62,16.35 176.06,17.91 174.41,17.91 173.05,19.26 173.05,22.66 173.65,23.26 173.65,27.94 173.13,28.46 162.61,28.46 143.93,47.14 v2(129.96,47.14)
  IN4 w0.091: v2(129.78,97.82) 129.4,97.82 129.12,97.54 129.12,91.2 132.66,87.67 132.66,84.23 130.93,82.5 130.93,82.06 v2(129.51,80.64) 127.13,78.25 127.13,71.04 124.79,68.71 124.79,66.99 122.8,65 122.8,64.04 120.99,62.22 120.99,55.12 120.45,54.58 120.45,51.95 120.74,51.66 v2(120.93,51.66)
  IN5 w0.089: 99.93,27.31 99.93,23.5 97.41,20.98 96.48,20.98 95.63,20.13 93.49,20.13 93.26,19.9 92.69,19.9 92.51,20.07 91.81,20.07 91.25,19.52 91.25,18.93 90.77,18.45 84.81,18.45 83.88,17.52 80.47,17.52 80.32,17.36 80.32,17.03 80.06,16.77 78.61,16.77 77.68,17.71 76.63,17.71 76.29,17.37 75.06,17.37
  IN5 w0.099: v2(62.74,18.97) 63.47,18.25 65.96,18.25 67,17.2 73.89,17.2 74.06,17.37 75.06,17.37 ; 99.93,27.31 99.93,28.81 100.99,29.86 103.39,29.86 117.2,43.67 117.2,47.93 v2(120.93,51.66)
  BOTTOM w0.14: v2(129.51,80.64) 129.72,80.84 RH158.1 130.15,80.08 RH165.2 ; PR1103.1 119.81,108.82 v2(119.97,108.97) ; v2(120.93,51.66) 121.33,51.26 121.99,51.26 126.12,47.14 v2(129.96,47.14)
H_PROCHOT#_EC: length 2.7
  TOP w0.14: RE96.1 295.78,22.37 v1(296.27,21.88) UE3.A46
H_PROCHOT#_R: length 7.4
  BOTTOM w0.076: 134.62,81.05 135.13,81.05 v1(135.4,81.31) 135.51,81.43 137.62,81.43 137.9,81.15 UH1.BR30
  BOTTOM w0.14: RH158.2 131.26,81.05 134.62,81.05
H_THERMTRIP#: length 7
  BOTTOM w0.089: UH2.AJ3 98.78,12.51 99.07,12.51 99.38,12.2 99.6,12.2 99.81,12 100.42,12 100.91,12.48 v1(100.91,13.11) 100.91,13.29 101.56,13.93 101.98,13.93
  BOTTOM w0.14: 101.98,13.93 103.33,13.93 RH191.1
H_THERMTRIP#_R: length 327.7
  TOP w0.14: v2(309.39,20.34) 309.64,20.09 QE10.3
  TOP w0.254: RH163.2 172.7,82.11 v2(172.7,82.15)
  IN3 w0.091: v2(174.56,19.82) 175.45,18.93 176.66,18.93 177.7,17.89 228.88,17.89 229.64,18.65 230.79,18.65 231.34,19.21 250.82,19.21 252.32,20.71 252.93,20.71 254.64,22.42 257.62,22.42 258.49,23.3 259.28,23.3 261.19,21.39 265.92,21.39 267.56,23.03 276.51,23.03 277.02,23.55 279.32,23.55 281.68,25.9 288.44,25.9 288.9,26.36 290.65,26.36 292.04,27.75 292.04,31.29 293.46,32.71 297.31,32.71 299.87,30.15 303.02,30.15 304.03,29.14 305.37,29.14 306.92,30.69 311.93,30.69 v2(312.76,29.85)
  IN6 w0.089: v2(172.7,82.15) 172.7,80.78 172.89,80.58 177.54,80.58 178.2,79.92 178.2,68.44 181.04,65.6 181.1,65.6
  IN6 w0.099: 181.1,65.6 182.37,65.6 182.83,65.6 190.25,58.18 190.25,54.87 192.13,52.99 192.13,46.12 178.23,32.22 178.23,27.26 176.49,25.52 176.49,24.4 176.77,24.12 176.77,22.66 176.11,22.01 176.11,20.91 175.02,19.82 v2(174.56,19.82) 174.12,20.27 174.05,20.27 173.99,20.33 173.42,20.33 172.79,19.7 151.38,19.7 150.65,18.97 133.95,18.97 133.32,19.6 107.18,19.6 106.96,19.82 106.96,20.3 106.42,20.84 105.94,20.84 104.55,22.23 v2(103.57,22.23)
  BOTTOM w0.076: UH1.J31 173.03,81.81 v2(172.7,82.15)
  BOTTOM w0.14: v2(103.57,22.23) 103.57,21.75 103.31,21.49 103.31,17.27 103.21,17.17 103.21,15.62 RH191.2 ; v2(309.39,20.34) 309.17,20.56 309.17,23.38 312.01,26.22 312.01,29.1 v2(312.76,29.85)
H_VCCST_PWRGD: length 126.3
  TOP w0.089: 181.1,65.68 RH164.2
  TOP w0.127: RH164.2 178.84,66.59 RH154.1
  TOP w0.14: RH482.1 131.14,90.05 v2(131.47,89.72) ; 181.1,65.68 181.92,65.68 183.01,64.59 v2(183.01,63.52) ; UZ19.4 121.54,59.26 122.1,58.7 RZ82.2 122.56,60.65 v1(122.62,60.71) 122.62,61.13 v2(122.93,61.44)
  IN4 w0.091: v2(131.47,89.72) 131.47,90.58 131.65,90.76 131.99,90.76 133.32,89.43 133.32,85.16 133.81,84.67 133.81,82.13 129.03,77.36 129.03,70.29 127.15,68.4 127.15,65.14 123.45,61.44 v2(122.93,61.44)
  IN4 w0.102: v2(183.01,63.52) 182.06,64.47 182.06,80.74 181.62,81.17 181.62,87.12 180.76,87.98 180.28,87.98 178.8,89.45 v2(178.8,89.61)
  IN6 w0.099: v2(131.47,89.72) 131.47,90.36 132.75,91.64 156.85,91.64 157.48,91 170.34,91 171.17,90.18 175.91,90.18 176.48,89.61 v2(178.8,89.61)
H_VCCST_PWRGD_EC: length 267.8
  TOP w0.14: v2(116.37,14.07) 116.02,14.41 116.02,16.94 114.17,18.79 109.4,18.79 108.11,20.07 108.11,21.47 107.99,21.6 107.99,25.18 107.73,25.44 107.73,29.47 118.75,40.49 v3(118.75,48.14) 118.75,49.6 119.7,50.55 119.7,51 119.38,51.31 119.38,54.58 119.78,54.98 122.13,54.98 122.48,55.33 122.48,56.03 122.81,56.36 122.81,57.53 RZ82.1 121.78,58.56 120.4,58.56 120.24,58.4 UZ19.1 119.72,57.73 119.59,57.86 RZ84.2 ; UE3.A44 297.27,21.5 v2(297.42,21.65)
  IN5 w0.099: v2(257.35,12.23) 257.34,12.23 256.93,12.64 251.44,12.64 251.44,12.64 235.26,12.64 235.05,12.43 230.55,12.43 229.63,13.35 223.97,13.35 219.22,18.11 219.22,24.52 218.19,25.55 186.77,25.55 186.51,25.81 182.53,25.81 179.46,22.74 179.46,18.88 175.06,14.47 116.75,14.47 116.37,14.09 v2(116.37,14.07)
  IN6 w0.099: v2(297.42,21.65) 297.38,21.61 294.08,21.61 293.36,20.89 293.16,20.89 292.32,20.04 290.22,20.04 290.16,20.11 284.85,20.11 284.47,19.73 283.21,19.73 282.85,19.37 281.41,19.37 279.76,17.72 278.23,17.72 276.97,16.46 269.54,16.46 266.11,13.04 257.62,13.04 257.35,12.77 v2(257.35,12.23)
HD_SOC_SEL: length 3
  BOTTOM w0.108: UA1.6 9.24,34.23 9.79,33.68 9.79,33.62 10.03,33.37 10.03,33.26 RA16.2 11.13,33.19 RA15.2
HDA_BITCLK: length 57.5
  TOP w0.089: v2(100.78,4.5) 101.28,4.01 v3(101.28,4.01)
  TOP w0.14: RP15.8 64.86,8.54 64.8,8.6 v2(64.8,9.75)
  IN1 w0.076: 75.06,5.35 75.91,4.49 76.21,4.49 76.31,4.59 78.39,4.59 78.52,4.45 82.23,4.45 82.48,4.21 92.66,4.21 92.98,4.53 95.07,4.53 95.84,3.75 95.84,2.88 96,2.73 98.91,2.73 100.69,4.5 v2(100.78,4.5)
  IN1 w0.099: 75.06,5.35 74.62,5.79 69.36,5.79 67.34,7.81 66.2,7.81 64.8,9.2 v2(64.8,9.75)
  BOTTOM w0.089: 101.98,4.12 101.17,4.12 v2(100.78,4.5) ; UH2.BA9 95.61,5.57 95.67,5.5 95.67,4.41 95.77,4.31 95.77,4 96.2,3.57 96.2,3.56 96.29,3.56 96.57,3.28 96.57,2.67 96.27,2.36 96.27,1.65 96.5,1.43
  BOTTOM w0.14: 101.98,4.12 102.36,4.12 CH50.2 102.24,3.64 100.37,3.64 98.16,1.43 96.5,1.43
HDA_BITCLK_AUDIO: length 92
  TOP w0.14: RP15.1 63.71,9.35 64.28,9.91 v3(64.28,13.83) 64.56,14.11 64.81,14.11 65.98,15.27 v2(65.98,15.69)
  IN6 w0.099: v2(5.53,33.47) 5.34,33.47 4.99,33.82 4.99,34.46 5.65,35.12 10.22,35.12 11.14,36.04 12.15,36.04 12.98,35.21 14.33,35.21 15.31,34.23 15.31,29.76 16.74,28.33 19.85,28.33 20.18,28.01 25.35,28.01 25.75,27.6 25.75,26.23 26.1,25.89 31.95,25.89 32.37,25.47 35.21,25.47 36.27,26.53 36.98,26.53 37,26.51 45.2,26.51 46.16,25.55 47.16,25.55 48.07,24.64 54.79,24.64 57.01,22.42 59.08,22.42 59.87,21.63 59.87,18.27 60.28,17.86 63.01,17.86 63.68,18.54 65.69,18.54 66.19,18.03 66.19,15.91 v2(65.98,15.69)
  BOTTOM w0.14: CA120.2 CA33.1 5.04,32.98 v2(5.53,33.47) 6.44,34.38 UA1.13
HDA_RST#: length 39.6
  TOP w0.14: v2(65.75,9.75) v1(65.75,9.13) 65.75,8.94 65.8,8.89 65.8,7.46 65.34,7 RP15.6
  IN1 w0.076: v2(96.94,3.08) 96.94,3.12 96.93,3.13 96.93,3.18 95.25,4.86 92.84,4.86 92.52,4.54 82.62,4.54 82.37,4.79 78.66,4.79 77.27,6.18 76.13,6.18 75.63,6.68 75.06,6.68
  IN1 w0.099: 75.06,6.68 72.31,6.68 70.79,8.2 69.32,8.2 68.4,9.12 66.38,9.12 v2(65.75,9.75)
  BOTTOM w0.089: v2(96.94,3.08) 96.94,3.12 96.93,3.13 96.93,3.18 96.06,4.05 96.06,4.38 UH2.BD8
HDA_SDIN0: length 18.3
  TOP w0.14: RH96.2 108.54,3.44 v2(108.13,3.02) 108.88,2.27 v3(109.06,2.27)
  IN1 w0.076: 101.98,4.1 101.98,4.1 101.68,3.79 100.7,3.79 98.48,1.57 97.17,1.57 v2(96.7,2.04)
  IN1 w0.099: 101.98,4.1 107.13,4.1 108.13,3.09 v2(108.13,3.02)
  BOTTOM w0.089: UH2.BE7 96.41,4.06 96.8,3.68 96.94,3.68 97.11,3.51 97.36,3.26 97.36,2.7 v2(96.7,2.04)
HDA_SDIN0_AUDIO: length 176.4
  TOP w0.14: v3(110.61,1.49) 109.93,2.17 RH96.1 110.3,3.44 v2(110.62,3.76)
  IN2 w0.099: v2(3.41,27.41) 3.76,27.06 5.5,27.06 7.69,24.88 7.69,22.84 7.11,21.44 5.78,20.12 5.78,18.31 3.61,16.14 3.61,13.18 3.61,12.82 4.5,11.93 5.55,11.93 8.7,8.77 11.18,8.77 11.75,9.34 11.75,11.35 16.04,15.65 18.43,15.65 22.86,20.08 26.45,20.08 29.3,22.93 31.37,22.93 32.23,23.79 38.64,23.79 42.66,19.77 47.64,19.77 48.79,20.92 52.22,20.92 53.84,19.31 53.84,18.55 53.45,18.17 53.45,15.93 54.17,15.21 54.17,13.24 53,12.07 53,7.11 55.61,4.5 55.61,3.64 v2(57.72,1.53)
  IN3 w0.091: v2(58.1,10.55) 57.79,10.23 57.79,6.82 56.83,5.86 56.83,2.42 v2(57.72,1.53)
  IN5 w0.089: 75.06,7.84 76.15,6.74 77.95,6.74 78.61,7.41 78.91,7.41 79.15,7.18 79.15,7.01 79.66,6.49 81.66,6.49 82.27,5.88 83.15,5.88 83.6,5.44 84.06,5.44 84.57,5.95 85.12,5.95 85.54,6.37 87.02,6.37 87.08,6.43 88.26,6.43 89.2,7.37 90.05,7.37 90.36,7.06 90.36,6.68 90.67,6.37 93.21,6.37 93.66,5.91 93.66,5.79 93.84,5.61 95.26,5.61 96.03,4.84 97.29,4.84 97.5,5.05 98.89,5.05 99.01,4.92 101.77,4.92 101.98,4.71
  IN5 w0.099: v2(110.62,3.76) 109.71,4.67 107.54,4.67 107.16,5.05 105.66,5.05 105.32,4.71 101.98,4.71 ; v2(58.1,10.55) 59.37,10.55 61.89,8.03 67.79,8.03 68.51,8.75 72.64,8.75 73.38,8.01 74.89,8.01 75.06,7.84
  BOTTOM w0.14: RA6.1 2.41,28.01 3.02,27.41 v2(3.41,27.41)
HDA_SDOUT: length 64.4
  TOP w0.089: CH51.2 97.28,6.21 v2(96.69,6.8)
  TOP w0.14: v2(66.6,10.33) 66.52,10.33 66.17,9.98 66.17,9.08 66.19,9.06 66.19,7.3 66.17,7.28 66.17,7.21 65.47,6.5 RP15.5 ; v2(114.63,8.39) 114.83,8.19 v3(114.83,7.5) RH454.2
  IN1 w0.076: 75.06,7.83 76.23,6.66 77.85,6.66 78.01,6.5 78.01,6.49 78.69,5.8 79.27,5.8 79.69,6.23 81.16,6.23 82.69,4.71 92.45,4.71 92.77,5.03 94.93,5.03 96.69,6.78 v2(96.69,6.8)
  IN1 w0.099: v2(66.6,10.33) 67.68,10.33 69.47,8.55 71.41,8.55 71.97,7.98 74.91,7.98 75.06,7.83
  IN3 w0.089: 101.98,8.46 99.25,8.46 98.46,7.68 97.21,7.68 96.69,7.16 v2(96.69,6.8)
  IN3 w0.091: 101.98,8.46 102.14,8.46 103.94,10.27 105.99,10.27 106.35,10.63 109.25,10.63 110.16,9.71 112.38,9.71 113.28,8.81 114.21,8.81 v2(114.63,8.39)
  BOTTOM w0.089: v2(96.69,6.8) 96.34,6.45 UH2.BB7
HDA_SDOUT_AUDIO: length 95.6
  TOP w0.14: RP15.4 62.74,6.5 61.96,7.28 61.96,9.61 62.86,10.51 62.86,14.68 64.64,16.47 v3(64.64,16.81) v2(64.64,17.59) ; v2(3.96,31.45) 4.07,31.35 CA38.1
  IN2 w0.099: v2(3.96,31.45) 3.96,34.44 4.19,34.68 4.19,35.25 3.87,35.57 v2(3.49,35.57)
  IN6 w0.099: v2(64.64,17.59) 63.91,17.59 62.47,16.15 60.81,16.15 59.02,17.94 59.02,18.8 56.52,21.29 56.22,21.29 54.37,23.14 50.13,23.14 49.46,23.81 47.73,23.81 46.81,24.72 45.81,24.72 45.26,25.27 37.66,25.27 37.02,24.63 27.68,24.63 27.27,25.04 22.97,25.04 21.04,23.12 15.69,23.12 13.97,24.85 13.97,29.06 11.58,31.45 11.58,32.23 10.73,33.09 6.16,33.09 5.23,32.16 4.44,32.16 3.96,31.68 v2(3.96,31.45)
  BOTTOM w0.14: UA1.17 4.55,36.52 3.59,35.57 v2(3.49,35.57)
HDA_SYNC: length 40.8
  TOP w0.14: v2(64.8,10.33) 64.82,10.33 65.32,9.83 65.32,8.81 65.41,8.73 65.41,7.62 65.28,7.5 RP15.7
  IN1 w0.076: v2(96.21,3.08) 96.21,3.62 95.14,4.7 92.91,4.7 92.59,4.38 82.55,4.38 82.3,4.62 78.59,4.62 78.45,4.76 76.86,4.76 76.29,5.33 76.02,5.33 75.06,6.3
  IN1 w0.099: v2(64.8,10.33) 65.34,9.79 65.34,9.34 66.4,8.29 67.54,8.29 68.53,7.3 71.01,7.3 72.01,6.3 75.06,6.3
  BOTTOM w0.089: UH2.BD9 95.44,4.4 95.59,4.24 95.59,3.78 96.21,3.16 v2(96.21,3.08)
HDA_SYNC_AUDIO: length 86.8
  TOP w0.14: v2(65.21,17.82) 65.21,17.23 65.1,17.13 65.1,15.55 64.58,15.03 64.42,15.03 63.76,14.38 63.76,10.13 v3(63.36,9.73) 62.74,9.11 62.74,7.82 63.06,7.5 RP15.2
  IN6 w0.099: v2(5.46,34.11) 6,34.64 10.42,34.64 10.79,35.01 12.5,35.01 13.95,33.56 14.65,33.56 14.83,33.37 14.83,29.56 16.54,27.85 19.65,27.85 19.98,27.53 25.15,27.53 25.27,27.4 25.27,26.03 25.91,25.4 27.42,25.4 27.83,24.99 36.8,24.99 37.44,25.62 45.41,25.62 45.96,25.07 46.96,25.07 47.87,24.16 49.61,24.16 50.19,23.58 55.17,23.58 58.38,20.37 58.38,19.94 59.37,18.94 59.37,18.09 60.96,16.5 62.33,16.5 63.88,18.06 64.97,18.06 v2(65.21,17.82)
  BOTTOM w0.14: UA1.14 6.04,34.56 5.59,34.11 v2(5.46,34.11) 5.37,34.11 CA34.1
HDD_DET#: length 183.5
  TOP w0.089: RH513.1 76.15,13.74 77.48,13.74 78.1,13.11 80.44,13.11 80.68,12.86 v2(80.68,12.68) 80.14,12.14 v1(79.82,12.14)
  IN5 w0.089: 101.98,13.68 101.05,13.68 100.64,13.26 96.86,13.26 95.65,14.47 92.19,14.47 90.48,12.76 85.33,12.76 84.85,12.27 81.1,12.27 v2(80.68,12.68)
  IN5 w0.099: 101.98,13.68 106.28,13.68 106.49,13.46 114.56,13.46 114.76,13.26 116.05,13.26 116.93,12.38 121.94,12.38 122.82,13.26 124.95,13.26 125.12,13.43 145.81,13.43 146.16,13.08 148.82,13.08 149.18,13.43 160.64,13.43 160.99,13.79 175.23,13.79 180.32,18.88 180.32,22.74 182.79,25.21 186.26,25.21 186.54,24.93 217.95,24.93 218.62,24.26 218.62,17.86 223.72,12.75 229.37,12.75 230.3,11.83 v2(236.17,11.83)
  BOTTOM w0.089: UH2.AG39 80.34,13.02 v2(80.68,12.68)
  BOTTOM w0.14: v2(236.17,11.83) 236.86,11.14 JHDD.12
HDD_DEVSLP: length 176.1
  TOP w0.14: v2(230.79,12.92) v1(231.7,12) 232.15,11.55 232.15,10.65 233.83,8.97 RD100.1
  IN5 w0.089: 101.98,14.56 101.37,14.56 101.24,14.69 99.12,14.69 98.53,15.28 96.17,15.28 96.05,15.16 91.33,15.16 89.52,13.35 84.43,13.35 84.19,13.59 84.19,13.81 83.73,14.28 80.47,14.28 79.94,13.75 v2(79.93,13.75)
  IN5 w0.099: 101.98,14.56 105.9,14.56 106.06,14.72 175.01,14.72 179.26,18.97 179.26,22.82 182.45,26.01 186.59,26.01 186.85,25.75 218.27,25.75 219.42,24.6 219.42,18.19 224.06,13.55 230.15,13.55 v2(230.79,12.92)
  BOTTOM w0.089: UH2.AG43 78.71,13.14 78.99,13.42 79.32,13.42 79.65,13.75 v2(79.93,13.75)
HDMI_CEC: length 5.5
  BOTTOM w0.127: JHDMI1.13 12.32,85.43 14.72,87.83 v1(14.72,88.44) CV182.2
HDMI_HPLUG: length 10.1
  BOTTOM w0.127: JHDMI1.19 11.77,88.69 14.28,91.19 CV180.2 14.72,91.94 v1(15.06,92.29) 15.27,92.49 16.05,92.49 16.5,92.05 RV123.1
  BOTTOM w0.14: QV14.1 17.54,92.32 RV123.1
HDMI_RESERVED: length 8.8
  IN2 w0.099: JHDMI1.14 11.15,86.51 11.15,88.6 11.57,89.02 12.4,89.02 v2(13.4,88.02)
  BOTTOM w0.127: v2(13.4,88.02) 13.82,88.44 v1(13.82,89.85) 14.28,90.31 CV181.2
HOST_DEBUG_TX: length 24.4
  TOP w0.14: UE3.B44 v2(298.52,19.08) ; RE64.2 307.02,29.03 v2(306.67,29.38) 306.49,29.38 v3(305.63,28.52)
  IN4 w0.091: v2(306.67,29.38) 306.23,28.95 302.66,28.95 301.89,29.73 301.41,29.73 297.95,26.27 297.95,23.45 296.93,22.42 296.93,21.54 298.52,19.94 v2(298.52,19.08)
  BOTTOM w0.14: v2(306.67,29.38) 306.67,29.79 307.61,30.74 JDEG1.8
HOST_SD_WP#: length 297.8
  TOP w0.089: v2(77.65,7.65) 77.65,8.04 77.19,8.49 76.44,8.49 RH563.2
  IN1 w0.099: v2(329.44,42.81) 329.57,42.68 329.57,32.53 327.1,30.06 327.1,29.47 314.31,16.68 314.31,13.48 316.13,11.66 v2(316.13,10.79)
  IN5 w0.089: v2(77.65,7.65) 77.94,7.94 79.21,7.94 79.34,7.81 81.33,7.81 81.92,8.4 81.92,8.48 82.13,8.7 84.07,8.7 84.42,8.35 85.02,8.35 85.42,7.95 85.42,7.33 86.02,6.73 86.32,6.73 86.77,7.19 86.77,7.99 87.14,8.36 89.05,8.36 89.79,9.1 90.94,9.1 92.65,10.81 94.94,10.81 95.44,11.31 97.61,11.31 97.97,10.95 101.2,10.95 101.98,11.73
  IN5 w0.099: v2(316.13,10.79) 315.56,10.22 309.57,10.22 306.32,6.96 301.05,6.96 300.86,7.14 297.75,7.14 297,7.89 297,8.51 294.37,11.14 293.36,11.14 292.26,10.04 291.74,10.04 290.29,8.59 283.89,8.59 281.55,10.93 271.04,10.93 270.73,10.62 269.15,10.62 268.74,10.2 265.75,10.2 264.28,11.67 262.3,11.67 261.75,11.12 252.1,11.12 251.94,11.29 230.56,11.29 229.49,12.35 211.03,12.35 210.03,11.35 203.32,11.35 201.72,12.95 185.71,12.95 184.21,11.45 176.06,11.45 175.91,11.3 164.2,11.3 163.84,11.66 150.43,11.66 149.53,10.76 147.7,10.76 147.33,11.13 122.96,11.13 122.52,10.69 116.35,10.69 115.38,11.66 114.54,11.66 114,11.12 108.3,11.12 107.68,11.74 105.94,11.74 105.75,11.94 102.19,11.94 101.98,11.73
  BOTTOM w0.089: v2(77.65,7.65) 77.8,7.81 78.08,7.81 78.29,8.01 UH2.AU44
  BOTTOM w0.14: v2(329.44,42.81) 329.61,42.81 329.75,42.67 QR1.2
HP_JD#: length 55.6
  TOP w0.14: v3(6.54,12.77) 6.8,13.03 v2(6.8,13.33) 6.4,13.73 JAUDIO.8
  IN1 w0.099: v2(5.95,31.74) 5.96,31.75 7.09,31.75 7.54,32.2 9.62,32.2 10.52,31.93 10.75,31.79 10.83,31.75 11.33,31.42 12.81,29.95 12.81,24.79 13.72,23.87 13.72,23.27 13.21,22.76 13.21,22.23 13.05,22.06 13.05,21.74 v2(12.65,21.34)
  IN5 w0.254: v2(4.38,45.63) 5.69,44.32 5.69,41.37 5.41,41.09 5.41,35.57 6.05,34.93 6.05,33.02 5.92,32.89 5.92,31.77 v2(5.95,31.74)
  IN6 w0.099: v2(6.8,13.33) 5.27,14.86 5.27,17.66 7.31,19.7 8.95,19.7 9.71,20.46 11.77,20.46 v2(12.65,21.34)
  BOTTOM w0.108: v2(5.95,31.74) 5.98,31.76 5.98,32.59 6.76,33.37 RA14.1
  BOTTOM w0.254: v2(4.38,45.63) RA82.2 DA3.1 3.52,45.72 5.17,47.37 JHP1.6
HP_LINE1_JD: length 6.7
  BOTTOM w0.108: RA13.2 RA14.2 8.04,33.75 UA1.9
  BOTTOM w0.14: RA13.2 7.66,31.97 6.49,30.8 6.2,30.35 5.96,29.86 5.92,29.73 5.35,29.15 CA23.1
HPOUT_D_L_C: length 12.8
  TOP w0.508: LA6.2 13.91,54.07 13.89,54.09 CA42.2 v1(13.89,55.97) 13.2,56.66 v2(12.84,56.66)
  BOTTOM w0.508: v2(12.84,56.66) 13.18,57.01 13.18,57.88 12.76,58.3 10.58,58.3 10.12,58.77 DA2.1 9.27,58.14 10.8,56.61 JHP1.1
HPOUT_D_R_C: length 31.4
  TOP w0.508: LA7.2 14.22,47.87 14.99,47.1 DA9.1 CA43.1 13.67,46.82 v1(12.97,46.12) 12.62,46.12 12.32,46.43 10.71,46.43 v2(10.28,46.86)
  IN3 w0.508: v2(10.28,46.86) 10.81,46.32 13.59,46.32 14.01,46.74 14.01,50.61 13.35,51.27 13.35,52.55 13.63,52.83 13.63,57.3 12.62,58.3 6.91,58.3 5.8,57.19 JHP1.2
HPOUT_L: length 25.7
  TOP w0.508: RA30.2 10.26,42.35 v2(10.74,42.83) ; RA52.1 13.89,51.58 v2(14.03,51.44) ; v2(12.17,45.71) 11.82,45.37 RA75.2 RA28.2
  IN1 w0.508: v2(6.5,43.6) 6.5,43.23 6.86,42.87 6.86,42.54 7.33,42.07 8.88,42.07 9.64,42.83 v2(10.74,42.83)
  IN3 w0.508: v2(14.03,51.44) 14.62,50.86 14.62,46.49 13.84,45.71 v2(12.17,45.71) 8.62,45.71 v2(6.5,43.6)
  BOTTOM w0.203: v2(6.5,43.6) 6.91,43.19 6.91,42.61 7.24,42.29 UA1.32
HPOUT_L_R1: length 2
  TOP w0.102: v1(14.81,51.28) RA52.2
  TOP w0.457: RA52.2 14.81,53.18 LA6.1
HPOUT_R: length 15.9
  TOP w0.508: RA27.2 RA31.2 10.85,41.77 RA29.2 12.03,42.35 v2(12.09,42.28) ; v2(13.38,47.36) 13.38,48.22 14.09,48.93 RA51.1
  IN3 w0.508: v2(7.54,42.73) 8.04,42.22 12.03,42.22 v2(12.09,42.28)
  IN6 w0.508: v2(13.38,47.36) 13.38,43.57 v2(12.09,42.28)
  BOTTOM w0.203: UA1.33 7.64,42.63 v2(7.54,42.73)
HPOUT_R_R2: length 2.1
  TOP w0.127: v1(14.64,49.97) 15.07,49.54 RA51.2
  TOP w0.508: LA7.1 RA51.2
I2C0_SCK: length 11.3
  TOP w0.089: v2(81.35,8.35) 81.35,8.5 v1(81.08,8.77)
  TOP w0.14: v2(73.86,8.82) 73.86,8.85 73.74,8.72 72.9,8.72 RH424.2
  IN5 w0.089: 75.06,8.8 80.9,8.8 v2(81.35,8.35)
  IN5 w0.099: v2(73.86,8.82) 73.89,8.8 75.06,8.8
  BOTTOM w0.089: v2(81.35,8.35) 81.12,8.58 UH2.AR38
  BOTTOM w0.14: RH521.2 73,8.49 73.53,8.49 v2(73.86,8.82)
I2C0_SCK_DSP: length 115.4
  TOP w0.14: JAUDIO.5 5.6,18.82 v2(5.08,18.3)
  IN1 w0.099: v2(12.64,21.98) 13.01,22.35 13.01,23.12 13.24,23.35 13.24,24.02 12.58,24.68 12.58,29.89 11.2,31.26 10.74,31.58 10.66,31.61 10.44,31.74 9.59,32 7.67,32 6.29,30.62 5.92,30.62 v2(5.78,30.48)
  IN2 w0.099: v2(70.71,9.56) 70.73,9.57 70.73,10.31 70.05,10.98 70.05,16.34 70.76,17.05 70.76,17.91 68.43,20.24 68.43,21.05 v2(68.15,21.32) 68.15,22.38 67.44,23.1 66.31,23.1 65.2,24.2 60.06,24.2 56.07,28.19 46.96,28.19 44.42,30.73 39.44,30.73 38.82,30.11 33.47,30.11 32.44,29.08 30.82,29.08 29.57,27.83 29.01,27.83 28.57,27.39 28.57,26.34 26.71,24.49 25.92,24.49 24.72,23.29 22.83,23.29 22.28,22.74 19.11,22.74 18.18,21.81 15.22,21.81 14.68,22.34 13,22.34 v2(12.64,21.98)
  IN6 w0.099: v2(5.08,18.3) 6.69,19.9 8.87,19.9 9.72,20.75 11.42,20.75 v2(12.64,21.98)
  BOTTOM w0.108: UA1.12 6.84,34.06 5.5,32.72 5.5,32.16 5.27,31.93 5.27,30.98 v2(5.78,30.48)
  BOTTOM w0.127: v2(70.71,9.56) 70.95,9.32 71.28,9.32 71.87,8.72 RH521.1
  BOTTOM w0.14: QE18.4 66.98,19.56 RE136.2 66.98,20.94 67.37,21.32 68.15,21.32 v2(68.15,21.32)
I2C0_SDA: length 7.8
  TOP w0.14: v2(73.39,9.19) 73.39,9.39 73.06,9.72 RH425.2
  BOTTOM w0.089: 75.4,8.82 76,8.82 76.1,8.72 77.96,8.72 78.07,8.83 78.74,8.83 78.95,8.62 UH2.AT42
  BOTTOM w0.127: RH522.2 73.19,9.19 v2(73.39,9.19) 73.45,9.24 74.25,9.24 74.66,8.82 75.4,8.82
I2C0_SDA_DSP: length 110.1
  TOP w0.14: JAUDIO.3 4.8,19.21 v2(5.08,18.93)
  IN1 w0.099: v2(5.78,31.06) 5.66,31.06 5.02,30.42 5.02,28.11 9.34,23.79 11.39,23.79 v2(12.61,22.57)
  IN2 w0.099: v2(12.61,22.57) 12.68,22.64 18.73,22.64 19.03,22.94 22.19,22.94 22.75,23.49 24.64,23.49 25.84,24.69 26.63,24.69 28.37,26.42 28.37,27.48 28.92,28.03 29.49,28.03 30.74,29.28 32.16,29.28 34.05,31.18 35.24,31.18 35.88,30.53 38.95,30.53 39.36,30.94 44.5,30.94 47.04,28.39 56.16,28.39 60.12,24.43 65.26,24.43 66.4,23.3 67.52,23.3 68.63,22.19 68.63,20.33 70.99,17.96 70.99,16.55 v2(70.53,16.09) 70.53,13.09 70.91,12.71 70.91,11.15 71.26,10.79 v2(71.26,9.76)
  IN6 w0.099: v2(5.08,18.93) 5.27,18.93 6.44,20.1 8.78,20.1 9.64,20.95 10.99,20.95 v2(12.61,22.57)
  BOTTOM w0.108: UA1.11 7.24,34.16 5.73,32.65 5.73,32.09 5.53,31.89 5.53,31.31 v2(5.78,31.06)
  BOTTOM w0.127: RH522.1 71.43,9.6 v2(71.26,9.76)
  BOTTOM w0.14: v2(70.53,16.09) 70.14,16.09 v1(69.58,16.65) RE137.2 68.34,16.96 QE18.1
I2C1_SCK_TP: length 144
  TOP w0.14: v2(197.31,11.9) 197.52,11.7 QE2.3 ; v2(68.72,13.08) 68.72,13.34 68.08,13.98 67.93,13.98 67.74,14.17 RH119.2 67.74,15.89 67.11,16.53 v3(67.11,17.33)
  IN5 w0.089: v2(80.13,9.43) 79.36,9.43 79.08,9.71 75.06,9.71
  IN5 w0.099: v2(68.72,13.08) 68.72,11.41 69.46,10.68 71.02,10.68 71.99,9.71 75.06,9.71
  IN6 w0.089: 101.98,11.74 101.82,11.58 99.19,11.58 98.83,11.93 95.5,11.93 95.36,11.79 91.64,11.79 91.45,11.6 86.12,11.6 85.03,10.51 83.18,10.51 82.65,9.98 81.09,9.98 80.92,9.81 80.51,9.81 v2(80.13,9.43)
  IN6 w0.099: v2(197.31,11.9) 196.87,11.45 194.91,11.45 193.72,12.64 190.36,12.64 189.17,11.45 186.7,11.45 186.27,11.02 176.08,11.02 176.05,10.99 164.08,10.99 163.39,10.3 157.15,10.3 156.26,11.18 151.97,11.18 151.74,11.41 149.74,11.41 148.93,10.6 147.71,10.6 147.06,11.25 145.97,11.25 145.49,11.72 129.09,11.72 128.46,12.36 125.61,12.36 124.69,11.43 116.3,11.43 115.7,12.03 113.32,12.03 112.51,11.22 108.35,11.22 107.52,12.06 102.3,12.06 101.98,11.74
  BOTTOM w0.089: UH2.AR41 79.86,8.86 80.13,9.13 v2(80.13,9.43)
I2C1_SCK_TP_C: length 29.1
  TOP w0.14: RE9.1 191.94,10.36 194.3,10.36 194.53,10.59 QE19.3 194.53,11.47 194.69,11.63 194.95,11.63 195.2,11.38 195.2,10.23 196.34,9.09 197.23,9.09 198.82,10.68 198.82,13.66 197.79,14.69 v3(197.36,14.69) DE5.3 189.38,14.26 188.15,13.02 v2(188.15,11.92)
  BOTTOM w0.14: JTP.6 188,11.67 188.15,11.82 v2(188.15,11.92) 188.15,12.61 CE79.1
I2C1_SDA_TP: length 135.2
  TOP w0.14: QE2.6 195.85,12.73 195.33,12.21 v2(195.33,11.86)
  IN6 w0.089: 101.98,12.03 101.71,11.76 99.27,11.76 98.9,12.12 95.44,12.12 95.29,11.97 91.5,11.97 91.37,11.85 86.11,11.85 84.95,10.69 82.65,10.69 82.52,10.82 81.29,10.82 81.1,10.63 81.1,10.25 80.85,10 79.76,10 79.6,9.84 77.14,9.84 v2(76.63,9.33)
  IN6 w0.099: 101.98,12.03 102.21,12.26 107.6,12.26 108.44,11.42 112.42,11.42 113.23,12.23 115.79,12.23 116.39,11.63 124.6,11.63 125.53,12.56 128.55,12.56 129.18,11.93 145.57,11.93 146.05,11.45 147.14,11.45 147.79,10.8 148.84,10.8 149.65,11.61 151.82,11.61 152.05,11.39 156.34,11.39 157.23,10.5 163.3,10.5 164,11.19 175.97,11.19 175.99,11.22 185.42,11.22 187.05,12.84 194.34,12.84 v2(195.33,11.86)
  BOTTOM w0.089: UH2.AR44 78.15,9.16 77.89,8.9 77.06,8.9 v2(76.63,9.33) 75.13,9.33
  BOTTOM w0.127: 75.13,9.33 74.77,9.7 73.94,9.7 v1(73.75,9.89) 73.5,10.14 71.54,10.14 71.49,10.19 70.61,10.19 70.59,10.22 70.14,10.66 RH120.2
I2C1_SDA_TP_C: length 14.1
  TOP w0.14: v2(186.88,11.93) 186.88,11.55 187.21,11.22 188.33,11.22 188.57,11.47 188.57,12.62 188.71,12.76 DE5.2 190.49,12.76 191.33,13.6 v3(191.83,13.6) 193.04,13.6 193.23,13.41 QE19.6 193.23,12.36 192.41,11.54 192.41,11.18 192.28,11.06 RE7.1
  BOTTOM w0.14: JTP.7 187,11.82 v2(186.88,11.93) 186.9,11.95 CE80.1
I2C_EN8723: length 3.5
  BOTTOM w0.14: v1(316.27,28.04) 316.89,28.66 RI25.1 318.41,29.57 UI3.24
I2CA_SCL: length 2
  TOP w0.14: RV1108.2 RV1110.1 201.94,46.81 v1(201.65,46.52)
I2CA_SDA: length 0.8
  TOP w0.14: RV1111.1 RV1109.2
I2CB_SCL: length 16
  TOP w0.102: v2(210,63.38) 209.62,63 209.62,62.29 208.76,61.43 208.76,60.91 208.52,60.66 208.04,60.66 v1(207.53,60.15) 205.78,58.41 204.9,58.41 201.55,55.06 201.55,52.64 RV570.1
  BOTTOM w0.102: UV18.R7 210.39,63 v2(210,63.38)
I2CB_SDA: length 16.5
  TOP w0.102: v2(210.03,62.56) 210.03,62.37 209.5,61.84 209.5,61.34 209.58,61.26 209.58,60.7 209.13,60.26 208.27,60.26 v1(206.87,58.86) 206.19,58.18 205,58.18 201.8,54.99 201.8,52 RV571.1
  BOTTOM w0.102: UV18.R6 210.03,62.56 v2(210.03,62.56)
I2S_BCLK: length 24.2
  TOP w0.14: JAUDIO.9 7.2,18.71 v2(7.05,18.56)
  IN2 w0.099: v2(12.32,34.49) 12.32,33.41 11.91,33 11.91,31.1 13.12,29.9 13.12,26.72 11.96,25.56 11.03,25.56 10.1,24.64 9.37,23.9 9.37,21.12 9.67,20.82 9.67,20.03 9.21,19.57 7.43,19.57 7.05,19.19 v2(7.05,18.56)
  BOTTOM w0.108: UA1.56 12.39,35.72 12.5,35.62 12.5,34.67 v2(12.32,34.49)
I2S_IN: length 29.3
  TOP w0.14: JAUDIO.15 9.6,19.21 10.38,18.44 v2(10.38,17.69)
  IN2 w0.099: v2(10.16,33.88) 10.21,33.88 11.54,35.21 14.33,35.21 15.16,34.38 15.16,30.48 13.82,29.14 13.82,26.43 11.5,24.11 10.57,24.11 10.08,23.61 10.08,21.41 10.38,21.11 v2(10.38,17.69)
  BOTTOM w0.108: UA1.5 9.64,34.34 10.1,33.88 v2(10.16,33.88)
I2S_LRCK: length 26.6
  TOP w0.14: JAUDIO.13 8.8,19.11 9.45,18.47 9.45,17.63 v2(9.21,17.39)
  IN2 w0.099: v2(9.21,17.39) 7.64,17.39 6.59,18.45 6.59,19.81 7.71,20.93 9,24.04 10.88,25.92 11.81,25.92 12.76,26.87 12.76,29.75 11.56,30.95 11.56,32.71 11.47,32.8 11.47,34.33 v2(11.7,34.55)
  BOTTOM w0.14: UA1.1 11.24,34.53 11.36,34.4 11.54,34.4 v2(11.7,34.55)
I2S_MCLK: length 26.4
  TOP w0.14: v2(8.96,17.96) 8.96,18.22 8,19.19 JAUDIO.11
  IN2 w0.099: v2(8.96,17.96) 8.96,17.98 10.02,19.04 10.02,20.97 9.72,21.27 9.72,23.76 10.43,24.46 11.36,24.46 13.47,26.58 13.47,29.29 14.81,30.63 14.81,33.66 14.68,33.79 13.08,33.79 v2(12.76,34.11)
  BOTTOM w0.108: UA1.55 12.72,36.12 12.86,35.98 12.86,34.2 v2(12.76,34.11)
I2S_OUT: length 27.8
  TOP w0.14: JAUDIO.17 10.4,19.16 10.63,18.93 v2(10.92,18.93)
  IN2 w0.099: v2(11.39,35.63) 11.87,36.12 13.65,36.12 13.76,36.23 14.77,36.23 15.67,35.33 15.67,32.42 16.18,31.91 16.18,30.21 14.18,28.2 14.18,26.28 11.65,23.76 10.77,23.76 10.43,23.42 10.43,21.56 10.92,21.06 v2(10.92,18.93)
  BOTTOM w0.108: v2(11.39,35.63) 10.8,35.63 10.44,35.27 UA1.3
I2S_RST_AUDIO#: length 87.8
  TOP w0.14: v2(64.59,15.79) 64.59,15.77 63.26,14.44 v3(63.26,11.91) 63.26,10.36 62.35,9.45 62.35,7.44 62.79,7 RP15.3
  IN6 w0.099: v2(5.45,29.92) 5.27,30.11 5.27,31.67 6.34,32.74 9.8,32.74 13.62,28.91 13.62,24.7 15.55,22.77 21.19,22.77 23.11,24.69 27.13,24.69 27.54,24.28 37.17,24.28 37.8,24.92 45.11,24.92 45.86,24.17 46.86,24.17 48.25,22.79 54.22,22.79 55.48,21.53 55.48,20.79 57.73,18.54 57.73,17.43 59.37,15.79 v2(64.59,15.79)
  BOTTOM w0.14: CA37.1 RA17.2 4.04,29.75 RA93.1 5.44,29.9 v2(5.45,29.92)
I2S_RST_AUDIO#_R: length 6.2
  BOTTOM w0.14: RA93.2 3.99,30.82 3.53,31.28 v1(3.53,31.77) 3.53,31.89 3.8,32.15 3.8,33.61 3.86,33.66 3.86,34.16 4.52,34.83 4.52,35.54 4.7,35.72 UA1.15
I2S_SDIN0_AUDIO_R: length 7.6
  BOTTOM w0.14: RA6.2 2.41,30.36 2.89,30.84 2.89,33.31 v1(2.99,33.41) 2.99,34.12 3.3,34.44 3.79,34.44 4.28,34.93 4.28,35.68 4.72,36.12 UA1.16
I_ADP: length 270.3
  TOP w0.14: v1(56.77,10.55) 56.66,10.66 v2(56.66,11.06) ; UE3.A12 300.77,8.9 v2(301.08,8.59)
  TOP w0.254: v2(56.66,11.06) 56.9,11.3 PR314.1
  IN1 w0.099: v2(56.66,11.06) 58.23,11.06 58.49,10.79 59.43,10.79 60.68,12.04 68.09,12.04 68.95,11.17 69.78,11.17 70.37,11.76 72.27,11.76 72.74,11.29 75.98,11.29 76.15,11.12 78.89,11.12 79.66,11.89 84.87,11.89 85.83,12.85 92,12.85 92.36,13.2 95.02,13.2 96.1,12.13 98.51,12.13 98.74,11.89 100.88,11.89 101.49,12.5 103.45,12.5 104.39,13.45 107.86,13.45 108.33,13.92 109.79,13.92 110.26,13.45 114.83,13.45 116.21,12.07 148.72,12.07 149.23,11.57 153.54,11.57 154.09,11.02 155.38,11.02 156.39,10.02 165.2,10.02 166.15,10.97 177.64,10.97 178.46,10.15 183.23,10.15 183.65,9.73 187.84,9.73 188.57,9 196.33,9 196.98,9.65 200.18,9.65 200.23,9.6 201.46,9.6 202.81,10.94 211.41,10.94 212.41,9.94 214.41,9.94 215.11,9.25 225.42,9.25 225.91,8.76 229.27,8.76 229.5,8.53 233.31,8.53 233.41,8.63 264.71,8.63 265.95,9.88 266.3,9.88 268.89,12.47 269.77,12.47 272.06,14.76 278.55,14.76 279.99,16.2 v2(279.99,16.21)
  BOTTOM w0.14: v2(301.08,8.59) 301.08,7.48 301.51,7.06 301.51,6.49 299.87,4.85 285.5,4.85 280.72,9.64 280.72,15.48 v2(279.99,16.21)
I_BATT: length 245.4
  TOP w0.14: v2(286.86,19.02) 286.69,18.85 RE55.2
  TOP w0.254: PR317.1 60.41,14.6 60.41,13.72 v1(59.3,12.6) v2(58.71,12.01)
  IN1 w0.099: v2(58.71,12.01) 58.94,12.24 68.17,12.24 69.04,11.38 69.7,11.38 70.31,11.98 72.53,11.98 72.81,12.27 84.71,12.27 85.67,13.22 91.32,13.22 92.42,14.33 94.88,14.33 95.14,14.07 95.14,13.62 96.25,12.5 98.66,12.5 99.09,12.08 100.8,12.08 101.43,12.7 102.31,12.7 103.5,13.88 105.07,13.88 105.66,14.47 128.24,14.47 130.44,12.28 148.87,12.28 149.33,11.82 153.57,11.82 154.17,11.22 155.47,11.22 156.12,10.56 162.45,10.56 163.06,11.18 177.72,11.18 178.54,10.35 183.32,10.35 183.71,9.95 187.9,9.95 188.64,9.22 194.83,9.22 194.85,9.2 196.25,9.2 196.94,9.89 200.23,9.89 200.29,9.83 201.3,9.83 202.61,11.14 211.49,11.14 212.49,10.14 214.5,10.14 215.19,9.45 225.51,9.45 225.99,8.96 229.35,8.96 229.58,8.74 233.23,8.74 233.33,8.84 261.98,8.84 262.61,9.47 264.08,9.47 266.29,11.68 266.79,11.68 270.62,15.52 277.7,15.52 279,16.81 283.9,16.81 285.24,18.15 285.99,18.15 v2(286.86,19.02)
ILIM_HI1: length 6.5
  BOTTOM w0.14: UI2.16 331.69,63.01 331.92,62.78 331.94,62.78 332.8,61.92 v1(335.95,61.92) 336.92,61.92 RI12.1
ILIM_HI3: length 2.9
  TOP w0.127: RI7.1 22.85,89.96 UI1.16
  TOP w0.14: v1(22.3,88.29) RI7.1
ILIM_LO1: length 6.4
  BOTTOM w0.14: RI11.1 v1(333.95,62.43) 332.8,62.43 331.72,63.51 UI2.15
ILIM_LO3: length 2.7
  TOP w0.14: UI1.15 22.99,90.46 22.96,90.43 RI6.1 22.3,90.95 v1(21.83,91.42)
ILIM_SEL_L: length 386.3
  TOP w0.127: UI1.4 26.14,88.75 26.31,88.59 27.13,88.59 v2(27.41,88.87)
  TOP w0.14: v2(321.79,47.37) RI33.1 322.63,47.19 RI34.2 322.63,46.05 322.38,45.79 DI12.3 322.01,44.92 RI31.2 320.5,44.92 v1(319.61,44.03)
  IN2 w0.089: 33.45,47.13 33.66,46.92
  IN2 w0.099: 33.66,46.92 33.92,46.65 33.92,44.27 35.55,42.64 35.55,39.51 40.25,34.82 46.27,34.82 47.01,34.08 47.01,33.18 47.48,32.7 51.79,32.7 51.94,32.86 80.59,32.86 81.65,33.92 84.17,33.92 87.16,36.91 95.35,36.91 98.45,40 111.44,40 116.84,34.6 140.48,34.6 144.94,30.14 152.82,30.14 156.54,26.42 157.55,26.42 159.89,24.08 159.89,20.37 160.44,19.81 173.1,19.81 173.53,20.23 174.73,20.23 174.93,20.02 176.33,20.02 177.25,19.11 184.58,19.11 184.65,19.17 207.42,19.17 207.46,19.14 217.89,19.14 217.92,19.11 218.37,19.11 218.41,19.15 252.35,19.15 254.74,21.54 257.54,21.54 258.68,22.69 259.19,22.69 260.54,21.34 264.19,21.34 264.58,21.73 267.49,21.73 268.43,22.66 288.78,22.66 289.78,23.66 290.63,23.66 293,26.04 293.78,26.04 296.4,28.66 308.66,28.66 308.84,28.84 310.1,28.84 310.27,28.66 314.41,28.66 317.88,32.13 317.88,41.41 321.79,45.32 v2(321.79,47.37) ; v2(27.41,88.87) 27.4,88.87 26.39,87.85 26.39,78.53 27.28,77.64 27.28,68.23 28.58,66.94 28.58,57.26 28.58,57.26 28.58,51.4 29.62,50.37 29.89,50.37 30.17,50.08 31.88,50.08 33.17,48.8 33.17,48.77 33.17,47.41 33.45,47.13
