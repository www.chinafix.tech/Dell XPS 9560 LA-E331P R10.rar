# Allegro board Dell XPS 9560 LA-E331P R10.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GNDA_CHG: length 17.4
  TOP w0.254: PC333.1 55.63,23.25 55.02,23.25 v2(54.94,23.17) 54.83,23.06 54.25,23.06 PC332.2 PC330.1 ; PR316.2 55.14,11.76 PC322.1 56.06,11.71 56.06,11.3 56.37,10.39 56.41,10.28 56.57,10.12 57.32,10.12 57.47,10.27 57.47,10.82 57.79,11.13 PC327.2 57.81,11.79 58.64,12.62 58.64,14.16 v2(58.24,14.55)
  IN1 w0.254: v2(54.94,23.17) 54.94,19.41 v2(56.18,18.18)
  vias: v1(53.79,16.85) v2(54.05,18.18) v2(54.05,16.04) v2(55.11,17.11) v2(56.18,16.04)
GNDS_SENSE_VGA: length 4.5
  IN1 w0.381: v2(208.36,58.5) 207.94,58.5 206.82,57.39 v2(206.82,56.14)
  BOTTOM w0.254: UV18.U2 208.74,58.88 v2(208.36,58.5)
  BOTTOM w0.381: v2(206.82,56.14) 206.57,55.89 PR1517.1
V1N: length 33.5
  TOP w0.14: v2(149.8,104.78) 149.92,104.91 v3(150.5,104.91)
  IN1 w0.254: v2(149.8,104.78) 149.8,103.78 147.68,101.66 147.68,101.06 143.7,97.09 131.29,97.09 129.97,98.41 v2(126.58,98.41)
  BOTTOM w0.254: v2(149.8,104.78) 150.05,105.04 PR1219.2 ; PR1212.1 PR1213.1 126.18,98.81 v2(126.58,98.41) 126.71,98.28 127.76,98.28 PR1203.2
V2N: length 38.5
  TOP w0.14: v2(149.86,112.59) v3(150.51,112.59)
  IN1 w0.254: v2(149.86,112.59) 149.86,111.77 146.13,108.04 144.43,108.04 144.14,107.75 144.14,105.93 143.57,105.36 143.57,101.55 141.06,99.03 133.02,99.03 131.42,100.63 127.07,100.63 v2(126.85,100.41)
  BOTTOM w0.254: PR1214.1 PR1215.1 125.74,100.71 126.54,100.71 v2(126.85,100.41) 126.92,100.34 127.66,100.34 PR1207.2 ; PR1221.2 v2(149.86,112.59)
V3N: length 46.7
  TOP w0.14: v3(158.85,105.37) 158.85,105.76 v2(158.62,105.99)
  IN1 w0.254: v2(158.62,105.99) 157.93,105.29 157.93,101.04 156.49,99.6 148.43,99.6 145.11,96.29 133.96,96.29 133.33,95.66 130.53,95.66 129.96,95.08 127.72,95.08 127.12,95.69 126.33,95.69 v2(126.3,95.72)
  BOTTOM w0.254: PR1223.2 158.18,105.55 v2(158.62,105.99) ; PR1211.2 128.07,96.06 127.7,95.69 126.33,95.69 v2(126.3,95.72) 126.3,95.92 125.68,96.54 PR1216.1 125.67,96.67 PR1217.1
VBATT: length 35.6
  IN6 w0.254: v2(26.04,22.95) 26.04,22.81 26.46,22.39 27.62,22.39 28.23,23 41.2,23 42.29,21.91 46.53,21.91 47.3,21.14 50.64,21.14 50.93,20.84 52.3,20.84 52.6,20.53 52.6,19.94 v2(52.57,19.91)
  BOTTOM w0.254: PR320.2 56.14,22.61 55.21,21.69 54.96,21.69 54.26,20.99 53.18,20.99 v1(52.97,20.79) 52.69,20.51 52.69,20.03 v2(52.57,19.91) 52.46,19.8 51.96,19.8 51.5,20.26 PD302.2
VBUS_ACOK: length 38.8
  TOP w0.254: PQ229.1 v3(22.99,18.79) 22.99,18.81 21.12,20.68 v2(21.12,21.15) ; v2(23.37,4.14) 23.89,4.66 PR267.1
  IN5 w0.254: v2(23.37,4.14) 23.37,8.33 25.55,10.51 25.55,20.81 24.51,21.85 21.81,21.85 21.12,21.15 v2(21.12,21.15)
  BOTTOM w0.254: v2(21.12,21.15) 21.12,21.15 20.65,21.62 20.65,22.26 20.02,22.89 18.59,22.89 PR255.1 18.59,22.3 PC217.1 18.23,21.93 PR258.2 17.01,21.6 PU202.1
VBUS_HV_DIS#: length 322.7
  TOP w0.14: UE3.B2 295.52,11.28 v2(295.36,11.45)
  IN6 w0.089: 101.98,8.79 101.89,8.7 99.1,8.7 98.47,8.07 97.55,8.07 97.2,7.72 96.2,7.72 95.73,8.19 94.99,8.19 94.65,7.85 94.65,7.18 94.4,6.93 93.7,6.93 93.52,6.75 92.9,6.75 92.53,7.11 92.53,7.41 92.44,7.5 92.44,7.58 92.23,7.79 91.58,7.79 91.24,7.46 91.24,6.87 90.98,6.61 90.57,6.61 89.93,5.97 89.37,5.97 88.84,5.44 88.3,5.44 87.63,4.77 87.26,4.77 86.81,5.23 85.99,5.23 85.59,5.63 84.63,5.63 84.16,5.17 83.72,5.17 83.29,5.6 83.29,7.41 83.1,7.6 82.01,7.6 81.98,7.63 80.38,7.63 80.08,7.93 78.66,7.93 77.66,6.92 75.87,6.92 75.06,7.73
  IN6 w0.099: 75.06,7.73 73.03,7.73 71.62,9.14 69.79,9.14 66.92,12.01 64.39,12.01 63.68,12.72 54.91,12.72 54.3,13.33 54.3,14.78 53.43,15.65 53.43,18.15 51.67,19.91 51.19,19.91 50.44,20.66 47.11,20.66 46.33,21.43 42.26,21.43 41.8,20.97 32.97,20.97 31.23,19.23 28.59,19.23 25.12,15.76 v2(10.9,15.76) ; 101.98,8.79 102.58,9.39 105.85,9.39 106.15,9.09 107.56,9.09 107.84,9.37 114.75,9.37 114.9,9.22 125.22,9.22 126.43,10.42 127.76,10.42 128.21,9.98 128.21,9.57 128.56,9.22 133.9,9.22 134.53,9.85 144.81,9.85 145.22,9.44 146.31,9.44 148.43,7.32 151.8,7.32 152.27,7.79 154.43,7.79 155.12,7.1 156.66,7.1 157.37,6.4 161.52,6.4 162.78,7.66 165.67,7.66 165.67,7.66 177.86,7.66 178.93,8.73 184.14,8.73 184.64,9.24 187.43,9.24 187.88,8.79 194.77,8.79 195.73,9.75 201.64,9.75 202.71,10.82 210.67,10.82 213.91,7.58 226.68,7.58 228.26,6 237.88,6 239.16,7.27 253.08,7.27 253.28,7.07 256.25,7.07 256.98,7.8 262.47,7.8 262.83,7.44 272.56,7.44 273.73,6.26 282.69,6.26 283.91,7.48 292.07,7.48 293.21,8.62 v2(293.58,8.62)
  BOTTOM w0.14: v2(295.36,11.45) 295.36,10.69 293.58,8.91 v2(293.58,8.62)
  BOTTOM w0.254: PD211.1 7.94,10.66 PR290.1 9.22,11.94 9.22,13.17 9.27,13.23 v1(9.27,14.12) 10.85,15.7 10.85,15.71 v2(10.9,15.76)
VCC0V9_LVR_OUT: length 2.2
  IN2 w0.254: v2(25.4,40.99) 25.41,41 v2(26.05,41) ; v2(24.76,38.38) v2(24.11,38.38)
  BOTTOM w0.203: v2(24.11,38.38) 24.11,38.36 24.4,38.07 UT1.F18 ; v2(24.76,38.38) 25.06,38.07 UT1.H18
  vias: v1(24.09,39.07)
VCC0V9_SVR: length 2.9
  IN4 w0.254: 23.33,42.11 25.59,42.11 v2(26.06,41.64)
  vias: v2(21.9,46.97) v2(22.48,47.13) v2(22.47,46.54) v2(24.11,40.99) v2(24.11,40.34) v2(24.11,39.69) v2(26.71,41.64) v3(23.5,41.01)
VCC1V8A_TBTA_LDO: length 4.2
  BOTTOM w0.203: RT246.2 17.76,63.22 18.33,62.64 18.92,62.64 CT151.1 19.48,62.11 20.02,61.58 20.23,61.58 20.87,60.94 UT4.K1
VCC1V8D_TBTA_LDO: length 2
  BOTTOM w0.152: UT4.A2 21.37,55.73 21.03,55.39 21.03,54.83 CT152.1
VCC3V3_FLASH: length 53.1
  TOP w0.254: RT1093.1 24.52,64.14 23.1,65.56 23.1,66.52 v2(23.02,66.6)
  TOP w0.356: v2(21.88,52.8) 23.09,54.01 RT227.1 ; RT243.1 17.64,70.06 18.2,69.5 RT171.1 19.1,69.22 19.15,69.27 v2(19.55,69.27) 20.05,69.27 21.31,70.53 v3(22.85,70.53) 23.34,70.53 24.21,69.67 24.21,67.27 23.99,67.27 23.34,66.62 23.03,66.62 v2(23.02,66.6) 22.49,66.6 20.94,65.06 20.63,65.06 20.31,64.75 20.31,64.3 21.4,63.22 RT226.1
  TOP w0.381: RT432.1 21.38,62.75 RT226.1
  TOP w0.508: RT189.2 28.53,61.22 28.33,61.41 28.33,66.23 27.29,67.27 24.21,67.27 ; CT146.1 20.89,60.36 20.89,60.02 20.49,59.61 v2(20.26,59.61)
  IN5 w0.508: v2(19.55,69.27) 19.55,69.27 19.55,65.85 20.18,65.21 20.18,63.88 20.89,63.17 20.89,59.58
  BOTTOM w0.254: v2(20.26,59.61) 20.47,59.4 UT4.G1
  BOTTOM w0.305: RT169.1 RT168.1 v2(21.88,52.8)
  BOTTOM w0.356: v2(23.02,66.6) 23.02,66.59 23.03,66.58 23.03,66.49 23.14,66.38 RT170.1
  BOTTOM w0.508: UT5.8 18.56,70.43 19.55,69.44 v2(19.55,69.27)
VCC3V3_TBT_SX: length 1.4
  TOP w0.152: v2(21.92,60.36) 22.09,60.53 CT145.1
  BOTTOM w0.152: v2(21.92,60.36) 21.46,59.9 UT4.H2
VCC5V0_SYS: length 6
  IN2 w0.508: v2(26.18,55.13) 26.13,55.18 26.13,58.25 25.57,58.81 25.57,59.51 25.22,59.86 v2(24.87,59.86)
  BOTTOM w0.203: v2(24.87,59.86) 24.88,59.86 24.92,59.89 25.36,59.89 UT4.H10
  vias: v1(26.4,53.36)
VCC_3V3_PCIE: length 2.2
  TOP w0.089: CT99.1 25.46,38.31 24.99,37.84 v1(24.58,37.84)
  TOP w0.254: CT99.1 25.98,38.31 v2(26.06,38.39)
  BOTTOM w0.254: v2(26.06,38.39) UT1.L16
VCC_3V3_USB2: length 1.1
  TOP w0.254: v2(26.06,39.04) 25.95,38.93 CT100.1
  BOTTOM w0.254: v2(26.06,39.04) UT1.J16
VCC_SENSE: length 47.1
  TOP w0.14: v2(152,95.27) 152,95.83 v3(151.35,96.49)
  IN6 w0.254: v2(152,95.27) 152,95.01 151.73,94.74 151.14,94.74 149.85,96.03 145.62,96.03 143.15,98.51 136.71,98.51 134.18,101.04 129.68,101.04 129.4,100.76 127.84,100.76 127.56,101.04 125.27,101.04 124.98,100.75 120.32,100.75 119.66,100.08 117.62,100.08 117.22,99.69 v2(117.22,98.88)
  BOTTOM w0.254: v2(117.22,98.88) 117.06,98.71 PC1130.2 PR1142.1 ; RH198.2 152.7,93.07 151.84,93.93 151.84,95.12 151.99,95.27 v2(152,95.27)
VCCGT_B+:
  vias: v2(105.36,76.65) v2(105.36,76.02) v2(105.39,75.28) v2(105.39,73.93) v2(105.39,72.59) v2(105.93,77.16) v2(105.93,76.53) v2(105.93,75.89) v2(105.91,70.21) v2(106.05,70.81) v2(106.08,85.65) v2(106.08,85.01) v2(106.08,84.38) v2(106.08,83.74) v2(106.15,82.9) v2(106.15,81.55) v2(106.15,80.21) v2(106.4,75.28) v2(106.4,73.93) v2(106.4,72.59) v2(106.45,69.95) v2(106.73,85.66) v2(106.65,70.5) v2(107.05,69.95) v2(107.17,82.9) v2(107.17,81.55) v2(107.17,80.21) v3(104.45,81.86)
VCCGT_SENSE: length 58.3
  TOP w0.14: v3(148.82,96.43) 148.82,95.52 v2(149.15,95.2)
  TOP w0.254: PC1106.1 PR1113.1 v2(109.73,103.7)
  IN6 w0.254: v2(149.15,95.2) 149.02,95.07 144.92,95.07 142.63,97.36 136.14,97.36 133.88,99.62 128.76,99.62 127.07,97.93 126.11,97.93 125.07,98.97 122.06,98.97 121.02,97.93 119.93,97.93 119.46,98.4 116.66,98.4 114.59,100.47 110.97,100.47 110.43,101 110.43,103 v2(109.73,103.7)
  BOTTOM w0.254: v2(149.15,95.2) 149.31,95.03 149.31,94.23 149.47,94.08 149.48,94.08 154.73,88.82 RH204.2
VCCIO_SENSE: length 2.9
  TOP w0.254: PR808.2 171.98,69.77 172.59,69.16 172.89,69.16 v1(173.16,68.89) 173.16,68.4 v2(173.12,68.36)
  BOTTOM w0.254: UH1.H14 173.48,68.72 v2(173.12,68.36)
VCCSA_SENSE: length 65.7
  TOP w0.14: PC1118.2 124.91,106.26 ; v2(177.51,92.97) 176.99,92.97 v3(176.79,92.77)
  TOP w0.254: 124.91,106.26 v2(124.22,106.26)
  IN6 w0.254: v2(124.22,106.26) 123.74,105.77 123.74,103.85 124.77,102.82 129.55,102.82 130.61,103.88 134.35,103.88 135.6,102.64 135.6,101.67 137.53,99.74 142.2,99.74 142.55,100.08 152.78,100.08 158.2,94.66 169.89,94.66 170.76,93.8 173.48,93.8 174.25,93.04 177.45,93.04 v2(177.51,92.97)
  BOTTOM w0.254: PR1128.2 124.21,106.24 v2(124.22,106.26) ; RH202.2 178.14,92.63 177.8,92.97 v2(177.51,92.97)
VCCSENSE_VGA: length 108.8
  TOP w0.14: v2(172.71,115.96) v1(173.55,115.96)
  TOP w0.254: PR1021.1 172.52,116.15 v2(172.71,115.96)
  IN2 w0.254: v2(214.17,60.9) 214.19,60.88 214.19,58.99 214.18,58.98 214.18,58.95 212.97,57.75 212.97,56.26 209.24,52.52 206.57,52.52 199.71,59.38 199.71,60.63 198.83,61.5 198.02,62.32 197.36,62.32 196.61,63.07 196.61,63.53 196.03,64.11 195.21,64.11 189.67,69.64 189.67,72.94 184.74,77.87 184.74,80.77 181.26,84.26 181.26,85.81 179.71,87.36 178.6,87.36 177.8,86.56 176.66,86.56 176.53,86.43 175.53,86.43 174.94,87.02 174.94,88.86 174.5,89.3 173.57,89.3 173.07,89.8 171.8,89.8 169.9,91.7 169.9,93.01 169.2,93.71 166.18,93.71 165.23,94.66 165.23,98.49 167.81,101.07 167.81,102.65 166.37,104.09 166.37,105.72 167.29,106.64 167.29,110.02 168.53,111.26 168.53,112.47 170.12,114.05 170.12,115.16 170.78,115.83 172.58,115.83 v2(172.71,115.96)
  BOTTOM w0.203: v2(214.17,60.9) 213.77,60.5 UV18.L4
VCCST_PWRGD_CPU: length 6.6
  TOP w0.089: RH154.2 178.31,67.78 v3(179.33,67.78)
  TOP w0.102: RH154.2 177.78,67.51 177.18,68.11 175.63,68.11 175.49,67.97 174.21,67.97 v2(173.87,67.62)
  BOTTOM w0.076: v2(173.87,67.62) 173.51,67.99 UH1.H13
VDD33STB: length 2.8
  TOP w0.14: v2(7.62,33.97) 7.62,33.51 RA100.2 8.34,33.28 RA101.2
  BOTTOM w0.14: v2(7.62,33.97) 7.62,33.98 7.64,34 UA1.10
VDD_1.2V: length 6.1
  TOP w0.14: v2(289.81,27.56) 289.46,27.9 v3(288.98,27.9)
  TOP w0.254: v2(289.81,27.56) 289.54,27.29 PR603.2
  BOTTOM w0.203: PC610.1 289.94,26.49 PR601.1 288.99,26.73 289.31,27.05 289.31,27.5 289.07,27.75 PU600.11
  BOTTOM w0.254: v2(289.81,27.56) 290.13,27.23 PC610.1
VDDS_SENSE_VGA: length 3.9
  IN1 w0.381: v2(208.34,57.67) 208.11,57.67 207.8,57.36 207.8,57.13 208.28,56.65 208.28,56.33 208.08,56.13 v2(207.52,56.13)
  BOTTOM w0.254: v2(208.34,57.67) 208.74,58.06 UV18.U1
  BOTTOM w0.381: PR1520.1 v2(207.52,56.13)
VSS_SENSE: length 47
  TOP w0.14: v3(151.64,94.38) 151.38,94.64 v2(151.38,95.27)
  TOP w0.203: PU1100.18 117,102.27 116.92,102.19 116.92,101.41 117.16,101.16 v2(117.16,101.1) 117.54,100.72 PC1107.1
  IN6 w0.254: v2(117.16,101.1) 117.79,100.47 119.53,100.47 120.21,101.14 124.87,101.14 125.12,101.39 127.71,101.39 127.99,101.11 129.25,101.11 129.53,101.39 134.33,101.39 136.86,98.86 143.29,98.86 145.77,96.39 150.26,96.39 v2(151.38,95.27)
  BOTTOM w0.254: RH465.2 154.73,91.61 153.65,91.61 151.49,93.77 151.49,95.17 151.39,95.27 v2(151.38,95.27)
VSSGT_SENSE: length 63.7
  TOP w0.14: v3(149.53,94.36) 149.84,94.67 v2(149.84,95.2)
  TOP w0.203: v2(112.65,106.05) 112.68,106.09 PU1100.6
  TOP w0.254: v2(112.65,106.05) 112.46,106.05 112.27,105.86 PC1109.1
  IN6 w0.254: v2(112.65,106.05) 111.19,104.59 109.41,104.59 109.09,104.28 109.09,103.39 110.05,102.43 110.05,100.88 110.82,100.11 114.45,100.11 116.52,98.04 119.31,98.04 119.78,97.57 121.17,97.57 122.2,98.6 124.94,98.6 125.96,97.57 127.22,97.57 128.91,99.26 133.74,99.26 135.99,97.01 142.48,97.01 144.77,94.71 149.36,94.71 v2(149.84,95.2)
  BOTTOM w0.254: v2(149.84,95.2) 149.84,95.2 149.68,95.04 149.68,94.38 153.79,90.28 154.73,90.28 RH471.2
VSSIO_SENSE: length 2.5
  TOP w0.254: v2(172.29,68.75) 171.79,68.75 v1(171.77,68.78) 171.34,69.21 171.29,69.21 PR809.2
  BOTTOM w0.254: v2(172.29,68.75) 172.8,68.75 UH1.J14
VSSSA_SENSE: length 72.4
  TOP w0.14: v2(177.51,92.39) 178.36,92.39 v3(178.56,92.59)
  TOP w0.203: PU1100.31 120.76,106.09 120.93,105.91 121.35,105.91 121.62,106.18 121.62,106.77 121.92,107.07 121.92,107.98 v2(121.84,108.06) 121.97,108.19 122.39,108.19 PC1121.1
  IN6 w0.254: v2(121.84,108.06) 122.68,108.06 123.38,107.36 123.38,103.7 124.63,102.46 129.69,102.46 130.76,103.53 134.21,103.53 135.24,102.49 135.24,101.52 137.38,99.38 142.35,99.38 142.69,99.73 152.62,99.73 158.04,94.31 169.74,94.31 169.99,94.06 170.61,93.44 173.34,93.44 174.1,92.68 176.9,92.68 177.18,92.4 177.5,92.4 v2(177.51,92.39)
  BOTTOM w0.254: v2(177.51,92.39) 177.37,92.39 177.13,92.63 RH470.2
VSSSENSE_VGA: length 108.3
  TOP w0.254: v2(168.53,109.74) v1(168.53,111.16) 168.53,113.31 169.8,114.58 169.8,114.88 170.32,115.4 PR1018.1
  IN2 w0.254: v2(168.53,109.74) 168.53,105.54 168.57,105.5 168.57,103.62 168.19,103.24 168.19,100.95 165.58,98.35 165.58,94.81 166.33,94.07 169.35,94.07 170.26,93.16 170.26,91.85 171.94,90.16 173.22,90.16 173.72,89.66 174.89,89.66 176.82,87.73 179.23,87.73 179.55,88.06 180.79,88.06 181.97,86.88 182.88,86.88 184.79,84.97 184.79,81.23 185.1,80.92 185.1,78.37 185.93,77.54 186.69,77.54 187.01,77.86 187.8,77.86 188.13,77.54 188.13,74.99 190.03,73.09 190.03,69.79 195.36,64.46 196.18,64.46 196.97,63.67 196.97,63.22 197.51,62.68 198.16,62.68 199.19,61.65 200.06,60.78 200.06,59.53 206.71,52.88 209.09,52.88 209.51,53.3 209.51,53.66 208.88,54.29 208.88,54.65 209.24,55.01 209.6,55.01 210.23,54.38 210.59,54.38 210.95,54.74 210.95,55.1 210.32,55.73 210.32,56.09 210.68,56.45 211.04,56.45 211.67,55.81 212.03,55.81 212.62,56.4 212.62,57.9 213.82,59.1 213.82,59.13 213.83,59.13 213.83,60.4 213.34,60.89 v2(213.34,60.9)
  BOTTOM w0.203: UV18.L5 213.73,61.3 213.34,60.91 v2(213.34,60.9)
+AC_IN: length 38.3
  TOP w0.102: v3(12.13,32.46) 12.4,32.19 v2(12.89,32.19)
  TOP w0.381: PR219.1 12.96,61.08 v2(12.97,61.1)
  TOP w0.508: PR222.1 PR220.1 21.01,3.3 v2(20.77,3.06) PC208.1 ; v2(12.98,30.67) 12.98,30.41 13.51,29.88 PQ216.3
  IN1 w0.508: 14.16,29.66 13.58,29.08 13.58,24.59 14.12,24.04 14.12,21.61 14.37,21.37 14.37,20.54 13.53,19.69 13.53,16.33 18.63,11.22 18.63,9.51 19.28,8.86 19.28,4.54 v2(20.77,3.06)
  BOTTOM w0.457: v2(12.97,61.1) 12.11,60.24 PC221.1
  vias: v2(12.32,31.7) v2(12.4,61.69) v2(12.5,31.12) v2(12.89,33.36) v2(12.89,32.77) v2(12.9,31.59) v2(12.97,62.29) v2(12.98,61.69) v2(13.42,31.31) v2(13.45,32.51) v2(13.46,31.92) v2(13.55,62.29) v2(13.56,61.69) v2(13.55,61.1) v2(13.59,30.7) v2(14.14,62.29) v2(14.15,61.69) v2(14.14,61.1) v2(14.16,33.16) v2(14.16,32.52) v2(14.73,61.69) v2(14.72,61.1) v2(15.33,61.1)
+DC_IN: length 47.4
  TOP w0.102: v2(22.23,87.71) v3(20.87,87.71) ; v3(17.02,72.65) 17.27,72.4 v2(17.27,71.89)
  TOP w0.254: v2(19.56,26.7) 19.47,26.7 19.09,27.08 19.09,27.78 18.39,28.49 PC200.1 18.39,28.73 19.28,29.63 20.02,29.63 20.61,30.22 PR213.1 20.63,29.54 20.7,29.47 PR201.1
  TOP w0.508: PD202.2 33.45,21.52 32.89,20.96 v3(32.89,15.76) v2(32.45,15.31)
  IN2 w0.508: v2(15.62,79.56) 15.62,82.63 20.7,87.71 v2(22.23,87.71)
  IN5 w0.508: v2(21.08,24.98) 21.79,24.27 23.81,24.27 27.88,20.2 27.88,19.43 28.63,18.68 30.16,18.68 31.84,17 31.84,15.88 32.41,15.31 v2(32.45,15.31)
  BOTTOM w0.508: PC115.1 PC114.1
  vias: v2(15.43,71.76) v2(15.43,71.13) v2(15.69,70.56) v2(16.02,71.76) v2(16.02,71.13) v2(16.32,70.56) v2(16.64,71.83) v2(16.6,71.13) v2(16.96,70.56) v2(17.16,71.31) v2(17.74,71.31) v2(17.91,71.88) v2(19.23,26.16) v2(19.23,25.56) v2(19.81,26.16) v2(19.81,25.56) v2(19.81,24.98) v2(20.3,26.81) v2(20.45,26.22) v2(20.45,25.62) v2(20.45,24.98) v2(20.88,26.81) v2(21.08,26.22) v2(21.08,25.62)
+DC_IN_SS: length 89.3
  TOP w0.102: v2(55.05,1.85) 54.61,1.41 v3(54.61,1.39)
  IN2 w0.508: v2(35.31,21.41) 35.31,22.61 36.08,23.39 38.45,23.39 42.47,19.36 47.8,19.36 48.96,20.52 51.06,20.52 53.05,18.53 53.05,15.76 53.76,15.05 53.76,13.41 52.59,12.24 52.59,6.94 55.21,4.33 55.21,2.01 v2(55.05,1.85)
  IN5 w0.508: v2(26.79,26.55) 26.79,26.44 27.15,26.08 32.35,26.08 33.4,25.03 33.4,23.31 v2(35.31,21.41)
  IN6 w0.508: v2(9.82,17.43) 9.82,17.38 10.49,16.71 23.62,16.71 27.15,20.24 29.24,20.24 31.31,22.32 34.4,22.32 v2(35.31,21.41)
  BOTTOM w0.457: PR261.1 9.4,18.46 9.79,18.07 9.79,17.46 v2(9.82,17.43)
  BOTTOM w0.508: PD304.2 56.9,6.43 56.9,5.49 56.86,5.45 56.86,4.34 56.94,4.26 56.94,3.32 55.46,1.85 v2(55.05,1.85)
+DCPRTC: length 5.1
  TOP w0.089: 86.69,5.2 86.69,5.25 87.02,5.58 87.75,5.58 87.96,5.36 87.96,3.96 v3(87.69,3.69)
  TOP w0.254: CH70.1 86.69,5.2 86.31,5.58 v2(86.31,5.89)
  BOTTOM w0.203: v2(86.31,5.89) 86.47,6.05 UH2.BA26
+EDPVDD: length 13.9
  TOP w0.254: RV547.1 RV545.1 71.3,26.81 71.3,28.83 69.28,30.85 66.65,30.85 65.37,32.14 ; 64.7,30.16 65.92,28.94 65.92,28.02 65.74,27.83 RV546.1
  vias: v2(61.66,31.71) v2(62.26,31.7) v3(52.58,32.97) v3(56.45,32.97) v3(61.25,32.64)
+FB_PLLAVDD: length 6.5
  TOP w0.102: v1(217.48,71.48) 217.17,71.79 v2(216.73,71.79)
  TOP w0.381: v2(215.51,78.81) 215.26,78.56 214.77,78.56 CV923.1
  TOP w0.508: v2(209.15,80.18) 208.94,80.18 CV921.1 ; CV922.1 216.68,71.85 v2(216.73,71.79)
  BOTTOM w0.254: UV18.H17 v2(216.73,71.79) ; v2(209.15,80.18) 209.12,80.18 UV18.U27
  BOTTOM w0.305: v2(215.51,78.81) 214.91,78.81 214.47,79.25 214.47,79.69 UV18.K27
  vias: v2(191.66,83.93) v2(191.89,83.39)
+FBA_VREFC0: length 60
  TOP w0.406: v2(225.25,110.82) 225.25,109.83 224.67,109.26 CV927.1 223.71,109.26 RV625.1
  TOP w0.508: v2(204.09,104.91) 204.09,105.03 CV926.1 ; RV625.1 223.7,108.96 RV623.2 224.26,108.11 224.52,107.85 RV624.2
  IN6 w0.508: v2(204.09,104.91) 203.01,105.99 203.01,109.8 204.67,111.46 209.73,111.46 210.44,110.75 212.6,110.75 213.95,112.1 217.73,112.1 218.31,111.51 223.33,111.51 224.03,110.82 v2(225.25,110.82)
  BOTTOM w0.254: v2(225.25,110.82) v1(226.82,112.38) 227.28,112.85 229.2,112.85 230.46,111.59 237.99,111.59 239.33,110.24 239.33,104.34 238.89,103.89 238.1,103.89 UV23.J14 ; v2(204.09,104.91) 204.09,104.64 UV24.J14
+FBA_VREFC0_R: length 5.3
  TOP w0.508: QV101.1 221.01,106.74 QV95.1 222.6,106.17 v1(222.6,107.2) 222.85,107.46 RV624.1
+FBC_VREFC1: length 61.3
  TOP w0.102: CV988.1 241,91.07
  TOP w0.14: v1(240.87,91.53) 240.87,91.21 241,91.07
  TOP w0.406: CV989.1 v2(247.05,96.15) ; CV989.1 247.05,94.45 RV636.1 ; CV989.1 246.15,95.4 RV635.2 246.14,96.34 RV634.2
  TOP w0.508: CV988.1 241.87,90.55 242.52,89.9 v2(242.52,89.84)
  IN3 w0.508: v2(247.05,96.15) 247.05,95.29 242.52,90.76 v2(242.52,89.84)
  IN6 w0.508: v2(242.52,56.1) 242.52,56.01 243.14,55.38 244.22,55.38 244.7,55.86 244.7,55.86 244.73,55.89 244.73,59.67 245.46,60.4 245.99,60.4 246.7,61.11 246.7,62.84 246.49,63.05 246.49,64.96 246.73,65.2 246.73,67.55 243.59,70.7 243.59,76.21 245.49,78.11 247.52,78.11 248.03,78.62 248.03,79.57 247.33,80.27 247.33,82.75 247.51,82.93 247.51,85.6 244.94,88.17 244.94,89.12 244.22,89.84 v2(242.52,89.84)
  BOTTOM w0.254: UV26.J14 v2(242.52,89.84) ; UV25.J14 v2(242.52,56.1)
+FBC_VREFC1_R: length 4.6
  TOP w0.508: QV102.1 244.73,92.43 v1(245.71,93.4) 246.14,93.84 RV635.1 245.57,94.49 245.17,94.89 QV96.1
+GPCPLL_AVDD: length 13.3
  TOP w0.14: CV1050.1 214.9,76.72 CV1051.1 216.03,77.85 216.03,78.94 215.9,79.07 v2(215.9,79.38) 216.58,79.38 v1(216.8,79.6) 217.16,79.96 217.16,80.33 217.41,80.58 217.77,80.58 217.8,80.55 219.38,80.55 219.62,80.31 219.62,79.63 219.39,79.41 CV850.1 ; v2(213.36,80.21) 213.45,80.3 RV574.1
  IN2 w0.099: v2(213.36,80.21) 213.77,79.8 215.49,79.8 v2(215.9,79.38)
  BOTTOM w0.14: v2(215.9,79.38) 216.34,78.95 UV18.H26
+GPU_CORE: length 88.7
  TOP w0.381: PC1012.1 204.4,77.89 v2(204.78,77.89)
  TOP w0.508: PR1023.1 180.52,110.89 ; v2(165.69,118.87) 165.69,119.15 164.31,120.52 154.33,120.52 RV1810.1
  IN1 w0.508: v2(165.69,118.87) 168.19,118.87 172.82,114.23 172.82,112.2 173.64,111.39 175.85,111.39 176.84,110.4 176.84,110.23 177.56,109.51 177.56,109.51
  IN2 w0.099: v2(211.65,59.32) 211.27,59.7 211.27,61.03 210.16,62.14 209.04,62.14 208.6,62.58 208.6,63.83 207.44,64.99 205.46,64.99 204.63,65.82 202.04,65.82 200.66,67.19 197.32,67.19 196.98,67.53 196.98,67.78 196.74,68.02 194.99,68.02 192.28,70.73 192.28,79.43 189.97,81.73 189.97,84.74 190.25,85.01 190.25,92.79 188.86,94.17 184.16,94.17 184.04,94.05 183.52,94.05
  vias: v2(180.68,110.02) v2(180.68,109.39) v2(180.68,108.81) v2(180.68,108.2) v2(180.68,107.55) v2(180.68,106.97) v2(180.68,106.36) v2(180.68,105.76) v2(180.68,105.15) v2(180.68,104.56) v2(180.68,103.95) v2(181.5,96.07) v2(181.5,95.49) v2(181.5,94.9) v2(181.5,94.32) v2(182.06,110.31) v2(182.06,109.29) v2(182.06,103.17) v2(182.06,102.59) v2(182.08,97.82) v2(182.08,97.24) v2(182.08,96.66) v2(182.08,96.07) v2(182.08,95.49) v2(182.08,94.9) v2(182.08,94.32) v2(182.18,104.97) v2(182.18,104.36) v2(182.18,103.76) v2(182.37,109.8) v2(182.37,102.07) v2(182.64,103.17) v2(182.64,102.59) v2(182.69,109.29) v2(182.67,97.82) v2(182.67,97.24) v2(182.67,96.66) v2(182.67,96.07) v2(182.67,95.49) v2(182.67,94.9) v2(182.67,94.32) v2(182.82,104.97) v2(182.82,104.36) v2(182.82,103.76) v2(183.01,109.8) v2(182.96,102.07) v2(183.25,103.2) v2(183.25,102.61) v2(183.25,97.82) v2(183.25,97.24) v2(183.25,96.66) v2(183.25,96.07) v2(183.25,95.49) v2(183.25,94.9) v2(183.33,109.29) v2(183.45,104.97) v2(183.45,104.36) v2(183.45,103.76) v2(183.54,102.07) v2(183.83,103.2) v2(183.83,102.61) v2(183.77,101.46) v2(183.77,100.83) v2(183.77,100.25) v2(183.77,99.67) v2(183.77,99.08) v2(183.83,97.82) v2(183.83,97.24) v2(183.83,96.66) v2(183.83,96.07) v2(183.83,95.49) v2(183.83,94.9) v2(184.09,104.97) v2(184.09,104.36) v2(184.09,103.76) v2(184.13,102.07) v2(184.66,96.52) v2(184.66,95.93) v2(185.24,96.52) v2(185.24,95.93) v2(185.83,96.52) v2(185.83,95.93) v2(186.46,96.54) v2(186.46,95.96) v2(187.05,96.54) v2(187.05,95.96) v2(187.71,95.31) v2(188.02,94.78) v2(188.09,96.45) v2(188.09,95.86) v2(188.34,95.31) v2(188.72,96.27) v2(188.66,94.78) v2(188.81,95.68) v2(199.95,63.41) v2(201.03,71.94) v2(201.13,71.32) v2(201.36,76.45) v2(201.72,75.5) v2(201.7,74.49) v2(202.15,58.29) v2(202.83,57.49) v2(203.33,76.9) v2(203.34,72.82) v2(203.28,66.74) v2(203.34,63.39) v2(203.39,70.85) v2(204.34,68.01) v2(205.84,63.39) v2(205.84,62.57) v2(205.84,61.71) v2(205.84,60.11) v2(206.44,72.9) v2(206.36,70.71) v2(206.35,69.81) v2(206.69,60.08) v2(207.27,70.62) v2(207.33,67.74) v2(207.34,66.77) v2(207.32,65.99) v2(207.4,61.79) v2(207.52,64.33) v2(207.5,63.37) v2(207.45,62.41) v2(208.34,76.78) v2(208.33,75.82) v2(208.33,67.65) v2(208.34,66.01) v2(208.37,69.82) v2(209.35,77.82) v2(209.35,69.82) v2(209.35,69.05) v2(209.29,66.78) v2(209.36,72.91) v2(210.29,77.67) v2(210.26,69.86) v2(210.49,72.78) v2(211.33,77.67) v2(211.32,72.78) v2(211.3,70.57) v2(211.36,68.87) v2(211.72,65.71) v2(212.19,68.78) v2(212.31,77.68) v2(212.27,75.78) v2(212.27,70.76) v2(212.4,72.68) v2(213.24,66.77) v2(213.36,77.8) v2(213.36,76.91) v2(213.46,70.73) v2(213.57,72.79) v2(214.18,77.84) v2(214.17,68.79) v2(214.34,74.8) v2(214.31,72.82) v2(215.08,70.46) v2(215.14,69.11) v2(215.29,74.81) v2(215.32,72.2) v2(215.35,75.89) v3(183.26,107.32)
+GPU_CORE_VDDS: length 84.2
  TOP w0.508: v2(224.85,118.32) 224.22,118.32 RV1808.1 ; v2(205.46,66.74) 205.05,67.15 PC1502.1 ; PR1521.1 175.9,118.12 175.2,118.82 v2(175.2,119.33)
  IN1 w0.508: v2(224.85,118.32) 223.93,117.4 222.94,117.4 222.94,117.41 221.91,117.41 220.02,115.52 220.02,112.62 219.52,112.12 212.15,112.12 210.19,110.16 v2(210.19,109.14) ; 197.69,110.07 198.6,110.07 199.48,110.94 199.75,110.94 200.75,111.95 v2(201.14,111.95)
  IN4 w0.508: v2(175.2,119.33) 175.52,119.01 180.79,119.01 181.38,118.41 193.87,118.41 194.84,117.43 194.84,114.09 197.3,111.64 v2(197.3,108.47) ; v2(201.14,111.95) 201.77,111.95 202.61,111.11 202.61,111.04 202.9,110.75 204.24,110.75 204.98,111.49 209.39,111.49 210.15,110.73 210.15,109.18 v2(210.19,109.14)
  BOTTOM w0.203: 206.26,67.2 206.26,67.16 205.84,66.74 v2(205.46,66.74)
  BOTTOM w0.254: UV18.W21 206.84,75.37 v2(206.44,75.76) ; v2(211.39,76.84) 211.84,77.29 UV18.P23 ; v2(208.35,71.8) 207.86,72.3 UV18.V18 ; v2(203.33,74.81) UV18.AC21 ; UV18.W14 206.38,67.84 206.38,67.32 206.26,67.2 ; UV18.AA19 204.84,73.37 v2(204.47,73.73) ; v2(205.36,76.72) 204.84,77.24 UV18.AA23
  BOTTOM w0.305: v2(208.35,71.8) 208.84,71.32 UV18.U17 ; UV18.AA12 204.96,66.3 205.41,66.74 v2(205.46,66.74) ; v2(213.54,74.79) 213.54,75 UV18.M21 ; v2(211.24,66.77) 211.71,66.3 UV18.P12 ; UV18.P16 211.84,70.18 v2(212.15,69.86) ; UV18.AC14 203.04,68.3 v2(203.39,68.65) ; v2(204.4,69.86) UV18.AA16 ; v2(210.31,75.77) UV18.T21 ; v2(212.17,73.8) 211.84,73.47 UV18.P19 ; UV18.T14 v2(210.36,67.78) ; UV18.M14 v2(213.36,68.77)
  vias: v2(190.87,97.89) v2(190.87,97.29) v2(190.88,96.66) v2(192.66,96.91) v2(192.79,99.86) v2(192.79,99.27) v2(192.79,98.69) v2(192.79,98.08) v2(192.79,97.48) v2(193.1,100.4) v2(193.23,102.24) v2(193.23,101.61) v2(193.23,100.97) v2(193.26,102.88) v2(193.42,99.86) v2(193.42,99.27) v2(193.42,98.69) v2(193.42,98.08) v2(193.42,97.48) v2(194.06,99.86) v2(194.06,99.27) v2(194.06,98.69) v2(194.06,98.08) v2(194.06,97.48) v2(194.63,101.8) v2(194.63,101.16) v2(194.57,100.47) v2(194.69,103.7) v2(194.69,103.07) v2(194.69,102.43) v2(194.69,99.86) v2(194.69,99.27) v2(194.69,98.69) v2(195.14,101.48) v2(195.14,100.78) v2(195.33,103.7) v2(195.33,103.07) v2(195.33,102.43) v2(195.96,103.7) v2(195.96,103.07) v2(195.96,102.43) v2(196.53,107.2) v2(196.6,103.7) v2(196.6,103.07) v2(196.6,102.43) v2(197.3,107.83) v2(197.3,107.2) v2(197.3,106.56) v2(197.3,105.93) v2(197.3,105.29) v2(197.3,104.66) v2(197.3,104.02) v2(197.3,103.39) v2(197.3,102.75) v2(197.87,106.24) v2(197.87,105.61) v2(197.87,104.97) v2(197.87,104.34) v2(197.87,103.7) v3(196.91,100.4)
+INV_PWR_SRC: length 4.4
  TOP w0.127: v2(49.12,26.93) 49.14,26.93 50.23,28.03 v3(50.23,28.23) ; v2(49.12,26.93) 49.12,26.44 v3(48.31,25.62) ; v2(49.12,26.93) v3(48.39,27.66)
+NVVDDS_B+: length 27.3
  TOP w0.14: PC1510.1 189.42,109.97 189.57,109.81 v1(190.11,109.81)
  IN5 w0.254: v2(174.56,118.56) 175.65,118.56 176.71,119.62 187.19,119.62 189.84,116.96 189.84,112.21 187.94,110.31 v2(186.95,110.31)
  BOTTOM w0.254: PR1514.1 174.67,118.45 v2(174.56,118.56)
  vias: v2(185.68,110.31) v2(186.31,110.31) v2(187.07,109.74)
+ODR_PWR: length 26.4
  TOP w0.127: v2(327.22,51.16) 327.03,51.35 327.03,52.79 v3(327.37,53.13) ; v3(328.17,47.33) 328.75,47.33 329.52,48.09 329.52,49.5 ; v3(326.34,47.71) 327.36,48.73 327.36,49.95
  IN3 w1.016: 334.71,38.62 333.95,39.38 331.47,39.38 327.72,43.13 327.72,49.79
  BOTTOM w0.127: v2(327.22,51.16) 326.68,51.7 v3(326.68,52.75)
  BOTTOM w0.203: UR1.12 337.44,36.89
  BOTTOM w0.305: 337.44,36.89 337.21,36.89 v2(336.91,36.58)
  vias: v2(327.22,50.58) v2(336.32,36.58)
+PEX_PLL_HVDD: length 1.9
  TOP w0.14: v1(200.41,65.67) 200.22,65.48 199.25,65.48
  BOTTOM w0.305: v2(199.94,66.74) 199.54,67.14 UV18.AH12
+PEX_PLL_VDD: length 31.1
  TOP w0.14: v1(204.27,103.83) 203.57,104.53 v2(202.76,104.53)
  TOP w0.508: CV121.1 201.74,78.05 v2(201.68,77.99)
  IN3 w0.508: 201.04,81.16 201.04,79.7 201.68,79.07 v2(201.68,77.99) ; v2(202.76,104.53) 202.76,88.27 202.44,87.96 202.44,87.29 201.61,86.47 201.45,86.3 201.45,85.33 201.61,85.16 201.61,84.24 200.92,83.54 200.92,82.62
  BOTTOM w0.254: UV18.AG26 200.77,78.9 v2(201.68,77.99)
+PEX_SVDD_3V3: length 4.8
  TOP w0.14: RV1074.1 201.79,65.11 v1(201.7,65.03)
  TOP w0.508: RV1074.1 201.79,66.51 201.32,66.98 201.32,67.42 201.03,67.71 CV1049.1 199.98,67.71 v2(199.9,67.64)
  BOTTOM w0.102: v2(199.9,67.64) 200.34,67.2 UV18.AG12
+PWR_SRC_AC:
  vias: v1(53.66,9.85)
+RTC_CELL_VBAT: length 6.5
  TOP w0.305: UE3.B64 294.97,13.38 v2(295.22,13.62)
  TOP w0.508: v2(292.41,12.37) 291.91,12.37 291.49,12.79 CE17.1 RE16.2
  BOTTOM w0.508: v2(295.22,13.62) 294.02,13.62 292.76,12.37 v2(292.41,12.37)
+RTCBATT: length 41.2
  TOP w0.508: JRTC.1 329.75,101.92 329.06,101.23 329.06,92.91 331.34,90.62 v3(331.34,86.37) 331.34,84.34 332.8,82.88 346.46,82.88 347.16,82.18 348.62,82.18 349.19,82.75 RH67.2
+RTCVCC: length 494.9
  TOP w0.254: RP19.6 289.31,8.64 v2(288.85,9.1) 288.89,9.14 RP19.5
  TOP w0.381: v2(12.15,26.85) 12.54,27.25 12.54,29.47 11.69,31.29 11.69,32.07 11.55,32.47 10.88,33.14 10.11,33.14 RA101.1 ; RE50.1 287.29,15.18 287.29,15.73 v2(287.22,15.79) ; CH173.1 CH80.1 89.16,7.86 CH196.1 89.16,6.52 89.34,6.33 v2(89.56,6.33)
  TOP w0.508: v2(345.06,85.61) 345.58,85.09 D122.3 CH44.1 ; RE34.1 RE90.1 290.83,3.94 290.33,3.44 287.26,3.44 283.1,7.6 v3(282.39,7.6) v2(281.75,7.6) ; RE16.1 v2(290.32,11.25)
  IN1 w0.508: v2(288.85,9.1) 287.34,7.6 v2(281.75,7.6) ; v2(311.98,13.03) 311.98,9.72 313.18,8.52 313.18,6.99 313.82,6.36 317.06,6.36 317.76,7.06 317.76,11.18 315.12,13.82 315.12,16.08 325.59,26.55 327.84,26.55 331.98,30.69 339.36,30.69 341.6,32.93 343.5,32.93 345,34.43 345,36.33 345.63,36.97 346.77,36.97 348.55,38.74 348.55,40.39 347.79,41.16 347.79,54.81 347.04,55.56 347.04,57.93 342.46,62.52 338.71,62.52 333.82,67.41 333.82,80.37 337.15,83.7 344.23,83.7 345.06,84.53 v2(345.06,85.61)
  IN3 w0.381: v2(13.51,21.91) 13.82,21.6 13.82,21.46 15.01,20.28 17.3,20.28 17.87,20.85 19.43,20.85 19.69,20.59 20.31,20.59 20.56,20.85 20.56,21.39 20.87,21.7 23.6,21.7 24.2,22.3 26.93,22.3 27.66,23.02 28.68,23.02 29.51,23.85 39.63,23.85 41.71,21.77 41.71,21 42.59,20.12 46.93,20.12 47.06,20.25 51.14,20.25 53.25,18.14 53.25,15.28 54.46,14.08 54.46,13.19 55.63,12.02 57.77,12.02 58.45,11.33 v2(58.61,11.33)
  IN4 w0.381: v2(58.61,11.33) 58.61,11.03 64.22,5.42 74.31,5.42 75.5,4.23 77.34,4.23 77.67,4.57 87.84,4.57 89.56,6.28 v2(89.56,6.33) 90.3,5.59 90.3,5.41 91.15,4.57 95.77,4.57 v2(96.47,5.27)
  IN5 w0.457: 96.57,6 96.41,5.84 96.41,5.33 v2(96.47,5.27)
  IN5 w0.508: v2(290.32,11.25) 290.32,13.22 291.57,14.46 293.42,14.46 294.87,13.01 295.47,13.01 295.47,13.01 296.76,13.01 296.87,12.9 301.42,12.9 301.51,12.99 ; 96.57,6 96.75,6.18 97.69,6.18 ; 98.98,6.28 99.51,6.28 100.72,7.5 101.53,7.5 103.22,9.2 112.38,9.2 113.15,8.43 113.15,8.15 114.37,6.93 116.52,6.93 118.52,8.92 125.88,8.92 126.19,9.24 145.08,9.24 147.36,6.95 151.54,6.95 152.46,7.88 154.94,7.88 155.32,7.5 158.51,7.5 160.02,5.99 162.07,5.99 163.13,7.06 166.25,7.06 168,5.31 170.17,5.31 170.54,4.95 172.19,4.95 172.33,4.81 172.96,4.81 174.13,5.98 176.46,5.98 177.96,4.48 178.99,4.48 179.31,4.8 180.12,4.8 183.44,8.11 191.14,8.11 193.5,10.47 203.45,10.47 203.72,10.74 214.79,10.74 215.72,11.67 219.15,11.67 220.4,10.42 250.45,10.42 250.55,10.52 264.85,10.52 265.57,9.8 268.91,9.8 269.32,10.21 270.96,10.21 271.27,10.52 278.12,10.52 279.22,9.42 279.22,8.6 280.23,7.6 v2(281.75,7.6)
  IN6 w0.381: v2(13.51,21.91) 13.51,24.11 12.15,25.47 v2(12.15,26.85)
  BOTTOM w0.203: v2(89.56,6.33) 89.22,5.99 UH2.BA22
  BOTTOM w0.508: v2(287.22,15.79) 288.44,15.79 288.95,15.29 288.95,13.28 289.44,12.8 289.94,12.8 290.32,12.42 v2(290.32,11.25) 289.8,11.25 288.85,10.3 v2(288.85,9.1)
+SD_VDD2: length 36.7
  TOP w0.762: JCR.16 v2(349.82,47.3)
  IN6 w0.762: v2(336.74,37.35) 336.09,37.35 335.92,37.52 334.79,37.52 333.19,39.12 331.41,39.12 330.77,39.76 330.77,42.81 332.93,44.97 332.93,45.6 335.28,47.95 345.83,47.95 v2(346.74,47.05)
  BOTTOM w0.203: UR1.13 336.8,37.29 v2(336.74,37.35)
  BOTTOM w0.762: 347.54,49.22 347.54,49.49 348.07,50.02 349.21,50.02 349.97,49.26 349.97,48.27 349.82,48.12 v2(349.82,47.3)
+SDC_IN: length 17
  TOP w0.127: v3(54.55,4.07) 54.32,3.84 v2(54.32,3.5)
  IN2 w0.508: v2(51.69,13.66) 51.98,13.37 51.98,5.62 v2(53.47,4.14)
  BOTTOM w0.381: v2(51.69,13.66) 52.69,12.66 PR399.2
  BOTTOM w0.508: v2(51.69,13.66) 51.69,14.49 PR304.1 50.95,15.22 50.95,17.12 51.12,17.28 PD302.1
  vias: v2(21.86,27) v2(21.86,26.41) v2(21.86,25.83) v2(21.86,25.24) v2(22.44,27) v2(22.44,26.41) v2(22.44,25.83) v2(23.03,27) v2(23.03,26.41) v2(23.61,27) v2(23.61,26.41) v2(24.19,27) v2(24.19,26.41) v2(52.5,1.82) v2(52.57,3.5) v2(52.57,2.41) v2(52.83,2.94) v2(53.09,1.82) v2(53.15,3.5) v2(53.15,2.41) v2(53.42,2.94) v2(53.73,3.5) v2(53.73,2.41) v2(53.67,1.82) v2(54,2.94) v2(54.32,2.41) v2(54.26,1.82) v2(54.59,2.94)
+SP_PLLVDD: length 6.7
  TOP w0.254: RV576.1 199.02,61.98 v1(199.53,61.98) 200.98,61.98 201.75,62.75 CV852.1 202.51,64.27 v2(202.56,64.27)
  BOTTOM w0.254: v2(202.56,64.27) UV18.AE8
+V_DDR_REF: length 3
  BOTTOM w0.127: v1(289.43,32.88) 288.52,32.88 PC609.1
  BOTTOM w0.203: PU600.4 288.67,31.63 288.74,31.7 288.74,32.2 PC609.1
+V_DDR_REFA: length 31.9
  TOP w0.508: v2(126.99,16.7) 126.99,17.53 v3(126.59,17.93) 126.2,18.32 RH206.2 RH209.1 RH484.2 ; CD18.1 150.19,16.86 v2(150.2,16.86)
  IN4 w0.508: v2(126.99,16.7) 128.12,15.57 149.42,15.57 150.2,16.35 v2(150.2,16.86)
  BOTTOM w0.305: JDIMM1.164 150.12,16.93 v2(150.2,16.86)
+V_DDR_REFA_R: length 64.6
  TOP w0.127: v2(139.73,68.2) 139.5,67.97 v3(139.14,67.97)
  TOP w0.508: RH484.1 CH101.1 122,20.23 v2(122.19,20.42)
  IN3 w0.381: v2(139.73,68.2) 139.65,68.27 138.06,68.27 137.69,67.9 137.69,65.56 138.21,65.04 138.21,64.59
  IN3 w0.508: 138.21,64.59 138.32,64.48 138.32,60.86 138.66,60.51 140.02,60.51 140.81,59.72 140.81,58.74 137.2,55.13 136.34,55.13 135.95,55.51 134.19,55.51 122.71,44.03 122.71,24.54 122.19,24.02 v2(122.19,20.42)
+V_DDR_REFB: length 15.2
  TOP w0.508: v2(226.5,16.87) 226.5,16.87 CD29.1 ; RH485.2 RH207.2 RH210.1 234.3,17.61 v3(234.56,17.36) 234.93,16.99 v2(234.93,16.86)
  IN4 w0.508: v2(226.5,16.87) 226.5,17.08 226.89,17.48 234.5,17.48 234.93,17.05 v2(234.93,16.86)
  BOTTOM w0.305: v2(226.5,16.87) 226.42,16.95 JDIMM2.164
+V_DDR_REFB_R: length 129.3
  TOP w0.508: RH485.1 CH100.1 231.31,20.14 v2(230.57,20.87)
  IN3 w0.381: v2(138.43,67.4) 138.43,67.19 139.6,66.02 139.6,65.39
  IN3 w0.508: 139.6,65.39 139.6,64.17 140.45,63.32 142.31,63.32 143.11,62.52 143.11,61.94 143.71,61.34 143.71,58.51 143.11,57.91 143.11,57.87 141.53,56.29 141.53,51.05 163.12,29.46 180.48,29.46 183.71,26.23 204.22,26.23 205.65,24.8 205.65,19.6 206.22,19.04 227.59,19.04 228.33,19.79 229.08,19.79 230.17,20.87 v2(230.57,20.87)
+VCHGR:
  vias: v2(30.7,20.84) v2(30.7,20.24) v2(30.7,19.63) v3(30.28,21.7)
+VDISPLAY_VCC: length 21.1
  IN4 w0.508: v2(24.7,94.75) 24.09,94.14 23.25,94.14 21.77,92.66 20.77,92.66 v2(20.7,92.59) 20.5,92.39 20.5,91.73 19.42,90.65 15.22,90.65 v2(14.07,91.79)
  IN6 w0.508: JHDMI1.18 10.57,88.51 11.68,89.61 12.53,89.61 14.07,91.16 v2(14.07,91.79)
  BOTTOM w0.508: v2(24.7,94.75) 24.97,94.48 RV124.2 ; RV125.2 20.13,93.1 20.64,92.59 v2(20.7,92.59)
  vias: v3(16.08,90.64)
+VGA_B+: length 14.7
  IN4 w0.508: v2(167.07,105.1) 167.07,109.8 168.21,110.94 168.21,112.53 169.93,114.25 169.93,115.54 171.01,116.62 171.01,117.23 v2(171.13,117.36)
  BOTTOM w0.508: PR1014.1 171.45,117.67 v2(171.13,117.36)
  vias: v1(164.28,106.66) v2(161.99,105.61) v2(162.43,106.05) v2(162.56,105.42) v2(166.88,97.99) v2(166.88,97.35) v2(166.88,96.72) v2(167.2,104.47) v2(167.51,97.99) v2(167.51,97.35) v2(167.51,96.72) v2(167.96,104.47)
+VID_PLLVDD: length 10.8
  TOP w0.14: v2(196.62,60.93) 196.62,60.21 v1(196.61,60.19)
  TOP w0.508: CV854.1 201.88,62.06 202.41,62.59 v2(202.53,62.59) ; RV582.1 196.41,61.15 v2(196.62,60.93)
  IN1 w0.508: v2(196.62,60.93) 196.62,61.12 197.04,61.54 198.38,61.54 198.64,61.28 200.91,61.28 202.22,62.59 v2(202.53,62.59)
  BOTTOM w0.305: v2(202.53,62.59) UV18.AD7
+VLDOIN_1.2V: length 1.8
  BOTTOM w0.127: 284.51,30.79 284.51,32.06 v1(284.1,32.47)
+VR_CAP: length 8.4
  TOP w0.127: v2(302.83,8.06) 302.73,8.06 v3(302.22,8.57)
  TOP w0.305: UE3.B12 300.52,11.43 v2(300.57,11.48)
  TOP w0.508: v2(302.83,8.06) 302.64,7.87 CE40.1
  IN5 w0.508: v2(300.57,11.48) 300.57,9.94 300.47,9.84 300.47,8.34 300.83,7.98 300.88,7.98 301.3,7.57 302.34,7.57 v2(302.83,8.06)
+XS_PLLVDD: length 0.7
  BOTTOM w0.305: UV18.AD8 203.33,64.19 v2(203.33,64.31)
  vias: v1(204.57,62.67)
A_DE0: length 1.9
  BOTTOM w0.14: RI19.1 322.68,31.57 322.11,32.14 UI3.16
A_DE1: length 4
  BOTTOM w0.14: v1(324.64,28.81) 324.16,29.3 323.83,29.3 RI20.1 322.57,30.55 322.57,30.72 322.14,31.14 UI3.18
A_EQ0: length 2
  BOTTOM w0.14: RI15.1 323.06,30.68 322.1,31.64 UI3.17
A_EQ1: length 1.7
  BOTTOM w0.14: UI3.15 323.14,32.64 RI16.1
AC_DET: length 3
  TOP w0.14: PR240.1 17.9,21.12 18.54,21.12 v1(18.94,20.72)
  TOP w0.254: PR240.1 17.35,22.14 PR243.2
AC_DIS: length 345.8
  TOP w0.14: v2(284.53,11.31) 284.53,13.74 v1(284.67,13.87) 285.23,14.44 285.23,15.24 286.2,16.2 286.2,19.34 286.73,19.87 288.53,19.87 288.84,19.57 288.84,19.05 289.31,18.58 291.33,18.58 291.52,18.77 292.55,18.77 292.69,18.63 UE3.A50
  TOP w0.254: PQ211.2 23.85,30.21 v2(23.79,30.15)
  IN1 w0.254: v2(23.79,30.15) 23.79,29.98 22.71,28.9 16.38,28.9 15.46,27.97 15.46,25.39 14.96,24.89 14.96,21.96 15.21,21.71 15.21,19.92 14.54,19.25 v2(14.54,18.88)
  IN2 w0.254: v2(57.24,13.98) 57.24,14.7 57.59,15.05 57.59,20.02 56.64,20.96 56.12,20.96 53.77,23.31 50.8,23.31 50.01,24.1 47.61,24.1 46.98,24.74 44.89,24.74 43.38,26.24 40.01,26.24 38.87,27.38 37.02,27.38 36.13,28.27 36.13,28.78 35.83,29.08 34,29.08 33.02,28.1 33.02,26.68 32.04,25.7 31.61,25.7 30.53,24.62 27.81,24.62 27,23.81 26.2,23.81 25,22.61 23.11,22.61 22.56,22.06 19.51,22.06 17.53,20.07 15.37,20.07 14.54,19.25 v2(14.54,18.88)
  IN5 w0.089: 101.98,14.87 99.19,14.87 98.6,15.45 96.03,15.45 95.91,15.34 91.25,15.34 89.91,13.99 85.58,13.99 85.47,14.1 84.16,14.1 83.8,14.46 80.35,14.46 80.27,14.38 78.66,14.38 78,13.72 75.06,13.72
  IN5 w0.099: v2(284.53,11.31) 283.89,11.95 274.6,11.95 274.17,11.53 271.2,11.53 270.7,12.02 266.27,12.02 265.24,13.05 252.17,13.05 248.52,16.69 248.52,16.88 247.29,18.11 221.5,18.11 219.63,19.98 219.63,24.67 218.35,25.95 186.94,25.95 186.68,26.21 182.27,26.21 179.06,23 179.06,19.05 174.94,14.93 102.05,14.93 101.98,14.87 ; 75.06,13.72 68.61,13.72 68.4,13.94 57.28,13.94 v2(57.24,13.98)
  BOTTOM w0.127: 56.77,12.88 PQ304.2 56.77,13.51 v2(57.24,13.98)
  BOTTOM w0.14: 56.77,12.88 56.77,12.46 57.07,12.15 57.62,12.15 58.04,11.73 58.04,11.24 58.65,10.63 PR327.1
AC_PRESENT: length 277.3
  TOP w0.14: v2(313.93,4.85) 314.19,5.1 v3(314.19,5.41) ; UE3.A54 293.05,16.63 292.8,16.87 v2(292.8,16.89)
  IN2 w0.089: 101.98,3.61 100.67,3.61 98.46,1.41 ; v2(92.37,1.93) 92.37,1.93 92.6,1.93 93.12,1.41
  IN2 w0.099: 101.98,3.61 105.32,3.61 106.89,2.04 107.48,2.04 v2(108.03,1.5) 108.21,1.32 116.27,1.32 121.26,6.31 126.38,6.31 126.63,6.55 138.69,6.55 138.84,6.7 140.68,6.7 141.21,7.24 145.01,7.24 148.57,3.68 150.08,3.68 151.39,2.37 205.39,2.37 206.3,1.46 212.51,1.46 214.77,3.71 225.71,3.71 226.38,3.04 237.76,3.04 238.84,1.96 238.84,1.96 239.32,1.49 239.32,1.49 239.49,1.32 244.27,1.32 247.28,4.32 250.69,4.32 251.69,3.32 262.07,3.32 263.21,4.46 267.46,4.46 269.3,2.62 309.22,2.62 310.59,4 312.6,4 312.8,4.2 313.28,4.2 v2(313.93,4.85) ; 93.12,1.41 93.21,1.32 98.37,1.32 98.46,1.41
  IN3 w0.091: v2(313.93,4.85) 313.93,4.91 313.4,5.44 313.4,19 312.74,19.67 v2(312.3,19.67)
  IN6 w0.099: v2(312.3,19.67) 311.79,19.16 304.46,19.16 303.54,18.24 301.82,18.24 301.34,17.76 296.83,17.76 296.66,17.59 294.12,17.59 293.43,16.89 v2(292.8,16.89)
  BOTTOM w0.089: v2(92.37,1.93) 92.37,1.93 92,2.3 92,2.71 92.06,2.77 92.06,3.8 92.27,4.01 92.27,4.31 92.27,4.88 92.35,4.96 92.35,5.15 92.56,5.36 UH2.BB15
  BOTTOM w0.127: RH533.1 108.19,1.66 v2(108.03,1.5)
ACAV_IN: length 272
  TOP w0.14: v2(285.31,16.85) 285.31,16.61 284.08,15.38 v1(284.08,9.28) 284.08,8.91 286.2,6.79 286.2,6.42 286.79,5.83 288.1,5.83 289.09,6.82 290.11,6.82 290.61,7.32 291.36,7.32 291.66,7.61 291.66,8.09 292.95,9.38 292.95,11.3 293.28,11.63 UE3.A64
  IN1 w0.099: v2(285.31,16.85) 284.84,16.85 282.55,14.56 272.14,14.56 269.85,12.26 268.97,12.26 266.39,9.68 266.1,9.68 264.83,8.42 256.2,8.42 255.43,7.65 253.56,7.65 252.77,8.43 233.49,8.43 233.39,8.33 229.42,8.33 229.19,8.56 225.83,8.56 225.34,9.05 217.79,9.05 216.82,8.07 213.99,8.07 211.32,10.74 202.97,10.74 201.6,9.37 200.31,9.37 199.49,8.56 188.06,8.56 187.08,9.53 184.58,9.53 183.95,8.9 179.43,8.9 177.56,10.77 167.14,10.77 166.1,9.73 159.21,9.73 158.18,8.71 156.3,8.71 155.47,9.53 154.31,9.53 153.83,10.01 153.83,10.95 153.47,11.31 149.16,11.31 148.6,11.87 115.87,11.87 114.76,12.98 110.45,12.98 109.71,13.71 108.42,13.71 107.68,12.98 104.21,12.98 103.53,12.3 101.56,12.3 100.96,11.7 98.66,11.7 98.43,11.94 96.02,11.94 94.95,13.01 92.54,13.01 91.23,11.7 79.74,11.7 78.96,10.92 76.07,10.92 75.9,11.09 72.2,11.09 71.99,10.87 68.85,10.87 67.88,11.84 60.76,11.84 59.07,10.14 56.92,10.14 55.46,11.6 54.66,11.6 53.85,10.79 v2(53.84,10.79)
  BOTTOM w0.254: PR312.1 54.04,11.01 53.82,10.79 v2(53.84,10.79)
ACAV_IN_NB: length 13.5
  TOP w0.14: v2(302.22,11.96) 302.64,12.38 UE3.B20 ; RE142.1 308.12,9.04 DE11.2 308,8.93 v2(308,7.55)
  IN3 w0.091: v2(308,7.55) 307.84,7.72 307.84,9.05 306.81,10.08 305.44,10.08 304.73,10.79 304.73,11.87 304.19,12.42 302.69,12.42 302.24,11.96 v2(302.22,11.96)
ALL_GPWRGD: length 15.5
  TOP w0.14: RV1132.2 199.09,43.79 199.09,45.04 198.5,45.63 198.26,45.63 198.14,45.75 UV20.4 198.14,46.54 v2(198.5,46.91) ; RV590.2 196.79,52.84 v2(196.98,53.03) 196.98,53.35 v1(197.41,53.78)
  BOTTOM w0.14: v2(196.98,53.03) 198.35,51.66 199.02,51.66 200.22,50.47 200.22,48.27 198.86,46.91 v2(198.5,46.91)
ALW_PWRGD_3V_5V: length 396.7
  TOP w0.14: v2(319.52,26.18) 319.52,26.76 v3(319.42,26.86)
  TOP w0.254: v2(33.08,32.77) 33.08,32.48 32.81,32.2 32.81,31.53 32.67,31.39 PR277.1 ; PQ225.2 25.14,26.73 24.87,27 v2(24.83,27) ; v2(345.44,25.03) 345.12,24.71 PR407.1
  IN3 w0.091: v2(345.44,25.03) 346.52,26.11 346.52,30.69 344.88,32.33 340.37,32.33 338.44,30.4 323.1,30.4 319.52,26.82 v2(319.52,26.18)
  IN5 w0.254: v2(33.08,32.77) 33.08,32.9 32.32,33.66 28.2,33.66 26.42,31.88 26.42,30.74 24.83,29.16 v2(24.83,27) 24.88,27 29.59,22.28 v2(29.59,22.17)
  IN6 w0.089: 101.98,9.09 101.81,8.91 99.05,8.91 98.65,8.52 96.53,8.52 96.39,8.38 94.93,8.38 94.4,7.84 94.16,7.84 93.24,6.92 92.97,6.92 92.71,7.18 92.71,7.48 92.62,7.57 92.62,7.78 92.43,7.97 91.5,7.97 90.97,7.44 90.36,7.44 90.29,7.36 89.42,7.36 89.14,7.64 88.89,7.64 87.75,6.49 87.75,5.88 87.52,5.65 86.91,5.65 86.7,5.44 86.11,5.44 85.74,5.81 84.56,5.81 84.09,5.34 83.8,5.34 83.47,5.67 83.47,7.59 83.28,7.78 82.08,7.78 82.05,7.81 80.45,7.81 79.8,8.46 79.77,8.46 79.47,8.76 79.28,8.76 78.98,8.46 78.49,8.46 78.47,8.46 78.39,8.54 77.82,8.54 77.65,8.38 76.79,8.38 76.39,7.98 75.06,7.98
  IN6 w0.099: 101.98,9.09 102.49,9.59 105.93,9.59 106.23,9.29 107.12,9.29 107.4,9.57 114.83,9.57 114.98,9.42 125.14,9.42 126.36,10.64 127.91,10.64 128.41,10.14 128.41,9.65 128.64,9.42 133.81,9.42 134.44,10.05 144.9,10.05 145.3,9.64 146.39,9.64 148.51,7.52 151.71,7.52 152.18,7.99 154.51,7.99 155.2,7.31 159.06,7.31 159.45,7.69 162.53,7.69 162.7,7.86 165.55,7.86 165.55,7.86 172.95,7.86 173.84,8.75 178.57,8.75 178.75,8.93 184.06,8.93 184.59,9.46 187.49,9.46 187.96,8.99 194.68,8.99 195.64,9.95 201.56,9.95 202.63,11.02 210.75,11.02 213.99,7.78 226.8,7.78 228.35,6.23 237.83,6.23 239.28,7.68 252.96,7.68 253.37,7.27 256.16,7.27 256.9,8 262.55,8 262.91,7.64 274,7.64 275.18,6.46 282.61,6.46 283.83,7.68 291.99,7.68 293.33,9.02 293.99,9.02 294.34,8.68 294.64,8.68 294.93,8.39 294.93,8.23 295.62,7.54 305.87,7.54 306.27,7.95 306.27,8.54 306.81,9.08 312.18,9.08 312.89,8.37 317.17,8.37 319.28,10.47 319.28,23.85 320.15,24.72 320.15,25.54 v2(319.52,26.18) ; v2(29.59,22.17) 30.14,22.72 41.08,22.72 42.17,21.63 46.41,21.63 47.19,20.86 50.52,20.86 51.27,20.11 51.75,20.11 53.63,18.24 53.63,15.74 54.5,14.87 54.5,13.42 55,12.92 63.77,12.92 64.48,12.21 68.3,12.21 70.09,10.42 71.4,10.42 72.59,9.23 72.59,8.63 73.24,7.98 75.06,7.98
ALWON: length 72.3
  TOP w0.14: v2(316.37,25.74) 315.95,25.32 v3(315.95,24.88) ; UE3.A60 292.84,13.63 v2(292.62,13.84)
  TOP w0.254: PR326.1 v2(346.97,26.93)
  IN3 w0.091: v2(316.37,25.74) 316.54,25.57 318,25.57 323.02,30.6 338.36,30.6 340.33,32.56 344.92,32.56 346.97,30.51 v2(346.97,26.93)
  IN6 w0.099: v2(292.62,13.84) 292.84,14.06 300.47,14.06 300.88,14.46 304.13,14.46 304.59,14.92 306.56,14.92 307.76,16.13 311.72,16.13 312.29,16.7 312.29,17.23 316.16,21.1 316.16,25.53 v2(316.37,25.74)
AUD_AZA_CPU_SCLK: length 158.3
  IN5 w0.099: v2(106.55,19.9) 107.05,19.9 107.67,19.28 133.84,19.28 134.33,18.79 150.7,18.79 151.02,19.11 174.69,19.11 175.16,19.57 175.16,20.13 176.01,20.99 176.01,22.98 175.39,23.61 175.39,25.33 v2(176.16,26.11)
  IN6 w0.089: v2(174.48,80.21) 174.94,79.75 177.12,79.75 177.95,78.92 177.95,68.44 178.35,68.04 178.35,66.84 180.15,65.05 181.1,65.05
  IN6 w0.099: 181.1,65.05 182.6,65.05 189.63,58.01 189.63,44.41 177.67,32.45 177.67,27.49 176.29,26.11 v2(176.16,26.11)
  BOTTOM w0.076: v2(174.48,80.21) 174.48,79.32 UH1.G27
  BOTTOM w0.127: v2(106.55,19.9) 106.36,19.71 106.36,19.24 107.05,18.55 107.05,17.19 107.7,16.55 107.7,16.1 109.01,14.79 109.01,13.4 109.49,12.92 109.49,11.48 RH147.1
AUD_AZA_CPU_SCLK_R: length 9.2
  BOTTOM w0.089: 101.98,10.12 99.57,10.12 99.57,10.12 99.21,10.12 98.85,10.48 UH2.AM2
  BOTTOM w0.127: 105.67,9.97 105.67,9.97 102.82,9.97 102.73,10.05 102.73,10.06 102.67,10.12 101.98,10.12
  BOTTOM w0.14: RH147.2 107.27,10.55 v1(106.5,10.55) 106.25,10.55 105.67,9.97
AUD_AZA_CPU_SDI_R: length 167.3
  IN5 w0.099: v2(177.55,24.96) 177.43,25.08 175.88,25.08 175.68,24.87 175.68,23.65 176.23,23.1 176.23,20.82 175.36,19.95 175.36,19.49 174.71,18.84 151.03,18.84 150.78,18.59 134.25,18.59 133.76,19.08 107.12,19.08 v2(106.82,19.38)
  IN6 w0.099: v2(181.49,78.8) 181.49,70.18 183.41,68.26 183.41,66.48 184.82,65.07 189.06,65.07 190.12,64.01 190.12,61.41 193.4,58.13 193.4,46 179.41,32.01 179.41,26.83 v2(177.55,24.96)
  BOTTOM w0.089: UH2.AN2 99.08,10 99.19,9.89 101.98,9.89
  BOTTOM w0.127: 101.98,9.89 101.99,9.89 102.15,9.74 106.38,9.74 106.63,9.48 108.54,9.48 109.72,10.66 109.72,13.01 109.23,13.49 109.23,15.01 107.93,16.32 107.93,16.64 107.28,17.29 107.28,18.92 v2(106.82,19.38)
  BOTTOM w0.14: RH145.2 181.49,79.37 v2(181.49,78.8)
AUD_AZA_CPU_SDO: length 156.2
  IN5 w0.099: v2(106.13,20.32) 106.12,20.3 106.12,19.36 106.85,18.62 132.91,18.62 133.15,18.39 174.54,18.39 175.56,19.41 175.56,19.87 176.43,20.74 176.43,23.23 175.96,23.69 175.96,24.53 v2(176.09,24.65)
  IN6 w0.089: v2(174.51,77.05) 174.89,77.43 177.47,77.43 177.71,77.19 177.71,68.3 178.04,67.97 178.04,66.77 180.05,64.77 181.1,64.77
  IN6 w0.099: 181.1,64.77 182.59,64.77 189.43,57.93 189.43,44.49 177.47,32.53 177.47,27.57 176.41,26.51 175.99,26.51 175.72,26.24 175.72,25.02 v2(176.09,24.65)
  BOTTOM w0.076: UH1.G25 174.18,77.37 v2(174.51,77.05)
  BOTTOM w0.127: RH146.1 v1(108.18,12.63) 108.18,12.81 108.78,13.41 108.78,14.59 107.47,15.9 107.47,16.45 106.82,17.1 106.82,18.46 106.14,19.15 106.14,19.67 106.13,19.67 v2(106.13,20.32)
AUD_AZA_CPU_SDO_R: length 8.5
  BOTTOM w0.089: 101.98,10.35 99.6,10.35 99.58,10.38 UH2.AM1
  BOTTOM w0.127: RH146.2 106.77,11.52 105.56,10.31 v1(104.23,10.31) 103.2,10.31 103.16,10.35 101.98,10.35
AUD_PWR_EN: length 163.9
  TOP w0.14: v2(65.24,13.05) 65.24,12.29 v3(65.6,11.93) ; UA4.3 9.09,5.16 8.96,5.04 8.96,4.63 9.27,4.33 9.61,4.33 9.89,4.6 ; v2(10.22,4.14) 10.22,4.26 9.89,4.6 ; 9.89,4.6 UA4.5 ; v2(4.41,13.3) 4,13.71 JAUDIO.2
  IN2 w0.099: v2(58.45,5.17) 57.96,5.66 57.96,6.68 58.35,7.07 59.29,7.07 59.35,7.13 61.85,7.13 63.44,8.72 63.44,9.91 65.24,11.72 v2(65.24,13.05) 61.83,13.05 59.75,15.12 59.75,21.57 59.19,22.13 58.24,22.13 54.96,25.41 48.07,25.41 47.42,26.06 45.31,26.06 42.62,28.75 39.93,28.75 38.77,29.91 33.57,29.91 31.29,27.63 29.09,27.63 28.77,27.31 28.77,26.26 26.8,24.29 26,24.29 24.81,23.09 22.91,23.09 22.36,22.54 19.2,22.54 17.26,20.6 13.98,20.6 11.94,18.55 11.94,17.28 11.3,16.65 8.77,16.65 8.01,15.88 8.01,13.88 6.46,12.33 4.67,12.33 4.41,12.58 v2(4.41,13.3)
  IN5 w0.089: 75.06,5.04 75.69,4.41 79.58,4.41 79.78,4.61 82.21,4.61 82.41,4.41 86.29,4.41 86.92,3.77 87.65,3.77 88.54,2.89 88.85,2.89 89.32,2.42 v2(89.52,2.42)
  IN5 w0.099: 75.06,5.04 74.67,5.43 69.8,5.43 69.55,5.67 65.58,5.67 64.78,6.47 59.27,6.47 57.45,8.29 57.45,8.54 56.43,9.56 56.09,9.56 55.44,8.9 55.44,8.26 55.75,7.95 56.64,7.95 56.81,7.77 56.81,5.45 57,5.27 58.34,5.27 v2(58.45,5.17)
  IN6 w0.099: v2(10.22,4.14) 10.14,4.22 10.14,5.05 7.62,7.57 7.62,9.15 4.27,12.51 4.27,13.15 v2(4.41,13.3)
  BOTTOM w0.089: UH2.BE21 89.89,3.97 89.89,3.61 89.85,3.58 89.85,3.09 89.79,3.03 89.79,2.68 v2(89.52,2.42)
  BOTTOM w0.14: v2(58.45,5.17) 58.55,5.07 58.55,4.71 58.84,4.42 59.44,4.42 59.69,4.16 59.69,3.23 60.39,2.54 RH568.1 RH569.1
AUX_EN_WOWL: length 113.7
  TOP w0.14: UE3.B38 301.52,19.44 v2(301.41,19.33) ; v1(338.39,105.93) v2(338.39,103.56) DN3.3
  IN1 w0.099: v2(301.41,19.33) 301.89,19.81 303.19,19.81 303.82,19.17 305.72,19.17 308.52,21.97 315.15,21.97 318.17,24.99 318.17,29.91 325.3,37.05 325.3,41.54 326.4,42.64 326.4,43.62 326.4,43.63 326.4,44.02 328.03,45.65 328.03,49.02 330.12,51.11 330.12,55.19 332.87,57.93 332.87,59.7 332.61,59.95 332.61,61.97 333.45,62.81 333.45,63.51 333.21,63.76 333.21,66.03 332.19,67.04 332.19,73.14 330.07,75.26 330.07,76.84 330.52,77.29 330.52,85.68 338.27,93.43 338.27,103.44 v2(338.39,103.56)
B+: length 212.8
  IN3 w1.016: 244.48,115.32 243.02,116.79 241.87,116.79 240.58,115.49 237.58,115.49 236.92,116.15 235.52,116.15 233.93,117.74 229.87,117.74 228.61,116.48 224.15,116.48 223.18,117.45 221.12,117.45 221.04,117.37 220.15,117.37 219.25,118.27 219.25,118.72 217.96,120.02 198.07,120.02 196.61,118.56 187.64,118.56 187.45,118.75
  IN6 w1.016: 278.39,25.47 277.69,24.77 271.88,24.77 269.15,27.51 261.98,27.51 261.87,27.62 261.1,27.62 259.02,25.54 255.46,25.54 254,24.08 254,22.36 253.75,22.11
  BOTTOM w1.016: 137.92,10.68 140.78,10.68 142.76,12.65 170.69,12.65 171.04,12.31 176.74,12.31 180.12,15.69 183.77,15.69 183.77,15.69 189.02,15.69 191.17,15.69 191.18,15.68 192.44,15.68 192.45,15.69 196.47,15.69 196.47,15.69 203.44,15.69 203.45,15.68 244.13,15.68 245.1,14.72 250.04,14.72 251.65,16.33 251.65,17.95 252.86,19.16 252.86,19.95
  vias: v2(8.83,15.76) v2(9.4,16.2) v2(9.4,15.57) v2(10.03,16.2) v2(10.03,15.57) v2(34.28,16.5) v2(34.29,15.91) v2(34.93,16.51) v2(34.93,15.87) v2(35.56,16.51) v2(35.56,15.87) v2(36.2,19.05) v2(36.2,18.41) v2(36.2,17.78) v2(36.2,17.14) v2(36.2,16.51) v2(36.2,15.87) v2(36.83,19.05) v2(36.83,18.41) v2(36.83,17.78) v2(36.83,17.14) v2(36.83,16.51) v2(36.83,15.87) v2(37.05,21.56) v2(37.47,19.05) v2(37.47,18.41) v2(37.47,17.78) v2(37.47,17.14) v2(37.47,16.51) v2(37.47,15.87) v2(37.68,21.56) v2(38.1,19.05) v2(38.1,18.41) v2(38.1,17.78) v2(38.1,17.14) v2(38.09,16.52) v2(38.09,15.89) v2(38.32,21.56) v2(38.95,21.56) v2(104.22,68.69) v2(104.22,68.06) v2(104.22,67.42) v2(104.22,66.79) v2(104.84,68.69) v2(104.84,68.06) v2(104.84,67.42) v2(104.84,66.79) v2(105.03,56.52) v2(105.37,67.76) v2(105.39,67.08) v2(105.73,56.52) v2(107.83,99.72) v2(108.47,99.72) v2(109.1,99.72) v2(109.08,43.66) v2(109.5,44.14) v2(109.74,99.72) v2(109.92,43.63) v2(109.98,44.53) v2(110.43,44.98) v2(110.43,44.08) v2(110.88,45.43) v2(110.88,44.53) v2(110.88,43.63) v2(111.32,45.88) v2(111.32,44.98) v2(111.32,44.08) v2(111.77,46.33) v2(111.77,45.43) v2(111.77,44.53) v2(112.22,46.78) v2(112.22,45.88) v2(112.22,44.98) v2(112.67,46.33) v2(112.78,47.19) v2(128.59,106.77) v2(129.17,106.77) v2(129.16,105.6) v2(129.37,106.2) v2(129.74,105.6) v2(129.75,106.77) v2(129.96,106.2) v2(130.34,106.77) v2(130.33,105.6) v2(130.54,106.2) v2(130.91,105.6) v2(134.19,107.77) v2(134.83,107.77) v2(162.18,110.04) v2(162.18,109.42) v2(162.18,108.78) v2(162.18,107.58) v2(162.76,110.04) v2(162.76,109.42) v2(162.76,107.58) v2(163.35,110.04) v2(163.35,109.42) v2(163.35,107.57) v2(184.61,117.8) v2(184.61,117.17) v2(184.61,116.56) v2(184.61,115.96) v2(184.6,115.32) v2(185.23,117.8) v2(185.23,117.17) v2(185.23,116.56) v2(185.23,115.96) v2(185.23,115.32) v2(185.23,114.74) v2(185.17,112.02) v2(245.43,115.13) v2(245.43,114.5) v2(252.82,21.87) v2(252.82,21.17) v2(279.08,26.17) v2(279.72,26.17) v2(316.04,16.01) v2(316.17,15.38) v2(316.55,16.33) v2(316.55,14.87) v2(316.68,15.76) v2(316.99,15.25) v2(317.06,16.71) v2(317.25,16.14) v2(317.18,14.68) v2(317.63,17.66) v2(317.63,17.03) v2(317.56,15.38) v2(318.26,18.36) v2(318.26,17.73) v2(318.26,17.09) v3(35.56,14.97)
