# Allegro board Dell XPS 9560 LA-E331P R10.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+1.35VSDGPU on TOP (solid shape): 205.43,80.64 205.46,80.63 205.8,80.48 206.16,80.59 206.35,80.39 206.34,80.36 206.42,79.99 206.8,79.91 206.83,79.92 206.98,79.76 207.94,79.76 207.94,79.21 208.76,79.21 208.76,79.28 208.84,79.28 208.91,79.2 208.91,79.04 208.76,79.04 208.76,79.06 207.94,79.06 207.94,78.3 207.02,78.3 206.96,78.24 206.58,78.24 206.58,79.08 206.54,79.08 206.22,79.4 206.21,79.41 205.8,79.71 205.46,79.33 205.46,79.08 205.81,78.72 205.81,78.24 204.84,78.24 204.78,78.25 204.71,78.24 204.1,78.24 203.92,78.41 203.92,79.49 204.02,79.59 204.3,79.59 204.66,79.96 204.66,80.43 204.71,80.52 204.8,80.53 205.11,80.49 205.39,80.63
+1.35VSDGPU on TOP (solid shape): outline of 111 points within 209.42,77.99 213.55,80.15
+1.35VSDGPU on BOTTOM (solid shape): 217.87,117.1 217.87,111.64 217.3,111.07 214.31,111.07 213.68,111.71 213.68,116.79 214.06,117.17 214.57,117.17 214.57,116.72 214.63,116.66 216.6,116.66 216.79,116.85 216.79,117.23 217.74,117.23
+1.35VSDGPU on BOTTOM (solid shape): outline of 519 points within 199.98,63.54 216.56,80.02
+1.35VSDGPU on IN1 (solid shape): outline of 5507 points within 200.79,63.7 219.33,82.27
+1.35VSDGPU on IN3 (solid shape): outline of 31251 points within 202,53.92 250.83,116.66
+1.35VSDGPU on VCC: 204.22,120.58 228.52,120.58 228.88,120.22 229.42,119.86 230.06,119.73 233.41,119.73 234.69,117.65 237,116.83 238.5,116.83 241.09,117.91 242.17,120.5 242.17,120.58 246.28,120.58 246.28,119.4 247.72,117.19 250.33,117.61 250.33,98.5 250.76,97.38 251.83,96.84 251.83,65.4 252.4,59.4 254.07,53.6 227.39,53.6 227.39,86.09 222.42,91.07 210.23,91.07 204.22,97.08
+1V_MPHY on TOP (solid shape): 111.03,16 111.91,16 112.52,15.4 112.52,12.78 111.82,12.08 110.34,12.08 108.92,13.5 108.92,15.97 108.96,16 110.12,16 110.13,16.01 111.02,16.01
+1V_MPHY on TOP (solid shape): outline of 2066 points within 75.9,16.57 89.2,32.77
+1V_MPHY on VCC: 104.25,13.22 101.2,16.26 86.21,16.26 86.09,16.39 85.83,16.39 85.35,16.88 85.35,17.68 89.13,21.47 104.42,21.47 107.21,18.68 113.05,18.68 113.79,17.94 113.79,14.47 112.54,13.22
+1V_MPHY_MPHYPLL on TOP (solid shape): outline of 104 points within 75.85,25.13 81.48,31.44
+1V_MPHY_MPHYPLL on BOTTOM (solid shape): 77.91,28.29 77.91,27.32 78.93,26.3 78.93,25.98 78.93,25.98 78.8,25.72 78.97,25.49 78.97,25.25 78.81,25.08 78.66,25.08 78.57,25.17 78.57,25.3 78.36,25.5 78.36,25.9 77.65,26.61 76.74,26.61 76.47,26.34 76.47,25.75 77.1,25.12 77.81,25.12 77.96,24.97 78.19,24.97 78.36,24.81 78.36,24.63 78.22,24.5 77.95,24.5 77.76,24.65 77.52,24.58 76.35,24.58 75.58,25.36 75.58,27.83 76.08,28.34 76.11,28.34 76.49,28.72 77.47,28.72
+1V_PCH on TOP (solid shape): outline of 1036 points within 88.99,14.9 102.82,21.69
+1V_PCH on IN2 (solid shape): outline of 421 points within 87.69,9.6 92.97,19.2
+1V_PCH on IN4 (solid shape): outline of 1437 points within 89.22,12.07 104.77,23.73
+1V_PCH_CLK5 on BOTTOM (solid shape): 102.67,17.43 102.67,16.75 102.85,16.57 102.85,16.32 102.79,16.26 102.36,16.26 101.83,16.8 101.83,17.36 102.08,17.61 102.49,17.61
+1V_PCH_PRIM on TOP (solid shape): outline of 1082 points within 86.1,11.95 102.71,17.46
+1V_PCH_USBPLL on BOTTOM (solid shape): 97.5,12.03 97.5,10.76 97.27,10.52 97.27,10.08 97.11,9.93 96.88,9.93 96.76,10.05 96.76,10.64 96.89,10.77 96.89,11.27 97.16,11.53 97.16,12.01 97.26,12.11 97.42,12.11
+1VALW on TOP (solid shape): 106.51,16.17 107.84,16.17 108.12,15.89 108.12,14.29 108.21,14.21 108.21,13.22 108.08,13.09 107.57,13.09 106.83,13.83 106.62,13.83 106.51,13.94 106.51,14.69 106.44,14.77 105.37,14.77 105.3,14.69 105.3,14.37 103.63,12.71 102.46,12.71 102.28,12.89 102.28,13.36 102.29,13.36 102.82,13.36 102.84,13.38 102.84,13.82 102.83,13.83 102.28,13.83 102.27,13.84 102.27,14.61 102.46,14.8 102.81,14.8 103.7,14.8 103.7,15.95 103.13,16.52 103.13,16.55 102.84,16.84 102.49,16.84 102.41,16.92 102.41,17.67 102.42,17.68 102.95,17.68 102.96,17.69 102.96,18.14 102.95,18.15 102.42,18.15 102.41,18.16 102.41,18.7 102.47,18.75 103.92,18.75
+1VALW on TOP (solid shape): 182.23,86.04 182.25,86.02 182.3,85.98 182.35,85.96 182.4,85.94 182.46,85.93 182.51,85.92 182.57,85.93 182.63,85.94 182.68,85.97 182.73,86 182.77,86.03 182.81,86.08 182.84,86.13 182.86,86.18 182.88,86.24 183.55,86.24 184.13,85.67 184.13,83.07 183.52,82.46 179.43,82.46 179.38,82.51 179.38,84.12 179.45,84.2 180.63,84.2 180.77,84.33 180.77,85.02 181.72,85.02 181.72,84.97 181.73,84.91 181.74,84.86 181.77,84.81 181.8,84.77 181.83,84.73 181.87,84.7 181.92,84.67 181.97,84.65 182.02,84.64 182.08,84.64 182.13,84.64 182.18,84.65 182.23,84.67 182.28,84.7 182.32,84.73 182.35,84.77 182.38,84.81 182.41,84.86 182.42,84.91 182.43,84.97 182.43,85.02 182.42,85.07 182.41,85.12 182.38,85.17 182.35,85.22 182.32,85.25 182.28,85.29 182.23,85.31 182.18,85.33 182.13,85.35 182.08,85.35 182.02,85.35 181.97,85.33 181.92,85.31 181.87,85.29 181.83,85.25 181.8,85.22 181.77,85.17 181.74,85.12 181.73,85.07 181.72,85.02 180.77,85.02 180.77,85.7 181.14,86.07 181.14,86.07 181.31,86.24 182.02,86.24
+1VALW on BOTTOM (solid shape): 193.7,58.09 193.7,56.23 194.37,55.56 194.37,53.98 194.31,53.92 192.9,53.92 191.39,55.43 191.24,55.43 190.84,55.83 190.84,58.05 191.22,58.43 193.36,58.43
+1VALW on BOTTOM (solid shape): 184.54,84.87 184.54,82.34 184.51,82.3 182.11,82.3 181.63,82.79 181.01,82.79 180.91,82.88 180.91,83.4 180.98,83.46 181.6,83.46 181.67,83.39 182.6,83.39 182.7,83.5 182.7,83.7 182.71,83.71 182.74,83.84 182.71,83.96 182.7,83.97 182.7,84.35 182.71,84.36 182.74,84.49 182.71,84.61 182.7,84.62 182.7,84.71 182.53,84.88 182.53,85.76 182.68,85.91 183.5,85.91
+1VALW on BOTTOM (solid shape): 125.02,14.69 125.02,11.53 124.04,10.55 121.98,10.55 121.73,10.3 121.73,8.96 121.47,8.7 120.47,8.7 120.46,8.7 120.46,9.22 119.76,9.22 119.76,8.7 119.26,8.7 119.26,9.22 118.56,9.22 118.56,8.7 116.99,8.7 116.65,9.03 116.65,9.85 117.06,9.85 117.06,9.8 117.06,9.74 117.08,9.69 117.1,9.65 117.13,9.6 117.17,9.56 117.21,9.53 117.26,9.5 117.31,9.48 117.36,9.47 117.41,9.47 117.47,9.47 117.52,9.48 117.57,9.5 117.61,9.53 117.66,9.56 117.69,9.6 117.72,9.65 117.74,9.69 117.76,9.74 117.77,9.8 117.77,9.85 117.76,9.9 117.74,9.95 117.72,10 117.69,10.05 117.66,10.08 117.61,10.12 117.57,10.14 117.52,10.16 117.47,10.18 117.41,10.18 117.36,10.18 117.31,10.16 117.26,10.14 117.21,10.12 117.17,10.08 117.13,10.05 117.1,10 117.08,9.95 117.06,9.9 117.06,9.85 116.65,9.85 116.65,13.85 116.67,13.87 116.69,13.92 116.71,13.97 116.72,14.02 116.72,14.07 116.72,14.12 116.71,14.17 116.69,14.22 116.67,14.26 116.65,14.28 116.65,14.3 117.41,15.06 124.65,15.06
+1VALW on IN3 (solid shape): outline of 381 points within 102.62,10.57 119.34,17.25
+1VALW on IN4 (solid shape): 184.16,85.67 184.16,84.64 184.88,83.92 184.88,83.55 184.16,82.83 183.64,82.83 182.59,83.88 182.59,85.75 182.87,86.03 183.81,86.03
+1VALW on IN4 (solid shape): 193.41,58.44 193.41,56.33 193.2,56.12 191.99,56.12 191.79,56.32 191.79,58.39 191.97,58.57 193.27,58.57
+1VALW on IN4 (solid shape): outline of 287 points within 102.74,13.34 122.43,17.75
+1VS_GFX on TOP (solid shape): 199.9,104.02 199.9,101.1 199.65,100.85 198.38,100.85 198.31,100.91 198.31,101.74 198.76,102.18 198.76,104.02 198.88,104.15 199.77,104.15
+1VS_GFX on BOTTOM (solid shape): 223.93,117.65 223.93,117.04 223.41,117.04 223.41,116.34 223.93,116.34 223.93,115.84 223.41,115.84 223.41,115.14 223.93,115.14 223.93,113.96 223.78,113.8 221.3,113.8 220.92,114.18 220.92,117.48 221.28,117.85 223.74,117.85
+1VS_GFX on BOTTOM (solid shape): 199.9,103.64 200.85,103.64 201.42,103.07 201.42,102.69 201.68,102.43 201.68,101.42 201.61,101.35 200.98,101.35 200.85,101.48 200.85,101.93 200.15,102.62 199.77,102.62 199.52,102.88 199.3,102.88 199.01,103.16 199.01,103.83 199.2,104.02 199.52,104.02
+1VS_GFX on IN4 (solid shape): outline of 13557 points within 192.24,51.51 231.43,117.48
+1VSP on TOP (solid shape): 126.11,6.41 126.11,5.53 125.95,5.37 118.52,5.37 118.25,5.65 118.25,6.17 118.3,6.36 118.25,6.55 118.25,6.91 118.56,7.23 118.56,7.6 118.91,7.95 124.57,7.95
+1VSP on BOTTOM (solid shape): 119.13,8.57 119.88,8.57 119.88,9.1 120.33,9.1 120.33,8.57 120.34,8.57 120.34,8.52 124.02,8.52 125.99,6.55 125.99,2.49 125.67,2.17 123,2.17 122.77,2.4 122.77,4.77 122.12,5.41 118.43,5.41 118.3,5.54 118.3,7.9 117.96,8.24 117.96,8.49 117.99,8.52 118.68,8.52 118.68,9.1 119.13,9.1
+2.5V_MEM on TOP (solid shape): 251.73,29.85 251.73,29.27 251.09,28.63 251.09,28.09 250.55,27.54 250.55,25.76 250.42,25.64 249.85,25.64 249.53,25.95 249.53,27.36 249.42,27.47 249.42,30.39 249.68,30.65 250.93,30.65
+2.5V_MEM on TOP (solid shape): outline of 172 points within 173.51,16.73 180.98,30.96
+2.5V_MEM on BOTTOM (solid shape): 251.81,30.1 251.81,25.59 251.66,25.44 249.62,25.44 249.51,25.55 249.51,27.23 250.05,27.77 250.05,29.97 250.34,30.26 251.64,30.26
+2.5V_MEM on BOTTOM (solid shape): 175.98,30.4 175.98,29.32 175.57,28.9 175.57,27.98 175.57,27.97 175.57,25.65 175.38,25.46 173.3,25.46 173.21,25.55 173.21,30.06 173.85,30.71 175.67,30.71
+2.5V_MEM on IN5 (solid shape): 251.28,29.9 251.28,28.94 250.97,28.63 249.71,28.63 249.48,28.86 249.48,29.59 250.03,30.13 251.05,30.13
+2.5V_MEM on IN5 (solid shape): 176.12,31.21 176.12,30.76 176.11,30.74 176.11,30.11 175.9,29.89 174.32,29.89 174.19,30.02 174.19,30.34 175.36,31.5 175.83,31.5
+3.3VDX_SSD on TOP (solid shape): 247.21,9.53 247.21,8.64 246.57,8.01 244.58,8.01 244.29,8.3 242.84,8.3 242.79,8.35 242.79,9.96 243,10.17 243.02,10.17 246.57,10.17
+3.3VDX_SSD on BOTTOM (solid shape): outline of 563 points within 267.2,3.98 276.58,22.74
+3.3VDX_SSD on IN3 (solid shape): outline of 389 points within 244.15,7.55 270.77,13.7
+3V_PCH on TOP (solid shape): 60.85,6.14 60.85,5.62 60.75,5.52 60.59,5.52 60.49,5.41 60.29,5.41 60.29,5.37 60.19,5.37 60.19,5.36 59.76,5.36 59.5,5.1 59.5,4.72 59.76,4.46 59.99,4.46 60.08,4.41 60.08,4.31 60.04,4.22 60.03,4.13 60.03,4.1 59.87,3.94 58.97,3.94 58.86,3.84 58.79,3.81 58.72,3.76 57.79,3.76 57.79,4.4 57.81,4.41 58.24,4.41 58.86,5.03 58.86,5.09 58.9,5.21 58.9,5.34 58.9,5.34 58.9,6.2 58.95,6.26 60.73,6.26
+3V_PCH on TOP (solid shape): 80.84,8.68 80.89,8.6 80.97,8.54 81.02,8.49 81.03,8.43 81.22,8.04 81.63,8.17 81.71,8.21 81.79,8.18 81.96,8.01 81.96,7.52 81.93,7.5 81.86,7.47 81.81,7.43 81.42,7.43 81.32,7.53 81.21,7.53 81.21,7.54 81.1,7.55 81,7.54 80.99,7.53 80.6,7.53 80.59,7.53 80.3,7.25 80.24,7.22 80.17,7.24 79.66,7.16 79.85,6.68 79.88,6.67 79.88,6.21 79.82,6.14 79.3,6.14 79.24,6.19 79.24,7.08 78.95,7.37 78.95,7.9 78.98,7.93 79.57,7.93 79.81,8.17 80.02,8.17 80.28,8.43 80.46,8.43 80.46,8.6 80.57,8.71 80.83,8.71
+3V_PCH on BOTTOM (solid shape): 77.85,6.07 77.85,5.63 78.09,5.39 78.93,5.39 79.44,4.88 79.44,4.69 79.39,4.64 79.12,4.64 78.87,4.9 77.85,4.9 77.77,4.82 77.06,4.82 76.92,4.95 76.92,5.3 77.22,5.6 77.22,5.85 77.51,6.14 77.78,6.14
+3V_PCH on BOTTOM (solid shape): 98.54,4.7 98.54,4.46 98.71,4.28 98.71,3.85 98.81,3.76 98.81,3.44 98.68,3.31 97.83,3.31 97.69,3.44 97.69,3.83 97.83,3.97 97.83,4.17 97.94,4.29 98,4.33 98.05,4.39 98.12,4.47 98.12,4.69 98.22,4.79 98.45,4.79
+3V_PCH on BOTTOM (solid shape): 80.24,11.57 80.24,11.07 80.16,10.99 80.16,10.97 80.15,10.96 80.12,10.9 80.12,10.84 80.09,10.77 80.03,10.74 79.8,10.59 79.76,10.32 79.77,10.29 79.63,10.16 79.63,10.1 79.19,10.1 79.02,10.27 79.02,10.33 79.02,10.55 79.16,10.69 79.18,10.7 79.27,10.75 79.32,10.84 79.33,10.86 79.45,10.98 79.45,12.03 79.53,12.12 79.69,12.12
+3V_PCH on IN1 (solid shape): outline of 1798 points within 82.16,3.31 100.47,9.29
+3V_PCH on IN2 (solid shape): outline of 1609 points within 76.86,4.93 84.58,15.2
+3V_PCH on IN3 (solid shape): outline of 1573 points within 68.98,9.55 85.28,18.39
+3V_PCH on IN6 (solid shape): outline of 616 points within 58.76,1.98 79.35,9.28
+3V_PCH_AZIO on IN5 (solid shape): outline of 279 points within 91.65,6.53 94.92,9.29
+3V_PCH_DSW on BOTTOM (solid shape): 111.72,3.86 111.72,3.71 111.73,3.66 111.75,3.61 111.77,3.56 111.8,3.51 111.84,3.47 111.88,3.43 111.93,3.4 111.98,3.38 112.03,3.37 112.09,3.36 112.14,3.36 112.2,3.37 112.26,3.39 112.29,3.38 112.32,3.37 112.34,3.35 112.35,3.32 112.36,3.28 112.36,1.75 111.94,1.33 109.72,1.33 109.64,1.41 109.64,3.73 109.67,3.76 110.26,3.76 110.27,3.71 110.28,3.66 110.3,3.61 110.32,3.56 110.36,3.52 110.4,3.48 110.44,3.45 110.49,3.43 110.54,3.41 110.59,3.4 110.64,3.4 110.7,3.41 110.75,3.43 110.8,3.45 110.84,3.48 110.88,3.52 110.91,3.56 110.94,3.61 110.96,3.66 110.97,3.71 110.97,3.76 110.97,3.81 110.96,3.87 110.94,3.92 110.91,3.96 110.88,4 110.84,4.04 110.8,4.07 110.75,4.09 110.7,4.11 110.64,4.12 110.59,4.12 110.54,4.11 110.49,4.09 110.44,4.07 110.4,4.04 110.36,4 110.32,3.96 110.3,3.92 110.28,3.87 110.27,3.81 110.26,3.76 109.67,3.76 110.13,4.22 111.36,4.22
+3V_PCH_DSW on IN5 (solid shape): outline of 444 points within 87.19,1.92 111,6.08
+3V_PCH_SPI on TOP (solid shape): 78.39,4.66 78.39,3.78 78.51,3.65 78.78,3.65 79,3.44 79,2.68 78.8,2.49 78.66,2.49 78.49,2.66 78.49,2.93 78.3,3.11 78.3,3.38 77.97,3.71 77.71,3.71 77.67,3.74 77.67,4.67 77.74,4.73 78.31,4.73
+3V_PCH_SPI on BOTTOM (solid shape): 79.72,4.22 79.72,3.86 79.57,3.71 79.57,2.68 79.38,2.49 78.52,2.49 78.4,2.61 78.4,4.21 78.48,4.29 79.65,4.29
+3V_PS8723 on TOP (solid shape): 325.27,33.39 325.27,30.85 325.09,30.67 323.79,30.67 323.56,30.9 323.56,33.33 323.83,33.6 325.07,33.6
+3V_PS8723 on BOTTOM (solid shape): 315.32,32.9 315.32,30.62 315.26,30.57 314.71,30.57 314.08,31.2 314.08,31.86 314.17,31.94 314.5,31.94 314.67,32.11 314.67,32.89 314.73,32.95 315.28,32.95
+3V_PS8723 on BOTTOM (solid shape): 322.67,36.4 322.84,36.36 323,36.4 323.9,36.4 323.96,36.34 323.96,34.86 323.64,34.55 323.64,34.04 323.55,33.95 323.19,33.95 322.77,33.54 321.37,33.54 321.31,33.6 321.31,33.79 321.44,33.92 322.01,33.92 322.12,34.03 322.12,36.13 322.38,36.4
+3V_PS8723 on IN5 (solid shape): outline of 1163 points within 314.01,27.81 325.43,37.52
+3V_ROM on IN5 (solid shape): outline of 281 points within 64.24,1.27 73.89,3.66
+3V_TBT on TOP (solid shape): 33.4,48.42 33.4,47.94 33.28,47.81 32.97,47.81 32.96,47.82 32.85,47.82 32.83,47.84 32.83,47.97 32.84,48.07 32.83,48.16 32.83,48.26 32.64,48.45 32.36,48.45 32.23,48.57 32.23,48.78 32.36,48.9 32.92,48.9
+3V_TBT on BOTTOM (solid shape): 19.61,49.69 19.61,48.42 19.61,48.41 19.58,48.28 19.61,48.15 19.61,48.14 19.61,48.1 19.47,47.96 18.98,47.96 18.06,47.04 18.06,46.98 18.02,46.94 18.02,45.9 18.16,45.76 18.82,45.76 19.14,46.08 20.45,46.08 20.65,45.88 20.85,45.88 21.38,45.35 21.72,45.35 21.76,45.39 22.11,45.39 22.16,45.34 22.16,45.09 22.29,44.97 22.51,44.97 22.57,44.91 22.57,44.73 22.52,44.68 22.31,44.68 22.27,44.72 22.23,44.72 22.21,44.74 21.52,44.74 21.08,45.18 20.83,45.18 20.64,45.37 19.38,45.37 19.23,45.22 19.23,44.99 19.23,44.25 19.2,44.17 19.12,44.14 18.72,43.79 19.12,43.44 19.2,43.41 19.23,43.34 19.23,42.73 19.58,42.38 20.32,42.38 20.5,42.2 20.5,41.67 20.36,41.52 17.37,41.52 17.25,41.64 17.25,47.18 17.87,47.8 17.87,48.43 17.95,48.52 18.46,48.52 18.96,49.02 18.96,49.71 19.07,49.82 19.48,49.82
+3V_TBT on IN4 (solid shape): 33.61,48.4 33.61,47.77 33.92,47.46 33.95,47.39 33.92,47.32 33.82,46.98 34.06,46.72 34.12,46.67 34.14,46.6 34.32,46.2 34.76,46.29 34.84,46.33 34.91,46.29 35.18,45.98 35.18,45.92 35.06,45.8 35.01,45.77 34.97,45.73 33.79,45.73 33.66,45.86 33.66,46.02 33.4,46.29 33.4,46.76 33.37,46.78 33.37,46.79 33.29,46.92 33.17,46.99 33.16,47 32.83,47.33 32.83,47.97 32.84,48.07 32.83,48.16 32.83,48.4 32.62,48.4 32.61,48.4 32.49,48.42 32.36,48.4 32.35,48.4 32.31,48.4 32.18,48.52 32.18,48.9 32.28,48.99 33.02,48.99
+3V_TBT on IN5 (solid shape): 21.48,45.29 21.58,45.29 21.75,45.11 21.75,44.81 21.63,44.69 20.14,44.69 19.93,44.9 19.93,45.56 20.07,45.7 21.06,45.7
+3V_TBT on IN6 (solid shape): 22.43,45.69 22.43,45.25 21.93,44.75 21.31,44.75 20.82,45.24 20.82,45.49 20.94,45.61 21.15,45.61 21.41,45.36 21.67,45.36 22.06,45.74 22.37,45.74
+3V_TBT on IN6 (solid shape): 32.72,48.76 32.72,48.57 32.66,48.45 32.54,48.42 32.19,48.25 32.2,47.86 32.23,47.81 32.06,47.63 31.78,47.63 31.37,47.23 30.45,47.23 30.35,47.24 30.26,47.23 30.11,47.23 29.95,47.39 29.95,47.97 30.12,48.14 31.73,48.14 32.15,48.56 32.16,48.71 32.16,48.77 32.15,48.79 32.3,48.94 32.53,48.94
+3V_TBT_PWR on BOTTOM (solid shape): 18.86,34 18.86,33.36 18.66,33.17 17.12,33.17 16.94,32.99 16.94,32.19 16.8,32.06 16.04,32.06 15.92,32.19 15.92,32.59 15.22,33.28 15.22,33.98 15.42,34.17 18.69,34.17
+3V_TBT_SPI on BOTTOM (solid shape): 44.32,29.57 44.32,28.56 44.24,28.37 44.32,28.17 44.32,26.59 44.13,26.4 39.71,26.4 39.36,26.75 39.36,27.55 39.64,27.83 40.86,27.83 41.33,28.3 41.92,28.3 41.97,28.24 41.97,27.79 41.95,27.77 41.84,27.74 41.75,27.68 41.66,27.2 42.13,27.07 42.15,27.1 42.24,27.16 42.31,27.25 42.31,27.26 42.67,27.62 42.67,28.38 42.56,28.49 42.56,29.01 42.88,29.33 42.89,29.33 43.08,29.6 42.9,29.86 42.85,29.88 42.85,30.45 42.94,30.53 43.36,30.53
+3V_VC on BOTTOM (solid shape): outline of 102 points within 9.96,21.12 12.32,23.49
+3VA_TBT on TOP (solid shape): 30.36,48.96 30.62,48.87 30.87,48.98 31.92,48.98 32.1,48.8 32.09,48.77 32.08,48.66 32.1,48.55 32.11,48.52 32.14,48.48 32.14,48.13 32.13,48.07 32.14,47.9 32.04,47.81 30.37,47.81 29.85,48.33 29.85,48.65 30.06,48.86 30.16,48.9 30.25,48.98 30.35,48.98
+3VA_TBT on IN2 (solid shape): outline of 163 points within 25.59,63.32 27.6,67.32
+3VA_TBT on IN4 (solid shape): 24.84,48.75 24.84,48.37 25.05,48.17 25.09,48.12 29.38,48.12 30.08,48.81 30.46,48.81 30.62,48.65 30.62,47.86 30.11,47.35 24.59,47.35 24.28,47.66 24.28,48.6 24.51,48.83 24.77,48.83
+3VA_TBT on IN6 (solid shape): 24.87,48.73 24.87,48.4 24.74,48.27 22.24,48.27 22.11,48.4 22.11,48.81 22.22,48.93 24.66,48.93
+3VALW on TOP (solid shape): 12,5.86 12,4.82 11.7,4.51 10.42,4.51 10.18,4.75 10.18,5.84 10.26,5.92 11.94,5.92
+3VALW on TOP (solid shape): 276.7,5.66 276.7,4.14 276.69,4.13 276.69,3.91 276.54,3.76 275.46,3.76 275.35,3.87 275.35,5.53 275.59,5.77 276.58,5.77
+3VALW on TOP (solid shape): 243.75,3.79 243.75,2.37 243.85,2.26 243.85,2.17 243.65,1.98 242.32,1.98 242.19,2.1 242.19,2.32 242.28,2.41 242.28,3.8 242.35,3.87 243.67,3.87
+3VALW on TOP (solid shape): 339.19,101.32 339.19,100.24 338.85,99.89 337.69,99.89 337.57,100.02 337.57,101.42 337.69,101.55 338.96,101.55
+3VALW on TOP (solid shape): 325.14,29.89 325.14,27.54 324.32,26.72 324.32,24.33 323.8,24.33 323.8,23.63 324.32,23.63 324.32,23.13 323.8,23.13 323.8,22.43 324.32,22.43 324.32,21.37 324.04,21.09 320.87,21.09 320.03,21.93 320.03,28.96 321.06,29.99 325.04,29.99
+3VALW on TOP (solid shape): 317.01,36.67 317.01,35.38 316.77,35.14 316.56,35.14 316.26,35.43 316.26,35.44 316.23,35.47 314.78,35.47 314.61,35.3 314,35.3 313.88,35.42 313.88,35.88 314.26,36.26 315.08,36.26 315.42,36.6 316.14,36.6 316.27,36.73 316.95,36.73
+3VALW on TOP (solid shape): 45.58,31.12 45.58,30.39 45.27,30.08 44.4,30.08 44.4,30.08 43.83,30.08 43.44,29.69 42.81,29.69 42.57,29.45 42.57,28.58 41.56,27.58 41.56,27 41.36,26.8 40.29,26.8 40.19,26.9 40.19,28.06 41.02,28.88 41.05,28.9 41.11,28.94 41.15,28.98 41.19,29.03 41.21,29.07 41.26,29.12 41.26,29.71 40.89,30.08 40.89,30.29 42.76,30.29 42.77,30.24 42.78,30.19 42.8,30.14 42.82,30.09 42.86,30.05 42.9,30.02 42.94,29.99 42.99,29.96 43.04,29.95 43.09,29.94 43.15,29.94 43.2,29.95 43.25,29.96 43.3,29.99 43.34,30.02 43.38,30.05 43.41,30.09 43.44,30.14 43.46,30.19 43.47,30.24 43.48,30.29 43.47,30.35 43.46,30.4 43.44,30.45 43.41,30.5 43.38,30.54 43.34,30.57 43.3,30.6 43.25,30.63 43.2,30.64 43.15,30.65 43.09,30.65 43.04,30.64 42.99,30.63 42.94,30.6 42.9,30.57 42.86,30.54 42.82,30.5 42.8,30.45 42.78,30.4 42.77,30.35 42.76,30.29 40.89,30.29 40.89,30.47 41.38,30.96 43.99,30.96 44.34,31.3 45.4,31.3
+3VALW on TOP (solid shape): 58.74,6.75 58.74,5.66 58.73,5.58 58.69,5.5 58.59,5.49 58.28,5.48 58.1,5.23 58.06,5.17 57.99,5.15 57.72,5.06 57.6,4.81 57.56,4.74 57.49,4.71 56.52,4.71 56.44,4.78 56.44,5.44 56.54,5.54 57.31,5.54 57.83,5.68 57.61,6.17 57.54,6.24 57.56,6.33 57.56,7.16 57.64,7.25 58.24,7.25
+3VALW on BOTTOM (solid shape): 249.3,113.42 249.3,111.77 249.24,111.71 249.24,111.64 247.02,111.64 246.89,111.77 246.89,113.67 246.95,113.74 248.98,113.74
+3VALW on BOTTOM (solid shape): 136.02,5.85 136.02,4.96 135.89,4.83 134.43,4.83 134.22,5.04 133.18,5.04 133.17,5.06 133.17,5.27 133.2,5.31 134.58,5.31 135.19,5.91 135.95,5.91
+3VALW on BOTTOM (solid shape): 106.17,62.94 106.17,62.56 106.49,62.24 107.76,62.24 107.76,61.92 106.43,61.92 106.05,61.54 105.41,61.54 105.28,61.67 105.28,62.94 105.54,63.19 105.92,63.19
+3VALW on BOTTOM (solid shape): 19.55,33.56 19.55,33.14 19.67,33.01 20.61,33.01 20.62,33 20.62,32.52 20.61,32.52 20.61,32.27 20.6,32.25 19.57,32.25 19.38,32.06 18.29,32.06 18.21,32.15 18.21,32.82 18.33,32.94 18.66,32.94 19.03,33.31 19.03,33.59 19.11,33.67 19.43,33.67
+3VALW on BOTTOM (solid shape): 343.73,46.85 343.73,46.3 343.86,46.17 344.85,46.17 345.13,45.88 345.13,45.45 344.81,45.13 344.69,45.13 344.41,44.84 344.41,44.72 344.34,44.65 343.67,44.65 343.59,44.73 343.59,45.46 343.47,45.58 343.08,45.58 342.84,45.82 342.84,46.8 342.95,46.91 343.67,46.91
+3VALW on BOTTOM (solid shape): 242.83,113.8 243.59,113.8 243.71,113.93 244.79,113.93 245.05,113.67 245.05,113.04 244.86,112.85 243.08,112.85 242.96,112.87 242.85,112.85 242.76,112.85 242.38,113.23 242,113.23 241.87,113.36 241.87,113.67 241.75,113.8 241.11,113.8 241.05,113.86 241.05,114.12 242.51,114.12
+3VALW on IN1 (solid shape): outline of 108 points within 315.71,30.02 317.79,36.85
+3VALW on IN2 (solid shape): outline of 714 points within 40.85,12.4 69.86,30.55
+3VALW on IN4 (solid shape): 248.6,113.17 248.6,111.39 248.29,111.07 247.78,111.07 246.89,111.96 246.89,113.55 247.14,113.8 247.97,113.8
+3VALW on IN4 (solid shape): 253.3,45.05 253.3,43.44 253.14,43.28 251.78,43.28 251.64,43.41 251.64,45.09 251.76,45.21 253.14,45.21
+3VALW on IN4 (solid shape): 254.15,15.44 254.15,14.22 253.98,14.06 253.2,14.06 253.05,14.21 253.05,15.41 253.21,15.58 254.02,15.58
+3VALW on IN4 (solid shape): 252.92,50.48 252.92,48.48 252.84,48.41 252.08,48.41 251.82,48.66 251.82,49.82 250.9,50.74 250.9,50.83 251.52,51.46 251.94,51.46
+3VALW on IN4 (solid shape): outline of 6207 points within 4.01,1.27 59.05,39.16
+3VALW on TOP: 308.06,25.45 309.56,25.45 309.82,25.19 309.82,24.51 309.59,24.28 308.26,24.28 308.05,24.48 308.05,25.43
+3VALW on IN1: 309.54,25.41 309.72,25.23 309.72,25 309.97,24.75 310.4,24.75 310.5,24.65 310.5,23.77 310.38,23.64 309.04,23.64 309.04,23.66 308.85,23.85 308.85,25.04 309.22,25.41
+3VALW on VCC: outline of 112 points within 57.72,1.17 349,116.85 ; 1 cut-out
+3VALW_5085 on TOP (solid shape): 306.95,22.71 306.95,22.54 306.95,22.54 306.95,22.03 306.95,21.8 306.95,21.8 306.95,21.34 306.82,21.21 304.51,21.21 303.91,21.81 303.91,23.69 304.04,23.82 305.84,23.82
+3VALW_5085 on TOP (solid shape): 290.22,8.18 290.22,7.55 289.92,7.25 288.55,7.25 288.13,6.84 288.11,6.84 287.82,6.75 287.71,6.46 287.71,6.39 287.73,6.32 287.7,6.26 287.63,6.23 286.81,6.23 286.65,6.39 286.65,6.99 286.51,7.12 286.51,8.2 286.58,8.26 287.96,8.26 288.02,8.21 288.41,8.21 288.42,8.2 288.59,8.16 288.75,8.23 289.46,8.23 289.5,8.28 290.13,8.28
+3VALW_5085 on IN1 (solid shape): outline of 1753 points within 286.42,5.72 301.93,15.2
+3VALW_5085 on IN2 (solid shape): outline of 3914 points within 288.74,10.56 310.31,19.86
+3VALW_5085 on IN4 (solid shape): outline of 586 points within 289.05,14.74 295.23,25.24
+3VALW_5085 on IN4 (solid shape): outline of 942 points within 304.43,15.17 312.04,27.48
+3VALW_5085 on IN6 (solid shape): outline of 244 points within 298.84,22.14 310.93,27.62
+3VALW_23017 on TOP (solid shape): 277.73,9.58 277.88,9.55 278.03,9.58 278.04,9.58 278.77,9.58 278.82,9.54 278.82,9.43 278.86,9.39 278.86,7.98 278.73,7.85 277.25,7.85 277.07,8.03 277.07,9.4 277.25,9.58 277.72,9.58
+3VALW_23017 on IN3 (solid shape): outline of 564 points within 277.5,8.1 285.55,18.24
+3VALWP on TOP (solid shape): 326.59,27.19 326.77,27.14 326.96,27.19 332.49,27.19 332.62,27.06 332.62,23.38 332.36,23.12 326.39,23.12 325.02,21.76 324.54,21.76 324.45,21.84 324.45,22.53 324.45,22.53 324.45,22.55 323.94,22.55 323.94,23 324.45,23 324.45,23.03 324.45,23.03 324.45,23.73 324.45,23.73 324.45,23.75 323.94,23.75 323.94,24.2 324.45,24.2 324.45,24.23 324.45,24.23 324.45,25 324.45,25 324.45,26.26 325.38,27.19
+3VS on TOP (solid shape): 326.49,36.06 326.49,33.98 326.39,33.88 325.72,33.88 325.62,33.98 325.62,36.21 325.7,36.3 326.25,36.3
+3VS on TOP (solid shape): 67.31,7.25 67.31,6.93 67.01,6.63 67.01,5.11 66.87,4.96 66.3,4.96 66.1,5.15 66.1,6.68 66.93,7.5 67.06,7.5
+3VS on TOP (solid shape): 104.04,8.47 104.04,6.98 103.41,6.35 101.58,6.35 101.5,6.43 101.5,8.09 101.6,8.2 101.61,8.2 101.97,8.56 103.95,8.56
+3VS on TOP (solid shape): 313.25,39 313.25,37.92 312.87,37.54 311.53,37.54 311.41,37.41 311.41,36.46 311.28,36.33 309.31,36.33 309.18,36.46 309.18,36.9 309.43,37.16 311.34,38.24 311.66,38.24 312.48,39.06 313.18,39.06
+3VS on TOP (solid shape): outline of 144 points within 245.64,94.78 250.73,99.17
+3VS on TOP (solid shape): outline of 489 points within 168.26,8.39 174,28.25
+3VS on TOP (solid shape): outline of 510 points within 228,2.66 256.76,18.92
+3VS on TOP (solid shape): outline of 837 points within 67.79,5.48 76.06,20.74
+3VS on BOTTOM (solid shape): 16.57,44.96 16.57,44.08 16.62,44.08 16.89,43.81 16.89,42.05 16.61,41.77 16.05,41.77 15.82,42 15.82,44.9 15.92,45.01 16.53,45.01
+3VS on BOTTOM (solid shape): 219.67,12.02 219.67,9.53 219.22,9.08 217.97,9.08 217.66,8.77 217.63,8.76 216.92,8.76 216.57,9.1 216.57,11.98 216.85,12.26 219.43,12.26
+3VS on BOTTOM (solid shape): 326.24,36.19 326.24,35.09 326.06,34.91 325.28,34.91 325.27,34.92 325.16,34.93 325.05,34.92 325.04,34.91 324.81,34.91 324.78,34.95 324.78,36.35 324.85,36.42 326,36.42
+3VS on BOTTOM (solid shape): 346.97,44.71 346.97,44.14 350.01,41.09 350.01,39.32 348.81,38.11 348.81,37.47 348.58,37.25 348.11,37.25 348.02,37.34 348.02,38.78 348.74,39.51 348.74,40.78 346.2,43.32 346.2,44.84 346.27,44.9 346.77,44.9
+3VS on BOTTOM (solid shape): 302.7,34.02 302.7,33.99 302.72,33.94 302.74,33.89 302.77,33.85 302.81,33.81 302.85,33.78 302.89,33.75 302.94,33.73 303,33.72 303.02,33.71 303.28,33.46 303.28,30.74 302.69,30.16 300.94,30.16 300.15,30.94 300.15,31.43 301.32,31.43 301.32,31.38 301.33,31.32 301.34,31.27 301.37,31.22 301.4,31.18 301.43,31.14 301.48,31.11 301.52,31.08 301.57,31.06 301.62,31.05 301.68,31.05 301.73,31.05 301.78,31.06 301.83,31.08 301.88,31.11 301.92,31.14 301.96,31.18 301.99,31.22 302.01,31.27 302.02,31.32 302.03,31.38 302.03,31.43 302.02,31.48 302.01,31.53 301.99,31.58 301.96,31.63 301.92,31.66 301.88,31.7 301.83,31.72 301.78,31.74 301.73,31.76 301.68,31.76 301.62,31.76 301.57,31.74 301.52,31.72 301.48,31.7 301.43,31.66 301.4,31.63 301.37,31.58 301.34,31.53 301.33,31.48 301.32,31.43 300.15,31.43 300.15,31.44 300.04,31.55 300.04,32.25 300.08,32.29 300.08,33.56 300.3,33.78 300.8,33.78 300.8,33.79 301.01,33.79 301.25,34.02
+3VS on BOTTOM (solid shape): outline of 99 points within 71.14,1.3 73.51,7.39
+3VS on IN1 (solid shape): 241.5,41.19 241.5,40.08 241.33,39.91 240.49,39.91 240.32,40.08 240.32,41.5 240.58,41.75 240.93,41.75
+3VS on IN1 (solid shape): 177.36,114.94 177.36,113.88 176.72,113.24 175.4,113.24 175.11,113.53 175.11,114.6 175.34,114.83 175.96,114.83 176.3,115.16 177.13,115.16
+3VS on IN1 (solid shape): 249.36,96.38 249.36,94.72 249.18,94.53 247.72,94.53 247.6,94.65 247.6,95.48 247.74,95.62 248.34,95.62 248.53,95.81 248.53,96.39 248.78,96.63 249.11,96.63
+3VS on IN1 (solid shape): 245.46,110.76 246.07,110.76 246.23,110.59 246.23,109.52 245.98,109.26 245.43,109.26 244.94,108.78 244.94,107.9 244.7,107.66 244.01,107.66 243.79,107.88 243.79,109.3 244.37,109.87 244.37,110.65 244.73,111.02 245.2,111.02
+3VS on IN1 (solid shape): 253.66,25.1 253.66,23.21 253.28,22.83 252.05,22.83 251.81,23.07 250.08,23.07 249.73,23.42 249.73,24.22 250.98,24.22 250.98,24.17 250.99,24.12 251.01,24.07 251.04,24.02 251.07,23.98 251.11,23.94 251.15,23.91 251.2,23.89 251.25,23.87 251.31,23.87 251.36,23.87 251.41,23.87 251.46,23.89 251.51,23.91 251.55,23.94 251.59,23.98 251.63,24.02 251.65,24.07 251.67,24.12 251.68,24.17 251.69,24.22 251.68,24.28 251.67,24.33 251.65,24.38 251.63,24.42 251.59,24.46 251.55,24.5 251.51,24.53 251.46,24.55 251.41,24.57 251.36,24.58 251.31,24.58 251.25,24.57 251.2,24.55 251.15,24.53 251.11,24.5 251.07,24.46 251.04,24.42 251.01,24.38 250.99,24.33 250.98,24.28 250.98,24.22 249.73,24.22 249.73,25.36 250.1,25.73 253.04,25.73
+3VS on IN1 (solid shape): outline of 126 points within 102.28,5.74 111.35,8.53
+3VS on IN3 (solid shape): outline of 1245 points within 300.42,30.72 327.94,40.01
+3VS on IN3 (solid shape): outline of 3331 points within 75.72,10.13 102.25,21.73
+3VS on IN4 (solid shape): 249.83,96.48 249.83,94.83 248.57,93.57 248.01,93.57 247.25,94.33 247.25,94.66 248.46,95.87 248.46,96.04 248.46,96.05 248.46,96.46 248.7,96.7 249.61,96.7
+3VS on IN4 (solid shape): 304.37,33.31 304.37,31.48 303.63,30.74 301.62,30.74 301.48,30.83 301.52,31 301.58,31.06 301.62,31.05 301.93,31.66 301.33,31.34 301.33,31.3 301.05,31.02 299.42,31.02 299.29,30.89 299.24,30.89 299.09,30.74 298.75,30.74 298.54,30.95 298.54,32.34 299.33,33.13 299.39,33.13 300.01,33.75 300.57,33.75 300.74,33.92 303.76,33.92
+3VS on IN4 (solid shape): outline of 935 points within 244.27,15.35 253.39,26.22
+3VS on IN6 (solid shape): 246.23,110.6 246.23,109.68 246.11,109.57 245.23,109.57 245.04,109.76 245.04,110.59 245.22,110.77 246.05,110.77
+3VS on IN6 (solid shape): outline of 629 points within 62.79,1.3 72.84,5.04
+3VS on VCC: 172.83,8.58 170.6,10.8 115.08,10.8 114.07,9.79 106.34,9.79 105.53,8.98 105.53,8.55 105.18,8.2 102.85,8.2 102.74,8.31 102.74,9.64 100.06,12.33 70.21,12.33 68.45,14.08 68.45,15.27 68.94,15.76 100.99,15.76 104.04,12.71 112.76,12.71 114.3,14.25 114.3,17.43 114.83,16.9 123.85,16.9 126.26,14.49 243.06,14.49 243.84,15.27 243.84,18.32 244.45,18.93 246.28,18.93 247.14,18.06 247.14,12.31 245.64,10.8 177,10.8 174.77,8.58
+3VS_AUDIO on TOP (solid shape): 10.59,10.96 11.25,10.96 11.58,11.29 12.13,11.29 12.32,11.1 12.32,10.36 12.26,10.29 11.6,10.29 11.41,10.11 10.37,10.11 10.04,9.77 9.78,9.77 9.65,9.9 9.65,10 9.63,10.1 9.63,10.35 9.61,10.36 9.61,10.77 9.49,10.89 9.49,11.22 9.59,11.33 10.23,11.33
+3VS_AUDIO on TOP (solid shape): 13.51,20.96 13.53,20.96 13.58,20.96 13.62,20.96 13.64,20.96 15.82,20.96 16.04,20.74 16.04,18.33 15.6,17.89 14.28,17.89 13.35,18.83 13.35,18.88 14.19,18.88 14.19,18.83 14.2,18.78 14.22,18.73 14.25,18.68 14.28,18.64 14.32,18.6 14.36,18.57 14.41,18.55 14.46,18.54 14.52,18.53 14.57,18.53 14.62,18.54 14.67,18.55 14.72,18.57 14.77,18.6 14.8,18.64 14.84,18.68 14.86,18.73 14.88,18.78 14.9,18.83 14.9,18.88 14.9,18.94 14.88,18.99 14.86,19.04 14.84,19.08 14.8,19.13 14.77,19.16 14.72,19.19 14.67,19.22 14.62,19.23 14.57,19.24 14.52,19.24 14.46,19.23 14.41,19.22 14.36,19.19 14.32,19.16 14.28,19.13 14.25,19.08 14.22,19.04 14.2,18.99 14.19,18.94 14.19,18.88 13.35,18.88 13.35,20.84 13.47,20.96
+3VS_AUDIO on BOTTOM (solid shape): 6.2,12.25 6.2,10.42 6.09,10.31 4.34,10.31 4.31,10.35 4.31,10.79 4.41,10.9 5.24,10.9 5.53,11.19 5.53,12.22 5.69,12.38 6.07,12.38
+3VS_AUDIO on IN1 (solid shape): outline of 240 points within 4.57,8.96 10.43,12.42
+3VS_AUDIO on IN2 (solid shape): outline of 212 points within 8.14,9.37 16.45,19.27
+3VS_CAM on TOP (solid shape): 61.15,31.7 61.15,31.53 61.36,31.31 62.42,31.31 62.51,31.22 62.51,30.71 62.42,30.62 60.99,30.62 60.73,30.36 60.73,29.96 60.59,29.82 59.79,29.82 59.69,29.92 59.69,31.31 60.3,31.92 60.92,31.92
+3VS_CR on BOTTOM (solid shape): 334.21,37.07 334.21,36.54 334.01,36.34 332.28,36.34 332.22,36.37 332.15,36.4 332,36.55 332,37.36 332.1,37.46 333.83,37.46
+3VS_CR on BOTTOM (solid shape): 347.35,38.24 347.35,37.35 347.35,37.35 347.35,36.34 347.22,36.2 347.22,32.99 346.69,32.46 345.23,32.46 344.86,32.82 344.86,36.28 343.81,37.33 343.36,37.33 343.28,37.41 343.28,37.64 343.39,37.74 344.23,37.74 344.33,37.65 346.27,37.65 346.46,37.84 346.46,38.24 346.57,38.35 347.23,38.35
+3VS_CR on IN3 (solid shape): outline of 398 points within 331.86,33.68 346.27,37.57
+3VS_FFS on TOP (solid shape): 240.59,47.71 241.31,47.1 242.15,46.69 242.16,46.68 242.22,46.63 242.22,45.64 242.09,45.51 241.14,45.51 241.03,45.41 240.07,45.41 239.8,45.15 239.8,44.27 239.66,44.13 238.94,44.13 238.88,44.19 238.88,45.18 238.65,45.41 238.08,45.41 238.02,45.46 238.02,45.96 238.11,46.05 239.22,46.05 239.43,46.26 239.43,47.53 239.61,47.71
+3VS_FFS on IN1 (solid shape): 241.24,47.7 241.24,47.06 240.98,46.81 239.71,46.81 239.27,47.25 239.27,47.51 239.61,47.85 239.63,47.85 239.7,47.86 239.77,47.89 241.05,47.89
+3VS_TP on TOP (solid shape): 191.1,11.35 191.1,9.81 190.98,9.69 190.68,9.69 190.6,9.62 190.6,8.45 190.82,8.24 190.82,7.82 190.63,7.63 190.27,7.63 190.26,7.62 190.05,7.62 189.93,7.5 189.93,6.24 189.81,6.12 189.29,6.12 189.03,6.38 189.03,6.41 189,6.53 188.94,6.63 188.94,6.83 188.95,6.85 189.01,6.98 189.03,7.12 189.03,7.29 189.01,7.44 188.94,7.57 188.94,8.25 188.71,8.48 188.71,10.94 189.28,11.5 190.95,11.5
+3VS_TPM on BOTTOM (solid shape): outline of 383 points within 148.56,2.35 160.34,11.36
+3VS_WLAN on TOP (solid shape): 333.99,108.74 333.99,105.56 334.2,105.36 334.9,105.36 334.96,105.29 334.96,104.02 334.07,103.13 334.07,102.23 332.42,100.57 332.42,96.53 332.8,96.15 335.03,96.15 335.66,96.78 335.66,98.5 336.42,99.26 336.42,100.21 336.49,100.28 337.12,100.28 337.25,100.15 337.25,96.02 335.49,94.26 330.56,94.26 329.94,94.88 329.94,100.72 332.93,103.71 332.93,105.1 332.36,105.67 332.36,108.72 332.55,108.91 333.82,108.91
+3VS_WLAN on BOTTOM (solid shape): 347.78,94.33 347.78,90.93 347.43,90.59 346.29,90.59 346.14,90.74 346.14,92.62 345.33,93.43 330.45,93.43 329.48,92.46 329.48,90.73 329.37,90.62 326.52,90.62 326.16,90.98 326.16,94.73 327.23,95.79 346.32,95.79
+5V_CHGUSB_1 on BOTTOM (solid shape): 332.16,69.94 332.16,66.3 331.9,66.05 331.6,66.05 331.53,65.99 331.15,65.99 330.77,66.37 330.77,67.26 330.65,67.38 330.65,70.05 330.9,70.3 331.79,70.3
+5V_CHGUSB_1 on IN3 (solid shape): outline of 266 points within 331.03,64.92 337.82,72.4
+5V_CHGUSB_1 on IN5 (solid shape): outline of 238 points within 331.03,65.16 337.82,72.4
+5V_CHGUSB_1 on VCC: 331.45,65.03 330.96,65.52 330.96,69.37 333.99,72.4 338.13,72.4 338.13,67.57 336.57,67.57 334.03,65.03
+5V_CHGUSB_2 on TOP (solid shape): 24.77,93.42 24.77,92.89 24.76,92.88 24.76,92.26 24.76,92.23 24.77,92.18 24.77,91.87 24.68,91.78 23.6,91.78 23.29,92.08 23.29,93.33 23.57,93.61 24.58,93.61
+5V_CHGUSB_2 on TOP (solid shape): 19.31,109.5 19.31,108.75 19.58,108.47 21.02,108.47 21.08,108.4 21.08,106.63 21.02,106.56 20.64,106.56 20.13,107.07 19.5,107.07 19.49,107.08 18.61,107.08 18.11,107.58 17.27,107.58 17.02,107.83 16.65,107.83 15.59,107.72 15.62,106.65 15.62,106.18 15.37,105.93 14.35,105.93 14.03,106.24 14.03,107.54 14.1,107.63 14.21,107.61 15.05,107.52 15.29,108.33 15.28,108.35 15.28,108.56 16.32,109.6 19.2,109.6
+5V_CHGUSB_2 on IN1 (solid shape): outline of 629 points within 18.96,91.58 25.36,107.87
+5V_CHGUSB_2 on IN3 (solid shape): outline of 224 points within 14.03,105.65 23.31,109.04
+5V_CHGUSB_2 on IN4 (solid shape): outline of 225 points within 13.98,105.41 23.23,108.71
+5V_CHGUSB_2 on IN5 (solid shape): outline of 224 points within 13.98,105.41 23.23,108.71
+5VALW on TOP (solid shape): 183.73,11.03 183.73,9.37 183.62,9.25 182.98,9.25 181.89,10.35 181.89,11.12 182,11.24 183.53,11.24
+5VALW on TOP (solid shape): 240.89,3.8 240.89,3.15 239.86,2.12 239.28,2.12 239.08,2.32 239.08,3.64 239.29,3.86 240.84,3.86
+5VALW on TOP (solid shape): 250.19,113.42 250.19,111.96 250,111.77 247.91,111.77 247.84,111.83 247.84,113.55 247.97,113.67 249.94,113.67
+5VALW on TOP (solid shape): 181.73,11.15 181.73,10.36 182.09,9.99 182.09,9.36 182.02,9.28 179.88,9.28 179.77,9.39 179.77,9.76 180.39,10.38 180.39,11.17 180.51,11.29 181.59,11.29
+5VALW on TOP (solid shape): 316.45,33.85 316.45,33.35 316.36,33.26 314.53,33.26 314.52,33.27 314.35,33.31 314.18,33.27 314.17,33.26 313.97,33.26 313.87,33.36 313.87,33.88 313.96,33.97 315.76,33.97 316.34,33.97
+5VALW on TOP (solid shape): 23.62,89.71 24.6,89.71 24.78,89.53 24.78,89.29 24.76,89.22 24.76,89.16 24.76,88.26 24.84,88.18 24.84,87.26 22.9,87.26 22.68,87.47 22.68,89.11 22.82,89.25 22.82,89.61 22.92,89.71 23.51,89.71
+5VALW on TOP (solid shape): 8.79,5.85 8.79,5.21 8.68,5.11 8.68,4.43 8.36,4.11 8.36,4.04 8.36,3.68 8.32,3.64 7.85,3.64 7.76,3.72 7.76,4.23 7.75,4.23 7.75,4.28 7.67,4.79 7.53,5.28 7.53,5.29 7.53,5.79 7.65,5.92 8.73,5.92
+5VALW on TOP (solid shape): 319.87,7.04 319.87,6.38 319.84,6.36 319.36,6.36 319.33,6.36 319.33,5.66 319.36,5.65 319.83,5.65 319.86,5.63 319.86,5.17 319.84,5.16 319.36,5.16 319.33,5.16 319.33,4.46 319.84,4.45 319.86,4.44 319.86,3.01 319.53,2.68 315.7,2.68 315.3,3.08 315.3,6.59 315.89,7.18 319.72,7.18
+5VALW on BOTTOM (solid shape): 249.19,46.26 249.19,44.26 249.1,44.18 248.06,44.18 247.96,44.28 247.96,46.55 248.19,46.78 248.66,46.78
+5VALW on BOTTOM (solid shape): 183.87,10.56 183.87,9.34 183.6,9.08 179.9,9.08 179.71,9.27 179.71,10.08 179.72,10.09 179.72,10.4 180.11,10.79 183.64,10.79
+5VALW on BOTTOM (solid shape): 250.01,7.22 250.01,6.99 248.72,5.69 247.64,5.69 247.55,5.78 247.55,6.63 247.61,6.69 248.23,6.69 249.31,7.76 249.46,7.76
+5VALW on BOTTOM (solid shape): 331.85,62.49 331.85,62.24 332.42,61.67 332.42,60.4 332.11,60.08 330.32,60.08 330.15,60.24 330.15,60.76 330.45,61.06 330.45,62.21 330.45,62.37 330.44,62.38 330.44,62.58 330.59,62.73 331.61,62.73
+5VALW on BOTTOM (solid shape): 9.86,5.84 9.86,4.2 9.72,4.05 9.62,4.05 9.34,4.2 9.05,4.05 7.76,4.05 7.75,4.1 7.7,4.66 7.56,5.2 7.56,5.21 7.56,5.78 7.75,5.97 9.73,5.97
+5VALW on BOTTOM (solid shape): outline of 110 points within 28.26,49.46 31.81,53.92
+5VALW on IN2 (solid shape): 316.41,34.05 316.41,33.48 316.32,33.39 314.18,33.39 314.12,33.46 314.12,34.05 314.25,34.19 316.28,34.19
+5VALW on IN2 (solid shape): outline of 821 points within 7.44,1.89 25.57,8.98
+5VALW on IN3 (solid shape): 316.55,34.49 316.55,33.47 316.36,33.28 314.81,33.28 314.67,33.42 314.67,34.01 315.66,35 316.04,35
+5VALW on IN4 (solid shape): outline of 57959 points within 13.46,1.27 350.29,115.76
+5VALW on IN5 (solid shape): 249.76,46.5 249.76,45.72 249.62,45.58 248.27,45.58 248.09,45.77 248.09,46.63 248.23,46.77 249.49,46.77
+5VALW on IN5 (solid shape): 250.25,113.1 250.25,111.13 250.09,110.96 249.32,110.96 249.15,111.12 249.15,113.14 249.3,113.29 250.06,113.29
+5VALWP on TOP (solid shape): 331.47,7.82 331.47,3.82 330.26,2.61 322.97,2.61 322.89,2.52 320.48,2.52 320,3 320,6.89 320.06,6.94 320.76,6.94 321.6,6.1 327.79,6.1 328.36,6.68 328.36,7.5 328.8,7.95 331.34,7.95
+5VS on TOP (solid shape): 18.47,89.15 18.96,89.15 19.24,88.87 19.24,87.72 18.92,87.4 17.11,87.4 16.89,87.63 16.89,89.1 17.17,89.38 18.24,89.38
+5VS on TOP (solid shape): 307.48,34.13 307.48,33.4 307.81,33.08 308.14,33.08 308.31,32.91 309.08,32.91 309.14,32.85 309.14,31.45 308.99,31.3 306.99,31.3 306.78,31.51 306.78,32.75 305.65,33.89 305.65,34.44 306.17,34.96 306.65,34.96
+5VS on TOP (solid shape): 95.45,36.93 95.45,36.12 95.64,35.93 96.07,35.93 96.23,35.77 96.23,35.28 96.43,35.08 96.43,34.61 96.58,34.45 98.42,34.45 98.55,34.32 98.55,33.66 98.34,33.45 93.7,33.45 93.5,33.65 93.5,36.23 94.24,36.23 94.24,36.18 94.25,36.12 94.27,36.07 94.29,36.03 94.32,35.98 94.36,35.94 94.4,35.91 94.45,35.88 94.49,35.86 94.55,35.85 94.6,35.85 94.65,35.85 94.71,35.86 94.75,35.88 94.8,35.91 94.84,35.94 94.88,35.98 94.91,36.03 94.93,36.07 94.95,36.12 94.96,36.18 94.96,36.23 94.95,36.28 94.93,36.33 94.91,36.38 94.88,36.43 94.84,36.47 94.8,36.5 94.75,36.53 94.71,36.54 94.65,36.56 94.6,36.56 94.55,36.56 94.49,36.54 94.45,36.53 94.4,36.5 94.36,36.47 94.32,36.43 94.29,36.38 94.27,36.33 94.25,36.28 94.24,36.23 93.5,36.23 93.5,36.89 93.85,37.24 95.15,37.24
+5VS on IN1 (solid shape): outline of 592 points within 135.68,107.03 142.15,115.05
+5VS on IN6 (solid shape): 30.8,13.03 30.8,12.33 30.61,12.14 28.83,12.14 28.58,12.39 28.58,13.22 28.64,13.28 30.54,13.28
+5VS on IN6 (solid shape): 49.91,19.82 49.91,19.57 49.28,18.93 47.31,18.93 47.05,19.19 47.05,19.5 47.5,19.95 49.79,19.95
+5VS on IN6 (solid shape): 307.33,34.26 307.33,33.57 306.15,32.39 305.46,32.39 304.69,33.17 304.69,33.75 305.74,34.81 306.78,34.81
+5VS on IN6 (solid shape): outline of 808 points within 241.63,15.88 262,23.06
+5VS on VCC: 126.47,14.99 124.06,17.41 115.04,17.41 113.26,19.19 107.42,19.19 104.63,21.98 88.92,21.98 84.84,17.89 84.84,16.75 84.35,16.26 53.74,16.26 53.62,16.14 50.53,16.14 48.9,17.77 48.9,19.84 48.94,19.88 50.31,19.88 51.39,18.8 56.18,18.8 57.64,20.27 59.4,20.27 59.69,19.97 59.69,19.21 60.09,18.8 78.97,18.8 85.7,25.54 102.09,25.54 103.13,26.57 103.13,32.67 103.87,33.41 107.52,33.41 107.7,33.23 107.7,32.11 110.84,28.96 113.23,28.96 113.59,28.61 113.59,26.47 114.27,25.79 115.85,25.79 116.71,24.92 116.71,20.48 117.75,19.44 127.28,19.44 127.78,18.93 242.72,18.93 243.33,18.32 243.33,15.48 242.85,14.99
+5VS on VCC: 12.04,12.07 10.03,14.08 10.03,19.93 7.24,22.72 7.24,24.37 5.44,26.17 2.07,26.17 2.07,31.38 3.29,31.38 3.75,31.92 3.75,36.92 4.11,37.28 5.69,37.28 6.29,37.88 6.29,40.19 6.33,40.23 10.82,40.21 11.33,39.7 13.44,39.7 13.76,40.01 14.9,40.01 15.37,40.48 15.37,44.48 16,45.12 16,53.12 15.62,53.5 15.62,54.97 15.35,55.24 15.35,57.92 15.04,58.23 15.04,58.84 14.5,59.38 14.5,60.04 12.19,62.34 12.19,72.8 16.89,77.5 16.89,89.31 17.25,89.67 18.69,89.67 19.43,88.93 19.43,77.58 14.48,72.63 14.48,68.61 17.27,65.82 17.27,36.18 13.72,32.63 13.72,17.68 15.26,16.14 24.66,16.14 26.18,14.61 29.61,14.61 30.86,13.37 30.86,12.07
+5VS_AUDIO on TOP (solid shape): 8.59,11.42 8.59,10.09 8.54,10.04 7.65,10.04 7.65,10.03 7.61,10.03 7.59,10.01 6.39,10.01 5.97,10.43 5.97,11.57 6.67,12.26 7.75,12.26
+5VS_AUDIO on TOP (solid shape): outline of 146 points within 12.47,34.56 15.06,40.04
+5VS_AUDIO on BOTTOM (solid shape): 15.48,38.78 15.48,38.24 15.32,38.08 15.32,36.83 15.24,36.76 14.82,36.76 14.57,37 14.2,37 14.12,37.08 14.12,37.41 14.2,37.48 14.66,37.48 14.75,37.57 14.75,38.78 14.83,38.85 15.4,38.85
+5VS_AUDIO on IN3 (solid shape): 7.78,12.55 7.78,11.66 7.68,11.57 6.73,11.57 6.61,11.69 6.61,12.26 6.73,12.39 6.99,12.39 7.24,12.65 7.68,12.65
+5VS_HDD on TOP (solid shape): 239.93,10.57 239.93,9.94 239.8,9.81 239.51,9.81 239.38,9.69 239.38,9.18 239.47,9.09 239.72,9.09 239.79,9.01 239.79,8.28 239.71,8.2 238.27,8.2 237.99,7.91 237.28,7.91 237.17,8.03 237.17,8.44 237.25,8.53 237.25,9.58 237.25,9.58 237.25,10.68 237.45,10.87 239.62,10.87
+5VS_HDD on BOTTOM (solid shape): 240.26,13.43 240.26,11.66 240.04,11.44 238.76,11.44 238.48,11.16 238.48,9.94 238.76,9.66 239.02,9.66 239.08,9.6 239.08,9.15 238.95,9.03 237.49,9.03 237.36,9.15 237.36,9.62 237.22,9.76 237.22,11.37 236.43,12.16 236.43,12.78 236.54,12.89 238.96,12.89 239.21,13.13 239.21,13.49 239.29,13.57 240.13,13.57
+AVDD1 on TOP (solid shape): 15.05,41.54 15.05,40.52 14.99,40.46 14.99,40.45 13.46,40.45 13.16,40.15 12.86,40.15 12.78,40.23 12.78,40.72 13.17,41.11 13.17,41.42 13.36,41.61 14.99,41.61
+AVDD1 on BOTTOM (solid shape): 15.3,41.28 15.3,40.74 15.18,40.61 14.36,40.61 14.36,40.6 13.65,40.6 13.06,40.01 11.79,40.01 11.74,40.07 11.74,40.17 11.8,40.24 12.6,40.24 12.66,40.3 12.74,40.3 13.21,40.77 13.21,41.22 13.25,41.26 13.72,41.26 13.86,41.4 15.18,41.4
+AVDD2 on TOP (solid shape): 4.08,41.67 4.08,40.48 4.58,39.97 4.58,38.74 4.49,38.65 4.12,38.65 3.94,38.72 3.75,38.65 2.97,38.65 2.85,38.77 2.85,41.66 3.04,41.84 3.91,41.84
+DVDD on BOTTOM (solid shape): 8.97,35.19 8.97,34.16 9.61,33.52 9.61,32.22 9.53,32.13 8.99,32.13 8.93,32.19 8.93,32.89 8.86,32.96 8.86,33.79 8.83,33.82 8.83,33.86 8.81,34.07 8.71,34.21 8.71,35.2 8.75,35.25 8.92,35.25
+DVDD on IN1 (solid shape): outline of 190 points within 5.9,31.79 11.57,34.5
+DVDDIO on BOTTOM (solid shape): 5.55,37.41 5.55,37.26 5.5,37.21 4.63,37.21 4.55,37.12 4.29,37.12 3.94,36.77 3.62,36.77 3.48,36.91 3.48,37.22 3.67,37.41 4.63,37.41 4.67,37.45 5.51,37.45
+VBUS_1 on TOP (solid shape): 6.95,64.78 8.62,64.78 8.71,64.87 8.91,64.87 9.04,64.73 9.04,64.52 8.84,64.32 6.82,64.32 6.75,64.26 6.39,64.26 6.19,64.47 6.19,64.74 6.22,64.79 6.26,64.86 6.37,64.97 6.75,64.97
+VBUS_1 on TOP (solid shape): 6.82,67.27 8.64,67.27 8.73,67.36 8.94,67.36 9.06,67.24 9.06,67.04 8.87,66.85 6.89,66.85 6.69,66.65 6.43,66.65 6.42,66.69 6.35,66.9 6.21,67.06 6.19,67.08 6.19,67.17 6.39,67.37 6.71,67.37
+VBUS_1 on BOTTOM (solid shape): 28.42,65.93 28.42,63.92 28.3,63.79 26.93,63.79 26.92,63.79 26.51,63.79 26.23,64.08 26.23,66.18 26.66,66.61 27.74,66.61
+VBUS_1 on BOTTOM (solid shape): outline of 329 points within 6.22,63.76 15.9,69.22
+VBUS_1 on IN1 (solid shape): outline of 2620 points within 6.35,61.39 28.45,76.21
+VBUS_1 on IN2 (solid shape): 13.73,67.21 13.73,66.61 14.61,65.73 14.61,64.59 14.23,64.21 11.85,64.21 11.83,64.23 12.04,64.72 11.53,64.87 11.53,65.07 11.53,65.11 11.53,65.15 11.53,66.72 12.45,67.64 13.3,67.64
+VBUS_1 on IN4 (solid shape): outline of 1555 points within 6.14,59.22 17.89,69.13
+VBUS_1 on IN5 (solid shape): outline of 909 points within 6.14,61.98 17.22,68.01
+VBUS_1 on IN6 (solid shape): outline of 428 points within 6.21,63.72 14.8,68.16
+VBUS_DC_SS on BOTTOM (solid shape): 16.75,30.32 18.96,30.32 19.14,30.14 19.14,27.98 19.02,27.87 16.68,27.87 16.54,27.72 16.33,27.72 16.19,27.58 16.09,27.57 16.07,27.56 15.94,27.47 15.86,27.34 15.85,27.33 15.56,27.03 15.56,26.55 15.45,26.44 12.88,26.44 12.81,26.51 12.81,28.67 13.05,28.9 15.05,28.9 15.5,29.35 15.5,30.44 15.75,30.69 16.37,30.69
+VCC0V9_CIO on BOTTOM (solid shape): 28.31,42.7 28.36,42.72 28.41,42.72 28.54,42.63 28.7,42.62 28.72,42.62 28.75,42.59 28.77,42.52 28.8,42.48 28.83,42.44 28.89,42.41 28.89,42.19 28.82,42.13 28.7,42 28.7,41.5 28.54,41.35 28.54,40.7 28.4,40.55 28.05,40.55 27.91,40.69 27.91,40.71 27.87,40.8 27.81,40.86 27.81,41.13 27.91,41.32 27.81,41.51 27.81,41.62 28.25,42.07 28.26,42.08 28.34,42.29 28.26,42.5 28.25,42.52 28.25,42.64
+VCC0V9_CIO on IN6 (solid shape): outline of 153 points within 27.76,40.3 33.89,43.23
+VCC0V9_DP on TOP (solid shape): outline of 418 points within 26.32,37.85 32.64,46.26
+VCC0V9_DP on BOTTOM (solid shape): 26.57,43.26 26.84,43.26 26.99,43.4 27.06,43.4 27.24,43.23 27.41,43.23 27.52,43.11 27.58,43.05 27.58,42.86 27.22,42.51 26.28,42.51 26.24,42.55 26.24,43.32 26.34,43.41 26.42,43.41
+VCC0V9_DP on BOTTOM (solid shape): 29.66,41.49 29.68,41.46 29.71,41.43 29.74,41.4 29.78,41.37 29.78,41.27 29.63,40.99 29.78,40.72 29.78,40.63 29.63,40.46 29.63,40.23 29.64,40.2 29.7,40.12 29.78,40.06 29.74,39.94 29.68,39.88 29.55,39.88 29.36,40.08 29.23,40.08 29.19,40.11 29.19,40.12 29.14,40.18 29.08,40.22 29.08,40.23 28.76,40.55 28.76,41.37 28.89,41.49
+VCC0V9_PCIE on TOP (solid shape): outline of 145 points within 25.79,35.65 29.19,39.96
+VCC0V9_PCIE on BOTTOM (solid shape): 27.17,40.1 27.2,40.04 27.19,39.98 27.03,39.68 27.21,39.4 27.24,39.39 27.24,39.07 27.24,39.07 27.16,38.99 27.16,38.67 27.03,38.53 27.03,38.26 27.23,38.06 27.49,38.06 27.63,38.2 27.72,38.2 27.76,38.16 27.81,38.12 27.81,37.36 27.77,37.33 27.73,37.28 27.59,37.28 27.35,37.51 27.27,37.51 27.13,37.66 26.94,37.66 26.78,37.5 26.65,37.5 26.45,37.3 26.32,37.3 26.28,37.34 26.28,37.5 26.39,37.74 26.28,37.99 26.28,38.15 26.36,38.26 26.39,38.4 26.39,38.42 26.48,38.51 26.54,38.55 26.58,38.6 26.6,38.78 26.48,38.92 26.44,39 26.47,39.08 26.54,39.14 26.54,39.2 26.61,39.37 26.54,39.54 26.54,39.85 26.6,39.94 26.61,40.06 26.64,40.13 26.71,40.16 27.11,40.16
+VCC_CORE on TOP (solid shape): outline of 2252 points within 145.66,68.1 171.84,114.84
+VCC_CORE on BOTTOM (solid shape): outline of 127 points within 160.71,67.34 171.85,69.14
+VCC_CORE on BOTTOM (solid shape): outline of 1504 points within 149.51,79.59 170.44,116.01
+VCC_CORE on IN1 (solid shape): outline of 2080 points within 157.7,67.26 172.69,88.46
+VCC_CORE on IN2 (solid shape): outline of 4561 points within 148.16,67.2 173.59,111.58
+VCC_CORE on IN4 (solid shape): outline of 4904 points within 145.66,67.41 172.77,110.75
+VCC_CORE on IN6 (solid shape): outline of 378 points within 149.56,95.28 166.24,116.01
+VCC_CORE on VCC: 154.67,56.52 154.18,57.01 154.18,67.17 152.4,68.95 152.4,78.39 153.54,79.53 153.54,85.22 151.26,87.5 149.92,87.5 148.75,88.67 146.14,88.67 144.3,90.51 144.3,92.67 138.3,98.67 138.3,98.71 138.92,99.32 140.44,99.32 142.37,101.25 142.37,105.31 143.11,106.05 144,106.05 145.16,107.22 145.16,110.39 145.78,111.01 154.37,111.01 154.89,110.49 154.89,107.91 157.25,105.55 166.39,105.55 166.69,105.25 166.69,96.04 168.55,94.18 172.04,94.18 172.98,93.25 172.98,86.52 175.01,84.49 175.01,58.92 172.62,56.52
+VCCGT on TOP (solid shape): outline of 7104 points within 116.47,67.59 158,89
+VCCGT on BOTTOM (solid shape): outline of 164 points within 143.8,67.49 156.81,69.16
+VCCGT on BOTTOM (solid shape): outline of 3083 points within 115.6,68.78 158,93.35
+VCCGT on IN1 (solid shape): outline of 3716 points within 138.25,67.64 157.99,88.26
+VCCGT on IN2 (solid shape): outline of 4055 points within 116.51,66.72 159.43,89.04
+VCCGT on IN3 (solid shape): 121.82,83.93 121.82,82.18 122.35,81.64 122.95,81.64 123.31,81.29 123.31,79.92 121.73,78.34 121.73,70.81 121.25,70.33 121.25,70.13 119.91,68.79 116.89,68.79 116.36,69.33 116.36,69.53 116.89,70.06 116.89,70.72 115.9,71.71 115.9,81.47 116.26,81.82 117.76,81.82 118.03,82.1 118.03,82.76 117.12,83.68 117.12,84.16 117.48,84.51 121.24,84.51
+VCCGT on IN4 (solid shape): outline of 99 points within 115.9,68.79 123.81,84.51
+VCCGT on IN4 (solid shape): outline of 2669 points within 138.66,67.64 158,88.71
+VCCGT on IN5 (solid shape): outline of 5046 points within 116.56,69.83 158.73,88.02
+VCCGT on IN6 (solid shape): outline of 107 points within 115.9,68.79 124.13,84.51
+VCCGT on VCC: 145.93,88.16 148.54,88.16 149.71,86.99 151.05,86.99 153.04,85.01 153.04,79.74 151.89,78.6 151.89,68.74 153.67,66.96 153.67,57.01 153.18,56.52 131.68,56.52 130.68,57.52 130.68,62.09 129.01,63.76 120.25,63.76 115.95,68.06 115.95,85.63 119.76,89.44 119.76,97.63 121.45,99.32 137.18,99.32 137.8,98.71 137.8,98.46 143.79,92.46 143.79,90.3 ; 1 cut-out
+VCCIO on TOP (solid shape): outline of 891 points within 172.5,69.88 177.94,76.48
+VCCIO on BOTTOM (solid shape): outline of 89 points within 117.45,62.32 121.62,68.22
