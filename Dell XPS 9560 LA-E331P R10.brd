# Allegro board Dell XPS 9560 LA-E331P R10.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
RL3  820_0402_5%  [R_0402]  344.22 103.39 0 top
RL4  820_0402_5%  [R_0402]  344.22 104.4 0 top
RL5  820_0402_5%  [R_0402]  344.22 105.29 0 top
RN1  0_0402_5%  [R_0402]  342.72 100.15 180 top
RN33  100K_0402_5%  [R_0402]  340.63 100.72 180 top
RN34  0_0603_5%  [R0603_0OHM]  335.41 99.77 0 top
RP1  2.2K_8P4R_5%  [RP_0804_8P4R]  100.71 8 0 top
RP2  10K_0804_8P4R_5%  [RP_0804_8P4R]  66.67 6.64 0 top
RP4  33_0804_8P4R_5%  [RP_0804_8P4R]  67.69 1.86 0 bottom
RP8  10K_0804_8P4R_5%  [RP_0804_8P4R]  72.2 18.86 180 bottom
RP15  33_8P4R_5%  [RP_0804_8P4R]  63.71 8 0 top
RP19  100K_0804_8P4R_5%  [RP_0804_8P4R]  291.03 7.64 180 top
RP20  10K_8P4R_5%  [RP_0804_8P4R]  311.71 28.84 270 top
RP22  10K_0804_8P4R_5%  [RP_0804_8P4R]  72.96 2.03 0 bottom
RP23  10K_0804_8P4R_5%  [RP_0804_8P4R]  72.96 4.97 0 bottom
RP24  10K_1206_10P8R_5%  [RP_1206_10P8R]  342.34 101.9 90 top
RR1  10K_0402_5%  [R_0402]  345.2 34.11 180 bottom
RR2  0_0402_5%  [R0402_0OHM]  334.91 39.06 180 bottom
RR3  0_0402_5%  [R0402_0OHM]  334.91 39.95 180 bottom
RR4  0_0402_5%  [R0402_0OHM]  336.11 40.83 90 bottom
RR5  0_0402_5%  [R0402_0OHM]  338.71 41.91 90 bottom
RR6  6.2K_0402_1%  [R_0402]  337.5 32.76 90 bottom
RR7  0_0402_5%  [R0402_0OHM]  339.6 41.91 90 bottom
RR8  0_0402_5%  [R0402_0OHM]  340.49 41.91 90 bottom
RR9  10K_0402_5%  [R_0402]  344.29 35 0 bottom
RR10  0_0402_5%  [R0402_0OHM]  343.41 34.1 90 bottom
RT1  3.01K_0402_1%  [R_0402]  28.04 38.41 90 top
RT2  14K_0402_1%  [R_0402]  29.4 42.91 0 top
RT3  100_0201_1%  [R_0201]  25.15 47.93 270 top
RT4  100_0201_1%  [R_0201]  34.39 43.44 180 bottom
RT5  14K_0402_1%  [R_0402]  31.61 35.91 0 top
RT6  10K_0201_5%  [R_0201]  34.39 43.44 180 top
RT7  10K_0201_5%  [R_0201]  34.39 45.44 180 top
RT8  10K_0201_5%  [R_0201]  34.39 44.87 180 top
RT9  10K_0201_5%  [R_0201]  34.39 44.08 180 top
RT10  4.75K_0402_0.5%  [R_0402]  25.02 42.3 0 top
RT12  499_0201_1%  [R_0201]  25.31 35.87 270 top
RT15  3.3K_0201_1%  [R_0201]  42.76 28.67 180 bottom
RT16  2.2K_0201_5%  [R_0201]  30.35 29.99 315 bottom
RT17  3.3K_0201_1%  [R_0201]  30.48 31.96 270 bottom
RT18  2.2K_0201_5%  [R_0201]  31.37 31.45 270 bottom
RT21  10K_0201_5%  [R_0201]  18.07 48.27 180 bottom
RT22  10K_0201_5%  [R_0201]  31.94 48.17 270 bottom
RT23  10K_0201_5%  [R_0201]  31.88 48.05 270 top
RT25  10K_0201_5%  [R_0201]  24.58 47.93 270 top
RT33  2.2K_0201_5%  [R_0201]  33.61 48.01 270 bottom
RT34  2.2K_0201_5%  [R_0201]  33.02 48.01 270 bottom
RT35  2.2K_0201_5%  [R_0201]  30.1 48.01 270 bottom
RT36  2.2K_0201_5%  [R_0201]  30.74 48.01 270 bottom
RT37  100K_0201_5%  [R_0201]  31.31 48.01 270 bottom
RT38  100K_0201_5%  [R_0201]  19.97 33.03 0 top
RT39  100K_0201_5%  [R_0201]  23.88 100.82 270 bottom
RT40  100K_0201_5%  [R_0201]  19.97 33.6 0 top
RT41  100K_0201_5%  [R_0201]  33.8 45.88 90 bottom
RT42  100K_0201_5%  [R_0201]  35.52 43.44 0 bottom
RT43  100K_0201_5%  [R_0201]  19.97 34.24 0 top
RT44  1M_0201_1%  [R_0201]  19.65 43.77 0 bottom
RT45  1M_0201_1%  [R_0201]  19.65 44.38 0 bottom
RT46  0_0603_5%  [R_0603]  16.19 45.79 0 bottom
RT107  10K_0201_5%  [R_0201]  33.02 47.99 270 top
RT113  0_0603_5%  [R0603_0OHM]  20.13 34.06 270 bottom
RT114  0.01_0603_1%  [R_0603]  18.42 33.69 90 bottom
RT164  499_0201_1%  [R_0201]  24.64 35.34 90 top
RT165  0_0805_5%  [R0805_0OHM]  28.73 51.76 180 bottom
RT167  10K_0201_5%  [R_0201]  18.5 56.59 0 bottom
RT168  3.3K_0201_1%  [R_0201]  21.88 53.72 90 bottom
RT169  3.3K_0201_1%  [R_0201]  22.52 53.72 90 bottom
RT170  3.3K_0201_1%  [R_0201]  23.14 65.22 0 bottom
RT171  3.3K_0201_1%  [R_0201]  18.2 69.22 180 top
RT176  0_0402_5%  [R0402_0OHM]  25.59 63.41 90 bottom
RT177  0_0402_5%  [R0402_0OHM]  24.7 63.41 90 bottom
RT178  0_0402_5%  [R0402_0OHM]  17.34 55.71 270 bottom
RT181  0_0402_5%  [R0402_0OHM]  25.41 53.41 180 bottom
RT182  0_0402_5%  [R0402_0OHM]  25.72 57.65 90 top
RT183  100K_0402_1%  [R_0402]  23.86 61.29 0 top
RT184  0_0402_5%  [R0402_0OHM]  19.62 64.27 270 bottom
RT185  0_0402_5%  [R0402_0OHM]  18.71 64.27 270 bottom
RT186  100K_0201_5%  [R_0201]  28.03 58.94 0 bottom
RT187  100K_0201_5%  [R_0201]  21.12 63.95 270 bottom
RT188  100K_0201_5%  [R_0201]  20.49 63.95 270 bottom
RT189  0_0402_5%  [R_0402]  27.61 60.33 0 top
RT190  0_0402_5%  [R0402_0OHM]  19.04 59.22 180 bottom
RT191  15K_0402_0.1%  [R_0402]  18.54 60.13 90 bottom
RT194  100K_0402_5%  [R_0402]  28.4 58.37 180 top
RT195  0_0402_5%  [R0402_0OHM]  26.23 56.79 270 top
RT199  0_0402_5%  [R_0402]  27.61 59.44 0 top
RT200  0_0402_5%  [R0402_0OHM]  22.48 67.81 90 top
RT201  0_0402_5%  [R0402_0OHM]  19.88 67.75 90 top
RT202  10K_0201_5%  [R_0201]  24.91 49.6 0 top
RT207  100K_0201_5%  [R_0201]  19.65 44.97 0 bottom
RT208  100K_0201_5%  [R_0201]  19.65 43.19 0 bottom
RT209  100K_0201_5%  [R_0201]  25.39 47.92 270 bottom
RT210  0_0201_5%  [R_0201]  16.64 67.41 90 bottom
RT211  0_0201_5%  [R_0201]  20.92 58 0 top
RT212  0_0201_5%  [R_0201]  26.86 69.64 270 bottom
RT213  0_0201_5%  [R_0201]  26.86 72.69 270 bottom
RT226  10K_0201_5%  [R_0201]  21.4 62.72 270 top
RT227  10K_0201_5%  [R_0201]  24.46 54.01 270 top
RT228  0_0201_5%  [R_0201]  41.91 31.34 90 bottom
RT229  0_0201_5%  [R_0201]  30.42 28.37 270 bottom
RT230  0_0201_5%  [R_0201]  31.61 27.84 180 bottom
RT231  0_0201_5%  [R_0201]  41.91 29.43 90 bottom
RT232  0_0201_5%  [R_0201]  21.16 65.06 180 bottom
RT233  0_0201_5%  [R_0201]  22.38 63.47 180 bottom
RT240  0_0402_5%  [R0402_0OHM]  20.19 30.83 90 bottom
RT241  0_0603_5%  [R0603_0OHM]  16.19 44.52 0 bottom
RT242  0_0402_5%  [R_0402]  32.78 36.79 180 top
RT243  0_0402_5%  [R0402_0OHM]  17.64 70.3 0 top
RT244  0_0402_5%  [R0402_0OHM]  25.66 51.27 270 top
RT245  0_0201_5%  [R_0201]  28.03 58.37 0 bottom
RT246  0_0402_5%  [R_0402]  17.76 64.25 270 bottom
RT429  100K_0402_5%  [R_0402]  23.94 58.23 90 top
RT430  1M_0201_1%  [R_0201]  20.97 58.61 180 top
RT431  100K_0201_5%  [R_0201]  20.07 61.45 270 top
RT432  100K_0201_5%  [R_0201]  20.74 62.75 180 top
RT433  10K_0201_5%  [R_0201]  26.86 95.92 90 bottom
RT434  10K_0201_5%  [R_0201]  34.39 44.08 180 bottom
RT435  10K_0201_5%  [R_0201]  25.91 100.88 270 bottom
RT436  10K_0201_5%  [R_0201]  24.39 95.6 90 bottom
RT437  1M_0201_1%  [R_0201]  29.59 56.43 270 top
RT1092  0_0603_5%  [R_0603]  23.43 52.27 90 bottom
RT1093  10K_0402_1%  [R_0402]  24.52 63.51 180 top
RT1094  0_0402_5%  [R_0402]  19.18 54.8 90 bottom
RT1095  0_0402_5%  [R_0402]  18.29 54.8 90 bottom
RT1133  0_0402_5%  [R_0402]  271.95 5.22 0 top
RV8  10_0402_1%  [R_0402]  251.13 56.12 0 top
RV11  100_0402_5%  [R_0402]  254.24 41.79 0 top
RV12  100K_0402_5%  [R_0402]  252.6 50.99 90 top
RV47  200_0402_1%  [R_0402]  198.11 79.07 0 top
RV103  100K_0402_5%  [R_0402]  219.86 118.47 270 top
RV107  10K_0402_5%  [R_0402]  54.28 27.19 0 top
RV108  100K_0402_5%  [R_0402]  225.44 47.06 180 top
RV109  100K_0402_5%  [R_0402]  51.42 27.19 0 top
RV110  0_0402_5%  [R0402_0OHM]  63.96 28.52 180 top
RV111  100K_0402_5%  [R_0402]  252.25 44.59 180 top
RV112  10_0402_1%  [R_0402]  221.44 115.95 270 top
RV113  0_0402_5%  [R0402_0OHM]  58.68 24.95 90 top
RV114  100K_0402_5%  [R_0402]  59.56 24.95 90 top
RV119  1M_0402_5%  [R_0402]  47.68 20.58 0 bottom
RV120  100K_0402_5%  [R_0402]  49.58 21.92 0 bottom
RV121  10K_0402_5%  [R_0402]  18.09 78.94 0 top
RV122  1M_0402_5%  [R_0402]  17.82 89.34 0 bottom
RV123  20K_0402_5%  [R_0402]  16.5 91.27 270 bottom
RV124  2.2K_0402_5%  [R_0402]  24.05 94.1 0 bottom
RV125  2.2K_0402_5%  [R_0402]  20.13 94.57 270 bottom
RV135  220K_0402_5%  [R_0402]  54.23 22.16 90 bottom
RV181  100K_0402_5%  [R_0402]  241.43 98.15 90 top
RV325  1.8K_0402_5%  [R_0402]  199.54 46.96 0 top
RV326  1.8K_0402_5%  [R_0402]  199.54 47.86 0 top
RV399  10K_0402_5%  [R_0402]  246.84 47.54 90 top
RV511  0.01_0805_1%  [R_0805]  244.16 102.54 90 top
RV512  475_0402_1%  [R_0402]  21.9 83.96 0 top
RV513  475_0402_1%  [R_0402]  21.9 84.84 0 top
RV514  475_0402_1%  [R_0402]  21.9 80.02 0 top
RV515  475_0402_1%  [R_0402]  21.9 80.91 0 top
RV516  475_0402_1%  [R_0402]  21.9 81.86 0 top
RV517  475_0402_1%  [R_0402]  21.9 82.75 0 top
RV518  475_0402_1%  [R_0402]  21.9 85.73 0 top
RV519  475_0402_1%  [R_0402]  21.9 86.62 0 top
RV520  0_0402_5%  [R0402_0OHM]  63.25 24.44 90 bottom
RV521  0_0402_5%  [R0402_0OHM]  64.26 24.44 90 bottom
RV522  0_0402_5%  [R0402_0OHM]  65.15 24.44 90 bottom
RV523  0_0402_5%  [R0402_0OHM]  66.17 24.44 90 bottom
RV524  0_0402_5%  [R0402_0OHM]  69.47 24.44 90 bottom
RV525  0_0402_5%  [R0402_0OHM]  70.49 24.44 90 bottom
RV526  0_0402_5%  [R0402_0OHM]  71.38 24.44 90 bottom
RV527  0_0402_5%  [R0402_0OHM]  72.39 24.44 90 bottom
RV528  0_0402_5%  [R0402_0OHM]  62.36 24.44 90 bottom
RV529  0_0402_5%  [R0402_0OHM]  61.34 24.44 90 bottom
RV530  8.2_0402_1%  [R_0402]  20.02 86.67 180 top
RV531  8.2_0402_1%  [R_0402]  20.02 85.78 180 top
RV532  8.2_0402_1%  [R_0402]  20.02 82.8 180 top
RV533  8.2_0402_1%  [R_0402]  20.02 81.91 180 top
RV534  8.2_0402_1%  [R_0402]  20.02 80.83 180 top
RV535  8.2_0402_1%  [R_0402]  20.02 79.94 180 top
RV536  8.2_0402_1%  [R_0402]  20.02 84.9 180 top
RV537  8.2_0402_1%  [R_0402]  20.02 84.01 180 top
RV538  150_0402_5%  [R_0402]  17.78 86.7 270 top
RV539  150_0402_5%  [R_0402]  17.78 82.83 270 top
RV540  150_0402_5%  [R_0402]  17.78 80.86 270 top
RV541  150_0402_5%  [R_0402]  17.78 84.92 270 top
RV545  2.2K_0402_5%  [R_0402]  71.12 26.63 270 top
RV546  2.2K_0402_5%  [R_0402]  65.74 27.31 180 top
RV547  0_0402_5%  [R0402_0OHM]  70.23 26.63 270 top
RV548  0_0402_5%  [R_0402]  70.28 24.65 0 top
RV549  0_0402_5%  [R_0402]  63.96 27.31 180 top
RV550  100K_0402_5%  [R_0402]  208.03 46.19 270 top
RV551  10K_0402_5%  [R_0402]  214 45.02 90 top
RV552  10K_0402_5%  [R_0402]  201.31 55.83 180 bottom
RV553  10K_0402_5%  [R_0402]  212.47 55.2 270 bottom
RV554  100K_0402_5%  [R_0402]  214.76 49.93 270 top
RV557  10K_0402_5%  [R_0402]  222.37 46.81 0 top
RV562  10K_0402_5%  [R_0402]  207.96 47.66 180 top
RV563  10K_0402_5%  [R_0402]  222.37 47.7 0 top
RV564  10K_0402_5%  [R_0402]  214.11 47.63 0 top
RV566  10K_0402_5%  [R_0402]  211.68 42.3 90 top
RV567  100K_0402_5%  [R_0402]  213.74 55.2 270 bottom
RV570  1.8K_0402_5%  [R_0402]  201.29 52.38 180 top
RV571  1.8K_0402_5%  [R_0402]  201.29 51.49 180 top
RV572  1.8K_0402_5%  [R_0402]  209.3 55.53 270 bottom
RV573  1.8K_0402_5%  [R_0402]  208.41 55.53 270 bottom
RV574  0_0402_5%  [R_0402]  213.45 80.84 90 top
RV575  0_0402_5%  [R_0402]  203.33 62.51 270 top
RV576  0_0402_5%  [R_0402]  198.26 62.75 180 top
RV577  0_0402_5%  [R_0402]  191.04 61.23 0 bottom
RV578  2.49K_0402_1%  [R_0402]  191.2 85.81 270 bottom
RV579  10K_0402_5%  [R_0402]  220.65 52.34 0 top
RV580  10K_0402_5%  [R_0402]  227.47 42.74 180 top
RV581  10K_0402_5%  [R_0402]  220.79 49.93 270 top
RV582  0_0402_5%  [R_0402]  196.41 61.85 90 top
RV583  0_0402_5%  [R_0402]  228.92 45.09 270 top
RV585  10M_0402_5%  [R_0402]  217.35 52.14 0 top
RV587  0_0402_5%  [R_0402]  224.66 41.73 180 top
RV588  10K_0402_5%  [R_0402]  222.19 42.53 180 top
RV589  100K_0402_5%  [R_0402]  190.18 61.22 90 bottom
RV590  10K_0402_5%  [R_0402]  197.7 52.37 180 top
RV591  10K_0402_5%  [R_0402]  199.48 52.37 180 top
RV592  10K_0402_5%  [R_0402]  191.95 62.11 180 bottom
RV593  10K_0402_5%  [R_0402]  192.23 64.41 180 bottom
RV594  10K_0402_5%  [R_0402]  219.46 46.06 270 top
RV597  0_0603_5%  [R_0603]  199.01 64.33 0 top
RV600  40.2_0402_1%  [R_0402]  214.95 83.46 270 top
RV601  40.2_0402_1%  [R_0402]  215.58 84.78 180 top
RV602  60.4_0402_1%  [R_0402]  218.57 74.44 90 top
RV605  10K_0402_5%  [R_0402]  231.34 103.58 180 top
RV606  10K_0402_5%  [R_0402]  244.11 62.3 90 top
RV607  10K_0402_5%  [R_0402]  211.63 105.04 0 top
RV608  10K_0402_5%  [R_0402]  245.63 79.57 180 top
RV613  10K_0402_5%  [R_0402]  217.55 103.88 90 bottom
RV614  10K_0402_5%  [R_0402]  225.3 103.88 90 bottom
RV615  10K_0402_5%  [R_0402]  243.46 82.17 90 top
RV616  10K_0402_5%  [R_0402]  241.81 63.46 270 top
RV617  1K_0402_1%  [R_0402]  226 106.49 90 top
RV618  1K_0402_1%  [R_0402]  215.6 105.03 90 top
RV619  121_0402_1%  [R_0402]  238.37 103.01 0 top
RV620  121_0402_1%  [R_0402]  207.63 104.47 0 top
RV621  40.2_0402_1%  [R_0402]  221.69 108.23 90 top
RV622  40.2_0402_1%  [R_0402]  220.77 108.23 90 top
RV623  549_0402_1%  [R_0402]  225.17 108.4 180 top
RV624  931_0402_1%  [R_0402]  223.61 107.46 0 top
RV625  1.33K_0402_1%  [R_0402]  223.7 109.25 90 top
RV626  40.2_0402_1%  [R_0402]  219.98 102.86 90 top
RV627  40.2_0402_1%  [R_0402]  219.07 102.86 90 top
RV628  40.2_0402_1%  [R_0402]  240.47 69.92 0 bottom
RV629  40.2_0402_1%  [R_0402]  240.47 69 0 bottom
RV630  1K_0402_1%  [R_0402]  243.07 77.48 0 bottom
RV631  1K_0402_1%  [R_0402]  242.7 67.18 90 top
RV632  121_0402_1%  [R_0402]  244.97 88.16 90 top
RV633  121_0402_1%  [R_0402]  241.94 55.2 270 top
RV634  549_0402_1%  [R_0402]  245.23 96.34 0 top
RV635  931_0402_1%  [R_0402]  246.14 94.49 90 top
RV636  1.33K_0402_1%  [R_0402]  247.06 94.44 0 top
RV637  40.2_0402_1%  [R_0402]  238.12 73.36 90 bottom
RV638  40.2_0402_1%  [R_0402]  237.21 73.36 90 bottom
RV639  100K_0402_5%  [R_0402]  225.43 49.94 270 top
RV640  100K_0402_5%  [R_0402]  226.45 49.94 270 top
RV641  100K_0402_5%  [R_0402]  230.95 51.3 90 top
RV642  100K_0402_5%  [R_0402]  225.43 52.22 270 top
RV643  100K_0402_5%  [R_0402]  226.45 52.22 270 top
RV644  100K_0402_5%  [R_0402]  230 52.22 270 top
RV645  100K_0402_5%  [R_0402]  223.46 49.94 270 top
RV646  100K_0402_5%  [R_0402]  228.23 49.94 270 top
RV647  100K_0402_5%  [R_0402]  227.34 49.94 270 top
RV648  100K_0402_5%  [R_0402]  229.12 49.94 270 top
RV649  100K_0402_5%  [R_0402]  224.42 49.94 270 top
RV650  100K_0402_5%  [R_0402]  222.57 49.93 270 top
RV651  100K_0402_5%  [R_0402]  223.45 52.21 270 top
RV652  100K_0402_5%  [R_0402]  228.23 52.22 270 top
RV653  100K_0402_5%  [R_0402]  227.34 52.22 270 top
RV654  100K_0402_5%  [R_0402]  229.12 52.22 270 top
RV655  100K_0402_5%  [R_0402]  224.42 52.22 270 top
RV656  100K_0402_5%  [R_0402]  222.44 52.36 270 top
RV657  100K_0402_5%  [R_0402]  247.75 47.56 90 top
RV658  0_0603_5%  [R_0603]  206.95 52.33 270 top
RV659  0_0603_5%  [R_0603]  206.06 46.02 180 top
RV1056  0_0603_5%  [R_0603]  197.93 64.33 180 top
RV1057  0_0603_5%  [R_0603]  201.99 103.07 180 bottom
RV1067  0_0603_5%  [R_0603]  199.07 87.83 180 top
RV1068  0_0603_5%  [R_0603]  193.99 87.87 180 top
RV1072  0_0402_5%  [R_0402]  220.65 51.44 0 top
RV1073  40.2K_0402_1%  [R_0402]  221.68 49.93 270 top
RV1074  0_0402_5%  [R_0402]  201.79 65.99 0 top
RV1075  0.015_1206_1%  [R_1206]  189.1 97.54 0 top
RV1076  0.015_1206_1%  [R_1206]  189.1 99.51 0 top
RV1077  10K_0402_5%  [R_0402]  218.82 55.51 270 bottom
RV1078  0_0603_5%  [R_0603]  192.91 84.31 0 top
RV1079  0_0603_5%  [R_0603]  192.72 85.39 90 top
RV1080  0_0402_5%  [R_0402]  231.9 51.3 90 top
RV1081  0_0402_5%  [R_0402]  232.86 51.3 90 top
RV1082  0_0402_5%  [R_0402]  218.44 46.06 270 top
RV1083  0_0402_5%  [R_0402]  216.21 45.22 0 top
RV1084  0_0402_5%  [R_0402]  219.48 43.51 270 top
RV1086  0_0402_5%  [R_0402]  198.62 104.91 0 top
RV1088  0_0402_5%  [R_0402]  212.47 48.54 270 top
RV1090  0_0402_5%  [R_0402]  211.39 55.52 270 bottom
RV1091  0_0402_5%  [R_0402]  221.36 47.71 270 top
RV1095  0_0201_5%  [R_0201]  163.74 118.18 180 bottom
RV1096  0_0201_5%  [R_0201]  212.22 46.25 270 top
RV1097  0_0201_5%  [R_0201]  215.14 45.07 270 top
RV1098  0_0201_5%  [R_0201]  174.71 112.53 0 bottom
RV1099  0_0201_5%  [R_0201]  206.25 50.08 270 top
RV1100  0_0201_5%  [R_0201]  214 49.01 270 top
RV1101  0_0201_5%  [R_0201]  201.08 54.05 180 bottom
RV1102  0_0201_5%  [R_0201]  212.83 55.89 180 bottom
RV1103  0_0201_5%  [R_0201]  213.45 55.89 0 bottom
RV1104  0_0201_5%  [R_0201]  229.87 42.27 270 top
RV1105  0_0201_5%  [R_0201]  214.19 51.33 270 top
RV1106  0_0201_5%  [R_0201]  229.3 42.29 270 top
RV1107  0_0201_5%  [R_0201]  230.29 43.76 180 top
RV1108  0_0402_5%  [R_0402]  202.72 48.55 270 top
RV1109  0_0402_5%  [R_0402]  203.59 48.55 270 top
RV1110  1.8K_0402_5%  [R_0402]  202.72 46.81 270 top
RV1111  1.8K_0402_5%  [R_0402]  203.59 46.81 270 top
RV1112  1.8K_0402_5%  [R_0402]  244.67 46.11 180 top
RV1114  0_0402_5%  [R_0402]  242.16 48.43 90 top
RV1118  0_0201_5%  [R_0201]  212.45 42.12 90 top
RV1119  0_0201_5%  [R_0201]  209.27 47.51 180 top
RV1120  0_0201_5%  [R_0201]  213.22 42.66 90 top
RV1121  0_0201_5%  [R_0201]  228.84 46.61 270 top
RV1122  0_0201_5%  [R_0201]  230.62 42.77 270 top
RV1123  0_0201_5%  [R_0201]  228.68 42.05 90 top
RV1124  0_0201_5%  [R_0201]  213.09 44.99 270 top
RV1128  1M_0402_5%  [R_0402]  179.15 114.22 270 top
RV1129  0_0402_5%  [R_0402]  175.49 110.87 0 top
RV1130  0_0402_5%  [R_0402]  164.96 114.52 180 top
RV1131  0_0402_5%  [R_0402]  199.99 42.9 0 top
RV1132  0_0402_5%  [R_0402]  199.11 42.9 180 top
RV1133  100K_0402_5%  [R_0402]  242.58 42.85 180 top
RV1140  100K_0402_5%  [R_0402]  225.57 42.87 180 top
RV1522  0_0402_5%  [R_0402]  243.7 42.85 270 top
RV1806  0_0402_5%  [R_0402]  180.9 114.05 0 top
RV1807  0_0402_5%  [R_0402]  180.02 113.31 90 top
RV1808  10_0402_1%  [R_0402]  224.21 118.31 90 top
RV1809  100K_0402_5%  [R_0402]  161.6 119.36 0 top
RV1810  10_0402_1%  [R_0402]  153.98 120.16 270 top
RV1811  100_0402_5%  [R_0402]  248.22 42.25 0 top
RZ13  0_0603_5%  [R0603_0OHM]  310.2 32.39 180 top
RZ15  0_0603_5%  [R0603_0OHM]  312.48 36.97 180 top
RZ18  0_0603_5%  [R0603_0OHM]  58.23 2.68 90 top
RZ26  0_0603_5%  [R0603_0OHM]  340.36 46.11 90 bottom
RZ28  0_0603_5%  [R0603_0OHM]  348.36 37.79 180 bottom
RZ32  100K_0402_5%  [R_0402]  194.95 7.08 270 top
RZ34  0_0805_5%  [R0805_0OHM]  239.02 6.97 90 top
RZ35  0_0603_5%  [R0603_0OHM]  44.51 29.35 0 top
RZ36  0_0805_5%  [R0805_0OHM]  243.52 7.03 90 top
RZ37  0_0603_5%  [R0603_0OHM]  44.39 25.8 0 top
RZ38  100K_0402_5%  [R_0402]  345.56 44.71 0 bottom
RZ39  100K_0402_5%  [R_0402]  345.58 45.84 0 bottom
RZ40  100K_0402_5%  [R_0402]  39.28 28.7 180 top
RZ41  100K_0402_5%  [R_0402]  281.32 20.07 180 top
RZ43  100K_0402_5%  [R_0402]  314.14 34.16 90 bottom
RZ46  100K_0402_5%  [R_0402]  56.96 7.83 270 top
RZ48  0_0603_5%  [R0603_0OHM]  181.5 80.96 315 bottom
RZ50  100K_0402_5%  [R_0402]  109.92 65.43 270 top
RZ58  0_0402_5%  [R0402_0OHM]  176.96 5.58 90 top
RZ59  0_0402_5%  [R_0402]  177.85 3.18 0 top
RZ60  0_0402_5%  [R0402_0OHM]  171.49 4.92 90 top
RZ61  0_0402_5%  [R_0402]  174.54 3.18 180 top
RZ66  0_0603_5%  [R0603_0OHM]  181.67 79.7 180 top
RZ67  0_0603_5%  [R0603_0OHM]  129.99 67 270 top
RZ70  0_0805_5%  [R0805_0OHM]  107.67 15.25 0 top
RZ71  100K_0402_5%  [R_0402]  175.53 5.86 270 top
RZ72  0_0402_5%  [R_0402]  134 70.05 180 top
RZ74  100K_0402_5%  [R_0402]  243.51 1.55 0 top
RZ75  0_0402_5%  [R_0402]  242.65 1.55 180 top
RZ76  0_0402_5%  [R0402_0OHM]  239.95 1.55 0 top
RZ80  100K_0402_5%  [R_0402]  128.27 67.95 0 top
RZ81  0_0402_5%  [R0402_0OHM]  120.24 56.84 0 top
RZ82  0_0402_5%  [R_0402]  122.56 57.78 90 top
RZ84  100K_0402_5%  [R_0402]  120.51 60.61 180 top
RZ85  100K_0402_5%  [R_0402]  180.54 3.18 180 top
RZ86  100K_0402_5%  [R_0402]  171.5 3.44 0 top
RZ87  100K_0402_5%  [R_0402]  120.34 66.29 0 top
RZ88  100K_0402_5%  [R_0402]  108.95 51.95 0 top
RZ89  0_0402_5%  [R_0402]  170.12 9.39 90 bottom
RZ90  0_0402_5%  [R0402_0OHM]  132.39 65.48 0 top
RZ91  0_0402_5%  [R0402_0OHM]  105.4 54.43 0 top
RZ92  0.01_0805_1%  [R_0805]  212.47 49.64 90 top
RZ106  0_0402_5%  [R_0402]  248.22 43.4 0 top
RZ1133  0_0402_5%  [R_0402]  57.96 3.23 90 bottom
RZ1134  0.01_0603_1%  [R_0603]  276.16 5.41 90 top
RZ1135  0.01_0603_1%  [R_0603]  277.43 5.41 90 top
RZ1136  0.01_0603_1%  [R_0603]  308.55 25.09 270 top
RZ1137  0.01_0603_1%  [R_0603]  307.28 25.09 270 top
RZ1138  0.01_0603_1%  [R_0603]  166.65 5.1 90 top
RZ1139  0.01_0603_1%  [R_0603]  165.37 5.1 90 top
RZ1140  0_0402_5%  [R_0402]  56.91 2.21 0 bottom
SW1  SKRBAAE010_4P  [SW_SKRBAAE010_4P]  336.54 114.25 90 top
SW2  NTC311-EA1T-A160T_4P  [SW_NTC311-EA1T-A160T_4P]  348.63 110.32 90 top
SW4  SSAL120100_3P  [SW_SSAL120100_3P]  114 4.26 0 top
T2  PAD~D  [TPC12]  74.23 18.88 180 bottom
T4  PAD~D  [TPC12]  74.63 22.44 180 bottom
T8  PAD~D  [TPC12]  80.61 4.05 0 top
T17  PAD~D  [TPC12]  90.74 1.63 180 bottom
T18  PAD~D  [TPC12]  84.47 6.78 0 top
T20  PAD~D  [TPC12]  92.58 7.98 0 top
T39  PAD~D  [TPC12]  177.32 58.3 0 top
T40  PAD~D  [TPC12]  175.1 58.59 0 top
T41  PAD~D  [TPC12]  175.65 60.85 0 top
T42  PAD~D  [TPC12]  176.39 59.5 0 top
T43  PAD~D  [TPC12]  137.34 59 0 top
T44  PAD~D  [TPC12]  137.42 60.46 0 top
T45  PAD~D  [TPC12]  138.6 84.29 0 top
T46  PAD~D  [TPC12]  172.89 74.87 0 top
T47  PAD~D  [TPC12]  174.82 76.65 0 top
T48  PAD~D  [TPC12]  138.74 82.69 0 top
T49  PAD~D  [TPC12]  140.81 85.35 0 top
T50  PAD~D  [TPC12]  170.07 80.7 0 top
T51  PAD~D  [TPC12]  168.13 68.21 0 top
T52  PAD~D  [TPC12]  160.91 81 0 top
T53  PAD~D  [TPC12]  162.61 68.21 0 top
T57  PAD~D  [TPC12]  173.97 81.67 0 top
T58  PAD~D  [TPC12]  180.28 81.29 180 bottom
T59  PAD~D  [TPC12]  178.41 83.37 0 top
T60  PAD~D  [TPC12]  176.77 81.35 0 top
T61  PAD~D  [TPC12]  174.21 59.94 0 top
T62  PAD~D  [TPC12]  173.29 61.05 0 top
T63  PAD~D  [TPC12]  134.29 84.85 180 bottom
T64  PAD~D  [TPC12]  138.81 81.05 0 top
T65  PAD~D  [TPC12]  143.28 81.07 0 top
T66  PAD~D  [TPC12]  140.12 82.71 0 top
T67  PAD~D  [TPC12]  140.5 83.97 0 top
T68  PAD~D  [TPC12]  141.82 69.26 0 top
T69  PAD~D  [TPC12]  143.41 69.4 0 top
T70  PAD~D  [TPC12]  140.76 80.34 0 top
T71  PAD~D  [TPC12]  143.21 78.9 0 top
T73  PAD~D  [TPC12]  142.5 70.42 0 top
T74  PAD~D  [TPC12]  140.49 70.49 0 top
T75  PAD~D  [TPC12]  141.4 76.4 0 top
T76  PAD~D  [TPC12]  143.05 76.53 0 top
T77  PAD~D  [TPC12]  141.38 74.13 0 top
T78  PAD~D  [TPC12]  143.17 74.35 0 top
T79  PAD~D  [TPC12]  138.09 70.14 0 top
T80  PAD~D  [TPC12]  134.92 70.94 180 bottom
T81  PAD~D  [TPC12]  142.29 84.53 0 top
T82  PAD~D  [TPC12]  142.51 83.16 0 top
T83  PAD~D  [TPC12]  178 68.91 0 top
T84  PAD~D  [TPC12]  156.38 61.95 0 top
T85  PAD~D  [TPC12]  176.72 56.65 180 bottom
T86  PAD~D  [TPC12]  180.79 89.92 180 bottom
T87  PAD~D  [TPC12]  135.05 57.22 0 top
T88  PAD~D  [TPC12]  136.32 57.99 0 top
T89  PAD~D  [TPC12]  176.21 56.27 180 bottom
T90  PAD~D  [TPC12]  179.45 89.92 180 bottom
T91  PAD~D  [TPC12]  74.44 21.14 180 bottom
T92  PAD~D  [TPC12]  73.57 20.06 180 bottom
T94  PAD~D  [TPC12]  75.43 19.38 180 bottom
T104  PAD~D  [TPC12]  82.6 14.52 0 top
T105  PAD~D  [TPC12]  84.81 13.23 0 top
T106  PAD~D  [TPC12]  81.19 14.52 0 top
T107  PAD~D  [TPC12]  75.38 15.34 180 bottom
T108  PAD~D  [TPC12]  73.65 15.99 180 bottom
T120  PAD~D  [TPC12]  75.55 11.39 180 bottom
T121  PAD~D  [TPC12]  75.35 10.08 180 bottom
T122  PAD~D  [TPC12]  73.8 11.17 180 bottom
T123  PAD~D  [TPC12]  83.44 11.82 0 top
T124  PAD~D  [TPC12]  75.59 12.73 180 bottom
T127  PAD~D  [TPC12]  74.02 12.52 180 bottom
T182  PAD~D  [TPC12]  83.44 13.22 0 top
T185  PAD~D  [TPC12]  19.41 53.51 0 bottom
T187  PAD~D  [TPC12]  27.2 59.89 0 bottom
T191  PAD~D  [TPC12]  24.7 54.36 0 bottom
T192  PAD~D  [TPC12]  24.7 54.94 0 bottom
T193  PAD~D  [TPC12]  22.96 59.79 180 top
T194  PAD~D  [TPC12]  22.65 58.45 180 top
T195  PAD~D  [TPC12]  23.57 46.69 180 bottom
T196  PAD~D  [TPC12]  39.26 36.7 0 top
T197  PAD~D  [TPC12]  39.94 38.74 0 top
T198  PAD~D  [TPC12]  39.43 40.01 0 top
T199  PAD~D  [TPC12]  37.02 37.98 0 top
T200  PAD~D  [TPC12]  27.18 58.54 0 bottom
T201  PAD~D  [TPC12]  191.19 63.47 180 bottom
T202  PAD~D  [TPC12]  192.51 63.47 180 bottom
T203  PAD~D  [TPC12]  192.89 66.32 180 bottom
T204  PAD~D  [TPC12]  192.03 65.35 180 bottom
T205  PAD~D  [TPC12]  217.09 61.35 0 top
T208  PAD~D  [TPC12]  230.81 41.39 0 top
T209  PAD~D  [TPC12]  227.74 41.44 0 top
T210  PAD~D  [TPC12]  213.3 46.82 0 top
TV3  PAD~D  [TPC12]  228.92 112.4 180 bottom
TV4  PAD~D  [TPC12]  207.96 112.78 180 bottom
TV5  PAD~D  [TPC12]  250.19 86.98 0 top
TV6  PAD~D  [TPC12]  248.53 58.87 0 top
UA1  -  [ALC3266-CG_QFN56_7X7]  11.24 34.77 90 bottom
UA3  -  [G9090-180T11U_SOT23-5]  5.84 11.74 180 bottom
UA4  -  [EM5209VF_DFN14_3X2]  8.29 5.55 0 top
UC1  -  [74AUP1G07GW_TSSOP5]  124.85 53.21 90 top
UD2  S IC TC7SZ14FU SSOP 5P  [NL17SZ14DFT2G_SOT353-5]  258.13 6.25 270 bottom
UE1  NPCT650JBAYX_QFN32_5X5  [NPCT650JAAYX_QFN32_5X5]  156.73 5.43 180 top
UE2  AH1806-W-7_SC59  [AH1806-W-7_SC59-3-S]  347.25 119.78 90 top
UE3  MEC5085-LZY-HST01_DQFN132_11X11  [MEC5085-LZY_DQFN132_11X11]  295.27 9.93 0 top
UE4  -  [MCP23017T-E-ML_QFN28_6X6]  275.93 11.13 0 top
UE6  -  [APE8937GN2_DFN8_2X2]  191.61 5.34 0 top
UF1  LNG3DMTR_LGA16_3X3~D  [LNG3DMTR_LGA16_3X3]  238.39 49.92 180 top
UH1  SKL-H_BGA1440  [SKL-H_BGA_1440P-T]  178.08 59.74 270 bottom
UH2  SKY-H-PCH_BGA837  [SKY-S-PCH_BGA_837P-T]  99.33 25.75 0 bottom
UH7  -  [MC74VHC1G08DFT2G_SC70-5]  61.36 8.5 90 top
UH8  W25Q256FVEIQ_WSON8  [W25Q256FVEIG_WSON8]  68.65 9.15 270 bottom
UH14  -  [MC74VHC1G08DFT2G_SC70-5]  111.89 6.47 90 top
UI1  -  [TPS2546RTER_QFN16_3X3]  24.64 89.16 0 top
UI2  -  [TPS2546RTER_QFN16_3X3]  330.57 62.21 180 bottom
UI3  -  [PS8713BTQFN24GTR2_TQFN24_4X4]  317.61 31.14 90 bottom
UI4  MC74VHC1G32DFT2G_SC70-5~D  [MC74VHC1G32DFT2G_SC70-5]  26.8 84.46 0 top
UI5  MC74VHC1G32DFT2G_SC70-5~D  [MC74VHC1G32DFT2G_SC70-5]  324.71 51.26 0 top
UN3  -  [APE8937GN2_DFN8_2X2]  337.97 100.92 90 top
UR1  -  [RTS5242-GR_QFN32_4X4]  341.38 35.04 90 bottom
UT1  ALPINE-RIDGE_BGA337  [ALPINE-RIDGE_BGA_337P]  21.97 45.73 270 bottom
UT2  -  [W25Q80DVSSIG_SO8]  32.96 27.31 90 bottom
UT3  -  [APE8937GN2_DFN8_2X2]  18.63 32.7 270 bottom
UT4  TPS65982D_BGA96  [TPS65982_BGA_96P]  20.87 56.4 0 bottom
UT5  -  [W25Q32FVSSIQ_SO8]  25.41 70.43 270 bottom
UV16  -  [AP2330W-7_SC59-3]  18.67 88.09 180 top
UV17  -  [PCA9515BDGKR_VSSOP8]  64.37 25.75 270 top
UV18  N17P-GT_BGA908  [N15P-GT_BGA_908P]  222.04 58.1 90 bottom
UV19  TC7SZ08FU_SSOP5  [MC74VHC1G08DFT2G_SC70-5]  226.62 43.83 0 top
UV20  TC7SZ08FU_SSOP5  [TC7SH08FU_SSOP5]  196.84 44.02 0 top
UV21  TC7SZ08FU_SSOP5  [TC7SH08FU_SSOP5]  222.27 45.54 180 top
UV23  K4G80325FB-HC03_FBGA170~D  [H5GQ1H24AFR-T2L_BGA_170P]  227.61 97.58 0 bottom
UV24  K4G80325FB-HC03_FBGA170~D  [H5GQ1H24AFR-T2L_BGA_170P]  215.15 110.38 180 bottom
UV25  K4G80325FB-HC03_FBGA170~D  [H5GQ1H24AFR-T2L_BGA_170P]  236.52 66.11 270 bottom
UV26  K4G80325FB-HC03_FBGA170~D  [H5GQ1H24AFR-T2L_BGA_170P]  249.32 79.83 90 bottom
UV28  TC7SZ08FU_SSOP5  [MC74VHC1G08DFT2G_SC70-5]  175.88 111.94 0 top
UZ1  -  [EM5209VF_DFN14_3X2]  314.24 33.41 90 top
UZ4  -  [APE8937GN2_DFN8_2X2]  57.08 5.11 180 top
UZ5  -  [APE8937GN2_DFN8_2X2]  344 45.27 270 bottom
UZ7  -  [EM5209VF_DFN14_3X2]  240.39 3.5 0 top
UZ8  -  [SY6288C20AAC_SOT23-5]  43.13 27.35 90 top
UZ9  -  [TPS22961DNYR_WSON8]  182.36 82.54 90 bottom
UZ11  -  [MC74VHC1G08DFT2G_SC70-5]  178.02 4.47 0 top
UZ12  -  [MC74VHC1G08DFT2G_SC70-5]  173.13 4.49 0 top
UZ15  -  [TPS22961DNYR_WSON8]  181.57 84.67 180 top
UZ16  -  [APE8937GN2_DFN8_2X2]  133.6 66.7 90 top
UZ18  -  [MC74VHC1G08DFT2G_SC70-5]  125.29 68.86 270 top
UZ19  -  [MC74VHC1G09DFT2G_SC70-5]  120.24 57.73 0 top
UZ20  -  [MC74VHC1G08DFT2G_SC70-5]  180.98 6.44 270 top
UZ21  -  [MC74VHC1G08DFT2G_SC70-5]  168.47 4.98 270 top
UZ22  -  [MC74VHC1G08DFT2G_SC70-5]  122.49 63.87 90 top
UZ23  -  [MC74VHC1G08DFT2G_SC70-5]  105.99 53.36 270 top
UZ24  -  [APE8937GN2_DFN8_2X2]  208.39 50.36 270 top
YE1  32.768KHZ_12.5PF_CM7V-12520  [Y_CM7V-12520_2P]  287.28 12.82 270 top
YH1  32.768KHZ_X1A000141000300  [Y_CM31532768DZFT_2P]  101.43 2.18 0 top
YH2  24MHZ 12PF_10PPM_7M24090001  [Y_X3G024000DC1H_4P]  104.28 27.4 270 top
YT1  25MHZ_10PF_10PPM_7M25000013  [Y_7V25000014_4P]  23.05 33.47 0 bottom
YV1  27MHZ 10PF_10PPM_7M27000008  [Y_7V27000011_4P]  216.83 47.99 0 top

## Library data of the parts
ADP100 = ACES_50290-00701-001_7P-T
BAT100 = ACES_50290-01201-P01_12P-T
C2973 CA15 CA18 CA20 CA21 CA137 CE76 CE83 CH201 CH202 CT147-CT150 CT153 CT155 CT157 CT162 CT164 CT165 CV122 CV798 CV855 CV861-CV864 CV867-CV873 CV878-CV884 CV895-CV897 CV907 CV924 CV937-CV947 CV958-CV968 CV999-CV1009 CV1020-CV1030 DT174 PC200 PC208 PC219-PC222 PC288 PC289 PC311 PC320 PC321 PC323 PC329 PC333 PC335 PC400 PC410 PC411 PC414 PC417 PC419 PC501 PC512 PC513 PC600 PC607 PC610 PC611 PC709 PC714 PC755 PC780 PC781 PC801 PC805 PC812 PC813 PC901 PC905 PC912 PC913 PC1006-PC1014 PC1016 PC1022-PC1029 PC1047-PC1053 PC1056-PC1070 PC1102 PC1200 PC1209 PC1220 PC1227 PC1234 PC1249 PC1255 PC1261 PC1263-PC1265 PC1269 PC1271 PC1274 PC1276 PC1314 PC1318 PC1347-PC1354 PC1359-PC1363 PC1365-PC1370 PC1372-PC1380 PC1385 PC1386 PC1389-PC1391 PC1394-PC1396 PC1400 PC1402-PC1405 PC1502 PC1503 PC1507 PC1512-PC1514 PC1519 PC1521 PC1523-PC1525 PC1801 PC1803 = C_0603
C2974 CA2 CA4 CA6 CA7 CA9 CA11 CA13 CA14 CA25 CA27 CA29-CA31 CA39 CA41-CA45 CA77 CA78 CA119 CA128 CA129 CE2 CE72-CE75 CE77-CE82 CH200 CH203 CH204 CI21 CI22 CT144 CT146 CT151 CT152 CT158-CT161 CV121 CV363 CV499 CV794 CV796 CV817 CV850-CV854 CV857-CV860 CV865 CV866 CV874-CV877 CV885-CV894 CV898-CV906 CV917-CV919 CV921-CV923 CV925-CV936 CV948-CV957 CV969-CV998 CV1010-CV1019 CV1031-CV1051 CV1500 CZ96-CZ99 PC106-PC110 PC114 PC115 PC201-PC206 PC214-PC218 PC223 PC225 PC299 PC306 PC313 PC314 PC322 PC327 PC328 PC330-PC332 PC334 PC401-PC405 PC407 PC408 PC415 PC416 PC418 PC500 PC502 PC503 PC505 PC507 PC603 PC604 PC609 PC612-PC614 PC701 PC703 PC704 PC736 PC737 PC756 PC800 PC802 PC803 PC807 PC900 PC902 PC903 PC907 PC1003-PC1005 PC1015 PC1017 PC1018 PC1030-PC1041 PC1045 PC1046 PC1054 PC1055 PC1100 PC1101 PC1103-PC1139 PC1201 PC1213 PC1214 PC1221-PC1226 PC1228-PC1233 PC1237-PC1248 PC1250 PC1253 PC1254 PC1277 PC1302 PC1308 PC1313 PC1317 PC1319-PC1342 PC1345 PC1346 PC1355 PC1357 PC1364 PC1383 PC1384 PC1401 PC1406 PC1407 PC1501 PC1504 PC1508 PC1510 PC1511 PC1515-PC1518 PC1520 PC1522 PC1531 PC1532 PC1534 PC1800 PC1802 PC1804 = C_0402
CA1 CA3 CA5 CA8 CA10 CA12 CA16 CA17 CA19 CA23 CA24 CA26 CA28 CA32-CA38 CA40 CA120-CA122 CA124-CA127 CA130 CT25 CT141-CT143 CT145 CT163 CT170-CT173 CV818-CV849 = C_0201
CD1-CD4 CD12 CD16-CD18 CD69 CD74-CD79 = C_0402: room: DIMMA
CD5-CD10 CD13-CD15 CD70-CD73 = C_0603: room: DIMMA
CD11 = C_EEFSS0D221R: room: DIMMA
CD19-CD22 CD29-CD32 CD34 CD35 CD80-CD83 = C_0402: room: DIMMB
CD23-CD28 CD84-CD90 = C_0603: room: DIMMB
CD33 = C_EEFSS0D221R: room: DIMMB
CD36 = C_0603: room: NGFF SSD
CD37-CD47 CD51 CD53 = C_0402: room: NGFF SSD
CE8 CE11-CE13 = C_0402: room: TPM
CE14 = C_0603: room: TPM
CE15 CE16 = C_0402: room: LID
CE17-CE21 CE23-CE39 CE42-CE44 CE48 CE51 CE70 CE71 = C_0402: room: EC5085
CE22 CE40 = C_0603: room: EC5085
CE41 CE45-CE47 CE49 CE50 CE52 CE68 CE69 = C_0402: room: THERMAL
CE53 = C_0603: room: EC23017
CE54 CE55 = C_0402: room: EC23017
CE65 = C_0402: room: TOUCH PAD
CE66 CE67 = C_0402: room: FAN
CF1 = C_0603: room: HDD FFS
CF2 = C_0402: room: HDD FFS
CH3 CH100 CH101 CH174 CH175 CH197 CZ47 CZ49 CZ57 CZ82 CZ86 CZ88 = C_0402: room: CPU
CH5-CH36 = C_0201: room: CPU
CH44 CH196 = C_0402: room: RTC
CH45 CH46 CH50-CH53 CH70 CH80 CH82 CH173 CH176 CH179 CH180 CH183 CH186-CH192 CH198 CH199 = C_0402: room: PCH
CH47 CH48 = C_0201: room: PCH
CH102-CH104 CH111-CH132 CH136 = C_0603: room: CPU_DECAP
CH105-CH110 CH133-CH135 = C_0402: room: CPU_DECAP
CH138 = C_B2: room: CPU_DECAP
CH177 CH178 CH181 CH182 CH184 = C_0603: room: PCH
CI1 CI9 CI10 CI13 = C_0402: room: USB1
CI2-CI8 CI16 CI19 CI20 = C_0402: room: USB2
CI11 = C_0805: room: USB1
CI12 = C_0603: room: USB1
CI17 = C_0805: room: USB2
CI18 = C_0603: room: USB2
CLRP1 = SHORTPADS: User Part Number: PART#; room: PCH
CN1 CN6 = C_0603: room: NGFF WLAN
CN2 CN7-CN9 CN20-CN22 = C_0402: room: NGFF WLAN
CR1-CR3 CR5 CR7-CR11 CR13 CR15 CR16 CR18 = C_0402: room: CARD READER
CR4 CR6 CR12 CR14 CR17 = C_0603: room: CARD READER
CS12-CS14 CS17-CS20 = C_0402: room: HDD
CS15 = C_0603: room: HDD
CT1-CT8 CT17-CT24 CT26 CT29-CT44 CT47 CT50 CT52 CT62-CT68 CT71 CT72 CT74 CT80-CT86 CT93 CT94 CT99-CT103 CT107 CT108 = C_0201: room: THUNBERBOLT
CT53-CT56 CT95-CT98 CT106 CT120-CT123 = C_0402: room: THUNBERBOLT
CT88-CT90 CT105 = C_0603: room: THUNBERBOLT
CV123 CV856 PC307-PC310 PC315 PC316 PC319 PC325 PC336 PC337 PC406 PC409 PC504 PC506 PC508-PC511 PC601 PC602 PC605 PC606 PC700 PC705-PC708 PC710 PC712 PC713 PC764-PC766 PC804 PC806 PC808-PC811 PC904 PC906 PC908-PC911 PC1000 PC1001 PC1042 PC1043 PC1211 PC1212 PC1235 PC1236 PC1251 PC1252 PC1300 PC1303-PC1306 PC1309-PC1312 PC1315 PC1316 PC1343 PC1344 PC1356 PC1358 PC1382 PC1388 PC1393 PC1505 PC1509 PC1526-PC1528 = C_0805
CV156 CV158-CV167 CV169 = C_0402: room: EDP
CV157 CV168 = C_0603: room: EDP
CV170-CV177 = C_0201: room: HDMI
CV178 CV180-CV182 = C_0402: room: HDMI
CV179 = C_0603: room: HDMI
CV183 CV184 = C_0402: room: CAMERA
CZ4 CZ6 CZ8 CZ9 CZ11 CZ12 = C_0603: room: 3V_5V_DC_DC
CZ18-CZ20 = C_0402: room: PCH_DC_DC
CZ26 CZ29 CZ31 = C_0402: room: CAMERA_CR_DC_DC
CZ28 = C_0402: room: CPU_DC_DC
CZ37 CZ39 = C_0603: room: HDD_DC_DC
CZ41 CZ43 CZ44 = C_0402: room: EDP_DC_DC
CZ45 CZ46 = C_0402: room: HDD_DC_DC
D2 = ESD3V3S1B-02LS_PG-TSSLP-2-1-2
D122 = BAS40-04_SOT23-3: room: RTC
D123-D126 = ESD8011MUT5G_X3DFN2-2
DA2-DA5 DA9 = AZ5123-01FPR7G_DFN1006P2X2
DA7 DA14 DA55 DA56 DE11 DH1 DT28 DT29 DV14 DV15 = RB751S40T1G_SOD523-2
DE2 = AZ5125-02SPR7G_SOT23-3: room: PWR LED
DE4 DE5 = PESD5V0U2BT_SOT23-3: room: TOUCH PAD
DE7 DE8 = RB751S40T1G_SOD523-2: room: FAN
DE9 PD101 PD102 = TVNST52302AB0_SOT523-3
DI1 = RB751S40T1G_SOD523-2: room: EDP
DI3 = AZ5125-02SPR7G_SOT23-3: room: EDP
DI7 = AZ1045-04F_DFN2510P10E-10-9: room: USB1
DI9 = AZ1045-04F_DFN2510P10E-10-9: room: USB2
DI11 = RB751S40T1G_SOD523-2: room: USB2
DI12 DV13 DV16 DZ1 = BAT54CW-7-F_SOT323-3
DI13 = AZC199-02SPR7G_SOT23-3
DL1 = AZ5125-02SPR7G_SOT23-3: room: BATTERY LED
DN1 DN2 = RB751S40T1G_SOD523-2: room: NGFF WLAN
DN3 = BAT54CW-7-F_SOT323-3: room: NGFF WLAN
DT10 = PESD24VS2UT_SOT23-3
DT12-DT27 = ESD108-B1-CSP0201_WLL-2-1-2
DV1 DV2 = BAT54CW-7-F_SOT323-3: room: EDP
DV4 DV5 = AZ1045-04F_DFN2510P10E-10-9: room: HDMI
DV7 = BAT54CW-7-F_SOT323-3: room: EDP_DC_DC
DV12 = IP4223CZ6_SO6-6
F1 PR307 PR320 PR411 PR412 PR503 PR600 PR603 PR708 PR803 PR904 PR1010 PR1012 PR1015 PR1202 PR1206 PR1210 PR1301 PR1305 PR1309 PR1401 PR1510 PR1513 PR1805 RA2 RA18 RA74 RT114 RT1092 RV597 RV658 RV659 RV1056 RV1057 RV1067 RV1068 RV1078 RV1079 RZ1134-RZ1139 = R_0603
FD1-FD4 = FIDUCIAL_C40M80: room: ETY-ROOM
H1 H2 = H_2P3: room: ETY-ROOM
H5 H45 H46 = H_3P9
H9 H10 = H_2P5: room: ETY-ROOM
H11 = H_2P1N: room: ETY-ROOM
H12 = H_6P0N: room: ETY-ROOM
H13 H16 = H_3P9: room: ETY-ROOM
H17 = H_2P1X2P5N: room: ETY-ROOM
H18-H25 = EMIST_SUL-12A2M_1P: room: ETY-ROOM
H26 H28 H30-H35 H52 H53 H56-H58 = EMIST_SUL-12A2M_1P
H37 H38 = H_3P2
H39 H40 = H_2P5
H41 H42 = H_2P8
H43 H49 = H_2P3
H47 = H_6P0N
H48 = H_4P2
H50 = CLIP_C6-NPM
H51 = CLIP_C5P5
H54 H55 = CLIP_C5P5-NPM
H59 = H_2P9X2P1N
JAPS = ACES_50506-01841-P01_18P: room: CPU
JAUDIO = ACES_88028-3010M_30P
JCR = T-SOL_156-1051902601_19P-T: room: CARD READER
JDEG1 JLPDE1 = HB_A531015-SCHR21_10P: room: EC5085
JDIMM1 = BELLW_SD-80886-1021_260P-T: room: DIMMA
JDIMM2 = BELLW_SD-80886-1021_260P-T: room: DIMMB
JEDP1 = ACES_59003-04006-001_40P: room: EDP
JFAN1 JFAN2 = ACES_50224-00401-001_4P: room: FAN
JFP = JXT_FP241AH-006GAAM_6P
JHDD = J-L_UCNR2234B020-0_20P: room: HDD
JHDMI1 = ACON_HMRB9-AK120C_19P: room: HDMI
JHP1 = YUQIU_PJ567-F07J1BE-C_6P
JKB = E-T_6710K-Y15M-31L_15P: room: ETY-ROOM
JNGFF1 = CONCR_213AAAA32FA_67P: room: NGFF WLAN
JNGFF2 = CONCR_213MAAA32FA_67P-T: room: NGFF SSD
JRTC = E-T_3806K-F02N-03R_2P: room: RTC
JSPI1 = E-T_6705K-Y20N-00L_20P
JTAG1 = SHORTPADS: User Part Number: PART#; room: EC5085
JTP = ACES_51524-0080N-001_8P: room: TOUCH PAD
JTS = ACES_50208-00601-P01_6P
JUART = ACES_50207-00471-P01_4P-T
JUSB1 = TAIWI_USB019-107CRL-TWD_10P-T: room: USB1
JUSB2 = TAIWI_USB019-107CRL-TWD_10P-T: room: USB2
JUSBC1 = JAE_DX07S024XJ2_24P-T: room: THUNBERBOLT
JXDP = SAMTE_BSH-030-01-L-D-A_60P: room: CPU
LA1 LA3 = MURAT_BLM15PX600SN1D_2P
LA2 = MURAT_BLM21PG600SN1D_L0805_2P
LA4 = MURAT_BLM15BB220SN1D_2P
LA5-LA8 = MURAT_BLM15AX700SN1D_2P
LED1-LED5 = LED_LTW-270TLA_2P: room: BATTERY LED
LED6 = LED_HT-F196BP5_2P
LH1 LH2 = MURAT_BLM15PX221SN1D_2P
LI1 = INPAQ_MCM1012B900F06BP_4P: room: EDP
LI2 = INPAQ_MCM1012B900F06BP_4P: room: USB2
LI5 = INPAQ_MCM1012B900F06BP_4P: room: USB1
LN1 = INPAQ_MCM1012B900F06BP_4P: room: NGFF WLAN
LT1 = COILC_XFL4012-601MEC_2P: room: THUNBERBOLT
LT11 PL105-PL108 PL200-PL203 PL300 PL301 PL402 PL403 PL500 PL601 PL700 PL800 PL900 PL1000 PL1001 PL1203 PL1204 PL1303-PL1305 PL1444 PL1501 PL1502 = TAI-T_HCB2012KF-121T50_2P
LT12 LT13 = CHILI_CMMI21T-900Y-N_4P
LT14 LV23 LV26 = CHILI_PBY160808T-300Y-N_2P
LV22 = INPAQ_MCM1012B900F06BP_4P: room: CAMERA
LV24 = KC_FBMA-L11-160808300LMA25T_2P
ML17 = INPAQ_HCM2012GA900AE_4P
PC312 PC420 PC1210 PC1256 = C_D
PC317 PC318 PC324 PC326 = C_0906
PC412 PC413 PC456 PC1019-PC1021 PC1529 PC1530 = C_B2
PC608 = C_D1
PC1207 PC1208 PC1301 PC1307 = C_D2
PC1262 PC1397 = C_EEFSS0D221R
PD100 = AZ5125-01HPR7G_SOD523-2
PD202 PD203 PD211 PD302-PD304 = SDMK0340L-7-F_SOD323-2
PD301 = SX34H_SMA2
PH1100-PH1104 PR100-PR106 PR108 PR111 PR112 PR200-PR203 PR205 PR206 PR209 PR213 PR217 PR219 PR220 PR222-PR232 PR234 PR235 PR240 PR243 PR251-PR255 PR257-PR261 PR263-PR265 PR267 PR268 PR270-PR273 PR275-PR279 PR281-PR283 PR290 PR301-PR303 PR305 PR308 PR311 PR315 PR316 PR318 PR319 PR321 PR323 PR325-PR327 PR399 PR401-PR406 PR410 PR428 PR501 PR504 PR508 PR510 PR512 PR601 PR604 PR605 PR607 PR609 PR610 PR701-PR704 PR707 PR722 PR724 PR725 PR729 PR755 PR801 PR804 PR806 PR808-PR813 PR902 PR905-PR910 PR986-PR988 PR1000-PR1002 PR1004-PR1008 PR1011 PR1013 PR1014 PR1016 PR1019 PR1022 PR1023 PR1100 PR1101 PR1103-PR1117 PR1120-PR1131 PR1133-PR1145 PR1201 PR1203 PR1205 PR1207 PR1209 PR1211-PR1217 PR1224-PR1226 PR1302-PR1304 PR1306 PR1311 PR1318-PR1321 PR1400 PR1402-PR1405 PR1500-PR1502 PR1505 PR1507-PR1509 PR1511 PR1514-PR1516 PR1519 PR1521 PR1800 PR1803 PR1804 R1054 RA19-RA21 RA27-RA31 RA51 RA52 RA73 RA75 RA79 RA80 RA93-RA95 RA100 RA101 RD59 RD100 RE94-RE96 RE99-RE101 RE110 RE111 RE113-RE115 RE125 RE126 RE128 RE134 RE136 RE137 RE140 RE142-RE144 RF5 RH539 RH544-RH558 RH561-RH573 RH587-RH590 RI26-RI28 RI30 RI31 RI34 RI35 RI46 RL1-RL5 RT183 RT189 RT191 RT194 RT199 RT242 RT246 RT429 RT1093-RT1095 RT1133 RV8 RV11 RV12 RV47 RV103 RV108 RV111 RV112 RV181 RV325 RV326 RV512-RV519 RV530-RV541 RV545 RV546 RV548-RV554 RV557 RV562-RV564 RV566 RV567 RV570-RV583 RV585 RV587-RV594 RV600-RV602 RV605-RV608 RV613-RV657 RV1072-RV1074 RV1077 RV1080-RV1084 RV1086 RV1088 RV1090 RV1091 RV1108-RV1112 RV1114 RV1128-RV1133 RV1140 RV1522 RV1806-RV1811 RZ71 RZ72 RZ74 RZ75 RZ80 RZ82 RZ84-RZ89 RZ106 RZ1133 RZ1140 = R_0402
PJ1400 PJ1401 PJP602 PJP700 = JUMP_43X79
PJP300 PJP601 = JUMP_43X39
PJP400 PJP402 PJP403 PJP500 PJP600 PJP603 PJP701 PJP702 PJP800 PJP900 PJP1200 PJP1300 PJP1301 = JUMP_43X118
PJP1205 = JUMP_43X39: room: EC5085
PJP1206 = JUMP_43X39: room: EC23017
PJP1302 PJP1303 = JUMP_43X39: room: PCH
PL104 = MURAT_BLM15AG102SN1D_2P
PL302 = TAI-T_VMPI1004AR-3R3M-Z01_2P
PL400 = CYNTE_PCMB063T-3R3MS_2P
PL401 = CYNTE_PCMC063T-1R5MN_2P
PL501 PL801 PL901 = CYNTE_PCMB053T-1R0MS_2P
PL600 = CYNTE_PCMB063T-1R0MS_2P
PL701 = MAG_MMD-06CZ-R47M-V1_2P
PL1002 PL1003 PL1200-PL1202 PL1300 PL1301 PL1500 = MAG_MMD-06DZIR22MEM2L_2P
PL1306 = MAG_MMD05CZR47M_4P
PL1400 = TOKO_1239AS-H-1R0M-P2_2P
PQ100 = FDV301N-G_SOT23-3
PQ101 QE15 = MMBT3904WH_SOT323-3
PQ200 PQ201 PQ212-PQ214 PQ303 = AON7409_DFN8-5
PQ204 PQ216 PQ217 = NTR4502PT1G_SOT23-3
PQ205 PQ206 PQ208 PQ211 PQ218-PQ220 PQ222 PQ223 PQ225 PQ228-PQ233 PQ304 QT11 QT12 = SSM3K7002FU_SC70-3
PQ221 PQ224 = AO3413_SOT23-3
PQ300 PQ301 = SIR472DP-T1-GE3_POWERPAK8-5
PQ302 = SIRA06DP-T1-GE_POWERPAKSO-8-5
PQ400 = MDV1528URH_PDFN33-8-5
PQ401 = MDU1516URH_POWERDFN56-8-5
PQ402 = MDV1524URH_PDFN33-8-5
PQ403 = MDU1512RH_POWERDFN56-8-5
PQ600 = AON7406L_DFN8-5
PQ601 = AON7516_DFN8-5
PQ700 = RJU003N03_UMT3
PQ1300 = AON7934_DFN3X3A8-10
PR300 = R_1206_4P-D
PR304 PR313 PR413 PR414 PR502 PR602 PR705 PR802 PR903 PR1009 PR1020 PR1200 PR1204 PR1208 PR1300 PR1307 PR1308 PR1512 RV1075 RV1076 = R_1206
PR306 PR309 PR312 PR314 PR317 PR322 PR324 PR400 PR407-PR409 PR415 PR500 PR606 PR608 PR700 PR706 PR728 PR730 PR800 PR1003 PR1017 PR1018 PR1021 PR1102 PR1118 PR1119 PR1132 PR1503 PR1517 PR1518 PR1520 PR1801 RD58 RE102 RE103 RE107-RE109 RE112 RE116-RE120 RE122 RE129 RE133 RE138 RE139 RH540-RH543 RH576-RH581 RH586 RI32 RI33 RI36-RI44 RT176-RT178 RT181 RT182 RT184 RT185 RT190 RT195 RT200 RT201 RT240 RT243 RT244 RV520-RV529 RV547 RZ76 RZ81 RZ90 RZ91 = R0402_0OHM
PR310 = RL-3264-9W-R005-FNH_2512_2512
PR1218-PR1223 PR1312-PR1315 = R0402_0OHM-NPM
PU202 = LM393DMR2G_MICRO8
PU203 = RT9069-33GB_SOT23-5
PU204 UV19 UV28 UZ18 UZ20-UZ23 = MC74VHC1G08DFT2G_SC70-5
PU300 = BQ24777RUYR_WQFN28_4X4
PU400 = TPS51285BRUKR_QFN20_3X3
PU500 PU800 PU900 = SYX196DQNC_QFN10_3X3
PU600 = G5616ARZ1U_TQFN20_3X3
PU700 = TPS53353DQPR_QFN22_5X6
PU1000 PU1002 PU1502 = CSD86360Q5D_SON8-7
PU1001 PU1501 = RT8816AGQW_WQFN20_3X3
PU1100 = ISL95829AHRTZ-T_TQFN48_6X6
PU1200-PU1202 PU1300 PU1301 = AOZ5029QI_QFN24_5X3P5
PU1302 = ISL95808HRZ-TS2378_DFN8_2X2
PU1400 = G5719CRC1U_TDFN8_2X2-S
PU1800 = RT9059GQW_WDFN10_3X3
QE2 = DMN65D8LDW-7_SOT363-6: room: TOUCH PAD
QE4 = DMN65D8LDW-7_SOT363-6: room: EC5085
QE5 = MMBT3904WH_SOT323-3-S: room: THERMAL
QE6-QE12 = MMBT3904WH_SOT323-3: room: THERMAL
QE13 = L2N7002WT1G_SC-70-3: room: TOUCH PAD
QE18 QE19 QT20 QV3 QV104 QZ14-QZ17 = DMN65D8LDW-7_SOT363-6
QF1 = DMN65D8LDW-7_SOT363-6: room: HDD FFS
QH4 = DMN65D8LDW-7_SOT363-6: room: PCH
QI10 QR1 QR104 QV87 QV89 QZ18 = L2N7002WT1G_SC-70-3
QV9 QV12 = L2N7002WT1G_SC-70-3: room: EDP
QV11 = SI3457BDV-T1-E3_TSOP6: room: EDP
QV13 QV14 = L2N7002WT1G_SC-70-3: room: HDMI
QV21 = DMN63D8LDW-7_SOT363-6
QV86 QZ9 = DMG2301U-7_SOT23-3
QV91 QV95 QV96 QV98 QV101-QV103 = 2N7002W-T-R7_SOT323-3
QX1 = DMN65D8LDW-7_SOT363-6: room: HDMI
QZ6 QZ7 = DMN65D8LDW-7_SOT363-6: room: GPU
RA4 RA6 RA7 RA12-RA17 RA57 RA68 RA77 RA82 RA96-RA99 RT164 RT167-RT171 RT186-RT188 RT202 RT207-RT213 RT226-RT233 RT245 RT430-RT437 RV1095-RV1107 RV1118-RV1124 = R_0201
RA78 RA83 RA84 RE93 RE104 RE105 RE121 RE141 RH582-RH585 RN34 RT113 RT241 = R0603_0OHM
RD1-RD3 RD35 = R_0402: room: DIMMA
RD4 RD6 RD39 = R_0402: room: DIMMB
RD5 RD38 RD40 = R0402_0OHM: room: DIMMB
RD7-RD10 = R_0402: room: NGFF SSD
RD28-RD31 = R0402_0OHM: room: DIMMA
RE3 = R_0402: room: PWR LED
RE7 RE9 RE87 = R_0402: room: TOUCH PAD
RE11 RE13 RE14 RE77 RE85 RE86 = R_0402: room: TPM
RE15 = R_0402: room: LID
RE16 RE37 RE39 RE51 = R0402_0OHM: room: EC5085
RE17-RE27 RE30-RE36 RE38 RE41 RE43-RE45 RE48 RE50 RE52 RE54-RE56 RE59-RE65 RE67 RE68 RE70 RE89 RE90 = R_0402: room: EC5085
RE57 RE58 RE66 RE69 = R_0402: room: THERMAL
RE71-RE76 = R_0402: room: EC23017
RE81-RE84 = R_0402: room: FAN
RF1 = R0603_0OHM: room: HDD FFS
RF2-RF4 = R_0402: room: HDD FFS
RH2 RH5 RH6 RH24 RH30 RH57-RH59 RH95 RH97 RH98 RH100 RH145 RH148-RH156 RH158 RH163-RH167 RH183-RH189 RH191 RH192 RH197 RH201 RH203 RH206 RH207 RH209-RH212 RH456 RH466 RH469 RH472 RH474 RH475 RH479-RH485 RH488-RH490 RH492-RH498 RH519 RH525 RH530 RZ50 RZ59 RZ61 = R_0402: room: CPU
RH8 RH12 RH190 RH198 RH202 RH204 RH465 RH470 RH471 RH473 RH477 RH478 RH491 RZ58 RZ60 = R0402_0OHM: room: CPU
RH67 = R_0402: room: RTC
RH70 RH71 RH74 RH75 RH77 RH78 RH82-RH85 RH88 RH91 RH108-RH111 RH119 RH120 RH130 RH146 RH147 RH168 RH196 RH383 RH401 RH423-RH425 RH428 RH453-RH455 RH458-RH463 RH501-RH506 RH508 RH510-RH513 RH515 RH516 RH518 RH520-RH524 RH527-RH529 RH531 RH533 RH535-RH538 = R_0402: room: PCH
RH72 = R_0201: room: PCH
RH96 RH133 RH309 RH487 = R0402_0OHM: room: PCH
RH136 RH137 = R0603_0OHM: room: PCH
RI4-RI8 = R_0402: room: USB1
RI9-RI13 RI15-RI24 = R_0402: room: USB2
RI14 = R_0805: room: USB2
RI25 = R0402_0OHM: room: USB2
RI45 RV511 RZ92 = R_0805
RN1 RN33 = R_0402: room: NGFF WLAN
RP1 RP2 RP4 RP8 RP15 RP22 RP23 = RP_0804_8P4R: room: PCH
RP19 RP20 = RP_0804_8P4R: room: EC5085
RP24 = RP_1206_10P8R: room: BATTERY LED
RR1 RR6 RR9 = R_0402: room: CARD READER
RR2-RR5 RR7 RR8 RR10 = R0402_0OHM: room: CARD READER
RT1 RT2 RT5 RT10 = R_0402: room: THUNBERBOLT
RT3 RT4 RT6-RT9 RT12 RT15-RT18 RT21-RT23 RT25 RT33-RT45 RT107 = R_0201: room: THUNBERBOLT
RT46 = R_0603: room: THUNBERBOLT
RT165 RZ70 = R0805_0OHM
RV107 RV109 RV114 RV119 RV120 RV135 = R_0402: room: EDP
RV110 RV113 = R0402_0OHM: room: EDP
RV121-RV125 = R_0402: room: HDMI
RV399 = R_0402: room: GPU
RZ13 RZ15 = R0603_0OHM: room: 3V_5V_DC_DC
RZ18 = R0603_0OHM: room: PCH_DC_DC
RZ26 RZ28 = R0603_0OHM: room: CAMERA_CR_DC_DC
RZ32 = R_0402: room: CAMERA_CR_DC_DC
RZ34 RZ36 = R0805_0OHM: room: HDD_DC_DC
RZ35 RZ37 = R0603_0OHM: room: EDP_DC_DC
RZ38-RZ40 = R_0402: room: EDP_DC_DC
RZ41 = R_0402: room: PCH_DC_DC
RZ43 = R_0402: room: AUDIO_DC_DC
RZ46 = R_0402: room: HDD_DC_DC
RZ48 RZ67 = R0603_0OHM: room: CPU
RZ66 = R0603_0OHM: room: CPU_DC_DC
SW1 = SW_SKRBAAE010_4P: room: PWR LED
SW2 = SW_NTC311-EA1T-A160T_4P: room: BATTERY LED
SW4 = SW_SSAL120100_3P: room: PCH
T2 T4 T8 T17 T18 T20 T91 T92 T94 T104-T108 T120-T124 T127 = TPC12: room: PCH
T39-T53 T57-T71 T73-T90 = TPC12: room: CPU
T182 T185 T187 T191-T205 T208-T210 TV3-TV6 = TPC12
UA1 = ALC3266-CG_QFN56_7X7
UA3 = G9090-180T11U_SOT23-5
UA4 = EM5209VF_DFN14_3X2
UC1 = 74AUP1G07GW_TSSOP5: room: CPU
UD2 = NL17SZ14DFT2G_SOT353-5: room: NGFF SSD
UE1 = NPCT650JAAYX_QFN32_5X5: room: TPM
UE2 = AH1806-W-7_SC59-3-S: room: LID
UE3 = MEC5085-LZY_DQFN132_11X11: room: EC5085
UE4 = MCP23017T-E-ML_QFN28_6X6: room: EC23017
UE6 = APE8937GN2_DFN8_2X2: room: TOUCH PAD
UF1 = LNG3DMTR_LGA16_3X3: room: HDD FFS
UH1 = SKL-H_BGA_1440P-T: room: CPU
UH2 = SKY-S-PCH_BGA_837P-T: room: PCH
UH7 UH14 = MC74VHC1G08DFT2G_SC70-5: room: PCH
UH8 = W25Q256FVEIG_WSON8: room: PCH
UI1 = TPS2546RTER_QFN16_3X3: room: USB1
UI2 = TPS2546RTER_QFN16_3X3: room: USB2
UI3 = PS8713BTQFN24GTR2_TQFN24_4X4: room: USB2
UI4 UI5 = MC74VHC1G32DFT2G_SC70-5
UN3 = APE8937GN2_DFN8_2X2: room: NGFF WLAN
UR1 = RTS5242-GR_QFN32_4X4: room: CARD READER
UT1 = ALPINE-RIDGE_BGA_337P: room: THUNBERBOLT
UT2 = W25Q80DVSSIG_SO8
UT3 UZ24 = APE8937GN2_DFN8_2X2
UT4 = TPS65982_BGA_96P
UT5 = W25Q32FVSSIQ_SO8: room: THUNBERBOLT
UV16 = AP2330W-7_SC59-3: room: HDMI
UV17 = PCA9515BDGKR_VSSOP8
UV18 = N15P-GT_BGA_908P
UV20 UV21 = TC7SH08FU_SSOP5
UV23-UV26 = H5GQ1H24AFR-T2L_BGA_170P
UZ1 = EM5209VF_DFN14_3X2: room: 3V_5V_DC_DC
UZ4 = APE8937GN2_DFN8_2X2: room: PCH_DC_DC
UZ5 = APE8937GN2_DFN8_2X2: room: CAMERA_CR_DC_DC
UZ7 = EM5209VF_DFN14_3X2: room: HDD_DC_DC
UZ8 = SY6288C20AAC_SOT23-5: room: EDP_DC_DC
UZ9 = TPS22961DNYR_WSON8: room: CPU
UZ11 UZ12 = MC74VHC1G08DFT2G_SC70-5: room: CPU
UZ15 = TPS22961DNYR_WSON8: room: CPU_DC_DC
UZ16 = APE8937GN2_DFN8_2X2: room: CPU
UZ19 = MC74VHC1G09DFT2G_SC70-5
YE1 = Y_CM7V-12520_2P: room: EC5085
YH1 = Y_CM31532768DZFT_2P: room: PCH
YH2 = Y_X3G024000DC1H_4P: room: PCH
YT1 = Y_7V25000014_4P: room: THUNBERBOLT
YV1 = Y_7V27000011_4P: room: GPU

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
2N7002W-T-R7_SOT323-3
  oval 0.813x0.914 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
74AUP1G07GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
ACES_50207-00471-P01_4P-T
  oval 0.508x0.991 smd: 1(0,0) 2(-0.8,0) 3(-1.6,0) 4(-2.4,0)
  rect 1.194x1.702 smd: 5(-3.7,1.45) 6(1.3,1.45)
ACES_50208-00601-P01_6P
  oval 0.508x0.991 smd: 1(0,0) 2(-0.8,0) 3(-1.6,0) 4(-2.4,0) 5(-3.2,0) 6(-4,0)
  rect 1.194x1.702 smd: 7(-5.3,-1.95) 8(1.3,-1.95)
ACES_50224-00401-001_4P
  oval 0.61x1.549 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0)
  rect 1.194x1.803 smd: 5(4.3,-3.875) 6(-1.3,-3.875)
ACES_50290-00701-001_7P-T
  rect 0.838x7.01 smd: 1(0,0) 2(1.5,0) 3(3,0) 4(4.5,0) 5(6,0) 6(7.5,0) 7(9,0)
ACES_50290-01201-P01_12P-T
  rect 0.838x7.01 smd: 1(0,0) 2(1.5,0) 3(3,0) 4(4.5,0) 5(6,0) 6(7.5,0) 7(9,0) 8(10.5,0) 9(12,0) 10(13.5,0) 11(15,0) 12(16.5,0)
ACES_50506-01841-P01_18P
  oval 0.305x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0)
  rect 0.991x2.007 smd: 19(-2.1,-3.05) 20(10.6,-3.05)
ACES_51524-0080N-001_8P
  oval 0.61x1.295 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0) 5(4,0) 6(5,0) 7(6,0) 8(7,0)
  rect 2.489x2.21 smd: 9(10,-3.05) 10(-3,-3.05)
ACES_59003-04006-001_40P
  round 0.889 hole 0.889 unplated: (-20.25,2.125) (0.75,2.125)
  oval 0.254x1.143 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0) 5(-2,0) 6(-2.5,0) 7(-3,0) 8(-3.5,0) 9(-4,0) 10(-4.5,0) 11(-5,0) 12(-5.5,0) 13(-6,0) 14(-6.5,0) 15(-7,0) 16(-7.5,0) 17(-8,0) 18(-8.5,0) 19(-9,0) 20(-9.5,0) 21(-10,0) 22(-10.5,0) 23(-11,0) 24(-11.5,0) 25(-12,0) 26(-12.5,0) 27(-13,0) 28(-13.5,0) 29(-14,0) 30(-14.5,0) 31(-15,0) 32(-15.5,0) 33(-16,0) 34(-16.5,0) 35(-17,0) 36(-17.5,0) 37(-18,0) 38(-18.5,0) 39(-19,0) 40(-19.5,0)
  rect 1.499x2.997 smd: 41(-22,2.125) 42(2.5,2.125)
  rect 2.794x1.499 smd: 43(-15.45,4.175) 44(-4.05,4.175)
ACES_88028-3010M_30P
  oval 0.508x1.6 smd: 1(0,0) 2(0,-5.8) 3(0.8,0) 4(0.8,-5.8) 5(1.6,0) 6(1.6,-5.8) 7(2.4,0) 8(2.4,-5.8) 9(3.2,0) 10(3.2,-5.8) 11(4,0) 12(4,-5.8) 13(4.8,0) 14(4.8,-5.8) 15(5.6,0) 16(5.6,-5.8) 17(6.4,0) 18(6.4,-5.8) 19(7.2,0) 20(7.2,-5.8) 21(8,0) 22(8,-5.8) 23(8.8,0) 24(8.8,-5.8) 25(9.6,0) 26(9.6,-5.8) 27(10.4,0) 28(10.4,-5.8) 29(11.2,0) 30(11.2,-5.8)
  custom 0.375x0.375 smd: 31(-2.1,0) 32(13.3,0)
  rect 1.803x1.499 smd: 33(-2.1,-5.8) 34(13.3,-5.8)
  custom 0.451x0.451 smd: 35(-2.1,-2.9) 36(13.3,-2.9)
  round 1.245 hole 0.838: 37(-2,-1.2) 38(13.2,-1.2)
ACON_HMRB9-AK120C_19P
  round 0.762 hole 0.508: 1(0,0) 2(-0.5,-1.2) 3(-1,0) 4(-1.5,-1.2) 5(-2,0) 6(-2.5,-1.2) 7(-3,0) 8(-3.5,-1.2) 9(-4,0) 10(-4.5,-1.2) 11(-5,0) 12(-5.5,-1.2) 13(-6,0) 14(-6.5,-1.2) 15(-7,0) 16(-7.5,-1.2) 17(-8,0) 18(-8.5,-1.2) 19(-9,0)
  oval 1.6x2.311 hole 0.991x1.702: 20(-11.75,0) 21(-13.5,-7.57) 22(4.5,-7.57) 23(2.75,0)
AH1806-W-7_SC59-3-S
  oval 0.787x1.245 smd: 1(0,0) 2(-0.95,-2.654) 3(0.95,-2.654)
ALC3266-CG_QFN56_7X7
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 13(0,-4.8) 14(0,-5.2) 29(7.1,-5.2) 30(7.1,-4.8) 31(7.1,-4.4) 32(7.1,-4) 33(7.1,-3.6) 34(7.1,-3.2) 35(7.1,-2.8) 36(7.1,-2.4) 37(7.1,-2) 38(7.1,-1.6) 39(7.1,-1.2) 40(7.1,-0.8) 41(7.1,-0.4) 42(7.1,0)
  oval 0.203x0.889 smd: 15(0.95,-6.15) 16(1.35,-6.15) 17(1.75,-6.15) 18(2.15,-6.15) 19(2.55,-6.15) 20(2.95,-6.15) 21(3.35,-6.15) 22(3.75,-6.15) 23(4.15,-6.15) 24(4.55,-6.15) 25(4.95,-6.15) 26(5.35,-6.15) 27(5.75,-6.15) 28(6.15,-6.15) 43(6.15,0.95) 44(5.75,0.95) 45(5.35,0.95) 46(4.95,0.95) 47(4.55,0.95) 48(4.15,0.95) 49(3.75,0.95) 50(3.35,0.95) 51(2.95,0.95) 52(2.55,0.95) 53(2.15,0.95) 54(1.75,0.95) 55(1.35,0.95) 56(0.95,0.95)
  rect 4.597x4.597 smd: 57(3.55,-2.6)
