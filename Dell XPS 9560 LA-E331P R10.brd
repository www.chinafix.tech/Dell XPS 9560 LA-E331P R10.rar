# Allegro board Dell XPS 9560 LA-E331P R10.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
NC_B4: length 2.5
  BOTTOM w0.089: 20.58,44.97 20.79,44.97 20.98,44.78 21.15,44.78 21.36,44.57 22.14,44.57 22.36,44.35 UT1.B4
  BOTTOM w0.14: 20.58,44.97 RT207.2
NC_B5: length 2.5
  BOTTOM w0.089: UT1.B5 22.21,43.67 21.74,43.67 21.31,43.24 20.58,43.24
  BOTTOM w0.14: RT208.2 20.28,43.24 20.58,43.24
NC_G2: length 2.6
  BOTTOM w0.089: 25.39,47.13 25.39,47.04 25.63,46.81 25.63,46.53 25.25,46.15 25.21,46.15 24.97,45.91 24.97,45.51 UT1.G2
  BOTTOM w0.14: RT209.2 25.39,47.13
NGFF_ON: length 5.1
  TOP w0.14: UN3.3 339.34,101.92 339.35,101.93 ; 339.35,101.93 339.35,101.56 339.71,101.2 RN33.2 ; 339.35,101.93 v1(339.35,102.52) 339.35,103.59 339.28,103.66 DN3.1
NGFF_PWREN: length 391.4
  TOP w0.089: v2(86.91,1.52) 86.56,1.88 86.25,1.88 85.66,2.46 85.66,3.19 85.45,3.39 83.17,3.39 82.87,3.69 82.87,4.77 83.1,5 83.1,6.01 83.35,6.26 83.35,6.79 83.64,7.08 83.64,7.35 83.74,7.45 83.74,7.73 83.64,7.83 83.64,8.32 83.11,8.85 81.46,8.85 81.13,9.18 81.13,9.56 80.9,9.79 79.89,9.79 79.86,9.76 78.23,9.76 77.24,8.77 76.28,8.77 RH520.2
  TOP w0.14: v2(344.74,106.24) 344.3,106.24 343.79,105.74 v1(339.85,105.74) 339.28,106.31 337.82,106.31 337.38,105.87 DN3.2
  IN6 w0.089: 98.46,1.41 100.69,3.63 101.98,3.63 ; 87.03,1.41 86.92,1.53 86.92,1.52 v2(86.91,1.52)
  IN6 w0.099: v2(344.74,106.24) 344.74,105.16 345.33,104.58 345.33,89.04 340.83,84.54 338.98,84.54 334.96,80.53 334.96,65.6 337.12,63.45 337.12,57.61 332.29,52.78 332.29,49.35 330.01,47.06 330.01,42.19 328.04,40.22 328.04,32.46 324.96,29.37 324.96,26.84 320.28,22.17 320.28,10.06 316.31,6.08 307.98,6.08 306.36,4.46 304.55,4.46 304.2,4.11 301.94,4.11 301.9,4.15 295.88,4.15 295.84,4.11 295.69,3.96 290.83,3.96 290.32,3.45 274.15,3.45 272.27,5.34 268.15,5.34 267.51,5.98 262.97,5.98 262.19,5.19 245.56,5.19 244.76,4.4 243.63,4.4 242.93,3.69 240.41,3.69 239.63,4.48 227.8,4.48 226.61,5.66 213.74,5.66 210.6,8.8 206,8.8 205.38,8.18 202.76,8.18 201.76,7.18 180.05,7.18 179.08,6.21 176.26,6.21 174.66,4.61 169.64,4.61 167.5,2.47 151.21,2.47 150.16,1.42 140.1,1.42 137.46,4.06 134.54,4.06 132.61,5.99 130.31,5.99 129.71,6.59 126.88,6.59 126.79,6.67 120.9,6.67 117.19,2.96 109.24,2.96 108.68,2.4 106.28,2.4 105.05,3.63 101.98,3.63 ; 98.46,1.41 98.38,1.32 87.12,1.32 87.03,1.41
  BOTTOM w0.089: UH2.BC27 86.11,4.97 86.11,4.35 85.97,4.21 85.97,3.77 85.88,3.68 85.88,3.27 86,3.14 86,2.13 86.23,1.9 86.56,1.9 86.91,1.55 v2(86.91,1.52)
NRB_BIT: length 8.7
  TOP w0.089: RH524.2 82.58,2.38 83.24,2.38 83.8,2.94 v1(83.96,2.94) 84.14,3.12 85.26,3.12 85.48,2.9 85.48,2.39 v2(86.36,1.51)
  BOTTOM w0.089: UH2.BD28 85.86,4.39 85.79,4.32 85.79,3.85 85.7,3.76 85.7,3.19 85.82,3.07 85.82,2.06 86.36,1.53 v2(86.36,1.51)
NVVDD_EN: length 8.6
  TOP w0.254: QZ15.5 164.43,116.61 164.96,116.07 CV919.1 RV1130.1 165.76,114.52 v2(165.79,114.49) 165.86,114.49 PC1015.1 166.55,113.15 v1(166.18,112.78) 165.45,112.05 DA56.1
  BOTTOM w0.203: PU1001.3 165.85,114.44 v2(165.79,114.49) 165.74,114.44 PR1004.1
NVVDD_PGOOD: length 5.8
  TOP w0.14: v1(171.06,112.29) 171.79,113.02 171.79,113.97 PR1017.1
  TOP w0.254: PR1017.1 171.32,114.44 v2(170.96,114.44)
  BOTTOM w0.203: v2(170.96,114.44) PU1001.13
  BOTTOM w0.254: PR1019.1 171.89,113.55 171,114.44 v2(170.96,114.44)
NVVDD_PWM_VID: length 130
  TOP w0.14: v1(231.18,43.75) 231.1,43.67 v2(231.1,43.16) 231.12,43.15 231.12,42.35 230.95,42.19 RV1122.2
  IN2 w0.099: v2(231.1,43.16) 230.69,43.58 228.2,43.58 228.05,43.43 221.59,43.43 220.96,44.07 218.97,44.07 218.66,43.75 216.14,43.75 215.83,44.05 213.18,44.05 212.69,44.54 211.79,44.54 210.73,45.6 209.46,45.6 207.84,47.22 207.84,50.41 207.23,51.03 205.51,51.03 204.74,51.8 204.74,52.44 203.57,53.61 203.2,53.99 202.21,53.99 201.28,54.91 201.28,55.72 199.84,57.17 198.61,57.17 196.51,59.27 196.51,59.97 195.5,60.98 195.47,60.98 194.27,62.19 194.17,62.19 193.51,62.84 193.51,62.94 188,68.45 186.42,68.45 182.8,72.06 182.8,79.22 179.86,82.16 179.86,84.36 178.73,85.49 177.13,85.49 176.47,84.83 176.47,84.74 176.06,84.34 175.64,84.34 174.96,85.02 174.73,85.02 173.89,85.86 171.5,85.86 170.25,87.12 170.25,89.2 169.73,89.72 166.92,89.72 164.44,92.2 164.44,98.82 166.21,100.59 166.21,103.13 165.58,103.77 165.58,108.9 165.07,109.41 165.07,112.27 164.87,112.47 164.87,114.5 164.47,114.91 164.47,115.38 162.59,117.26 v2(162.59,117.42)
  BOTTOM w0.14: PR1003.1 163.87,117.41 163.16,118.12 RV1095.2 162.87,118.18 162.74,118.05 162.74,117.58 v2(162.59,117.42)
NVVDD_VID: length 3.4
  BOTTOM w0.203: PR1003.2 165.34,117.41 v1(165.76,116.99) 166.05,116.7 166.05,115.53 166.34,115.24 PU1001.5
NVVDDS_EN: length 87.6
  TOP w0.254: v2(243.39,107.67) 242.64,107.67 v1(242.49,107.82) 241.9,108.42 PR987.1 ; v2(222.43,118.67) 222.71,118.39 QZ14.2
  TOP w0.381: v2(180.44,112.59) 180.44,112.89 RV1807.1 180.18,113.46 180.62,113.46 180.9,113.74 RV1806.1
  IN5 w0.127: 226.38,114.02 221.54,114.02 219.46,111.93 211.44,111.93 211.21,112.16 204.59,112.16 204.21,111.78 201.73,111.78 200.85,110.91 197.5,110.91 197.09,110.5 194.68,110.5 193.35,109.17 186.23,109.17 184.12,111.27 181.33,111.27 180.44,112.16 v2(180.44,112.59)
  IN5 w0.254: v2(222.43,118.67) 223.08,118.02 223.08,117.32 228.22,112.17 229.5,112.17 229.51,112.16 238.88,112.16 240.08,113.37 242.85,113.37 244.56,111.65 244.56,108.85 v2(243.39,107.67)
  BOTTOM w0.203: PU1501.3 180.92,113.2 180.44,112.72 v2(180.44,112.59)
NVVDDS_PGOOD: length 3.6
  TOP w0.14: v1(181.1,120.46) 181.11,120.45 PR1518.1
  TOP w0.254: PR1518.1 181.11,118.19 v2(180.92,118)
  BOTTOM w0.203: PU1501.13 v2(180.92,118)
NVVDDS_PSI: length 6
  TOP w0.14: PR1500.2 179.38,111.59 v1(180.25,111.59)
  TOP w0.254: v2(179.86,112.59) 179.16,111.9 PR1500.2
  BOTTOM w0.203: v2(179.86,112.59) 179.86,112.76 180.52,113.43 PU1501.4
  BOTTOM w0.254: PR1501.1 PR1502.1 179.26,111.99 v2(179.86,112.59)
NVVDDS_PWM_VID: length 2.9
  BOTTOM w0.14: PR1503.1 176.19,113.42 RV1098.2 175.3,111.95 v1(175.76,111.49)
NVVDDS_VID: length 4.5
  BOTTOM w0.14: PR1503.2 177.56,112.72 177.09,112.25 v1(176.84,112.25)
  BOTTOM w0.203: PR1503.2 180,113.42 180.12,113.55 PU1501.5
P_SYS: length 426.1
  TOP w0.14: v3(104.47,35.72) 104.24,35.49 v2(104.24,34.93) ; UE3.A57 293.12,15.13 292.98,14.98 292.18,14.98 v2(291.91,15.25)
  TOP w0.203: PU1100.1 113.81,108.09 113.55,108.34 113.55,109.17 v2(112.71,110) 112.03,110 PC1100.2 ; PR324.1 61.27,15.63 62.89,17.25 62.89,18.44 v2(63.43,18.98)
  IN2 w0.089: 75.85,26.27 76.27,26.68
  IN2 w0.099: 75.85,26.27 75.62,26.03 75.62,21.21 73.95,19.54 v2(73.95,15.53) ; v2(104.24,34.93) 104.22,34.91 100.92,34.91 98.34,32.33 89.82,32.33 86.01,28.52 81.13,28.52 79.44,26.83 76.42,26.83 76.27,26.68
  IN5 w0.089: 75.06,15.53 75.37,15.53 75.44,15.46 84.22,15.46 84.49,15.73 90.78,15.73 92.17,17.12 101.33,17.12 101.98,16.47
  IN5 w0.099: v2(63.43,18.98) 63.03,19.38 62.69,19.38 62.69,19.38 61.32,19.38 60.54,18.6 60.54,17 62.27,15.27 73.69,15.27 v2(73.95,15.53) 75.06,15.53 ; v2(291.9,11.76) 291.9,11.36 291.27,10.74 290.26,10.74 289.02,11.98 289.02,12.79 288.32,13.49 284.74,13.49 283.68,12.43 281.56,12.43 281.42,12.58 272.14,12.58 272.11,12.55 266.95,12.55 266.05,13.45 253.23,13.45 251.8,14.88 251.8,16.99 249.97,18.82 222.67,18.82 221.38,20.11 221.38,24.01 219.04,26.35 187.1,26.35 186.84,26.61 182.11,26.61 178.65,23.16 178.65,19.21 174.88,15.44 130.57,15.44 130.51,15.5 105.53,15.5 105.37,15.66 102.79,15.66 101.98,16.47
  IN6 w0.099: v2(104.24,34.93) 104.24,37.34 105.14,38.24 108.07,38.24 114.85,45.02 114.85,48.4 115.57,49.12 115.57,54.61 117.54,56.58 117.54,60.96 120.34,63.76 120.34,64.53 121.6,65.79 123.91,65.79 124.51,66.4 124.51,69.34 126.41,71.24 126.41,76.49 128.64,78.73 128.64,83.13 128.32,83.45 126.81,83.45 122.73,87.53 122.73,95.8 121.23,97.29 119.66,97.29 119.19,97.76 116.4,97.76 116.07,98.09 115.49,98.68 113.4,98.68 113.24,98.51 111.85,98.51 109.64,100.72 109.64,102.08 108.76,102.96 108.76,107.45 107.34,108.87 107.34,109.71 107.58,109.96 112.1,109.96 112.15,110 v2(112.71,110)
  BOTTOM w0.14: v2(291.91,15.25) 293.19,13.97 293.19,13.44 292.69,12.94 292.3,12.94 291.9,12.53 v2(291.9,11.76)
  BOTTOM w0.254: v2(112.71,110) 112.7,109.99 PR1100.2
PANEL_BKEN_EC: length 273.4
  TOP w0.127: DV1.2 50.72,23.01 v3(50.72,22.67) 50.72,21.81 v2(51.15,21.38)
  TOP w0.14: UE4.4 v2(277.88,9.9)
  IN1 w0.099: v2(283.75,18.6) 281.07,18.6 280.26,17.79 278.91,17.79 277.62,16.5 270.75,16.5 266.53,12.28 266.04,12.28 263.83,10.07 262.36,10.07 261.73,9.44 248.95,9.44 248.11,10.28 233.8,10.28 233.57,10.05 215.44,10.05 213.7,11.79 201.88,11.79 200.89,10.81 196.94,10.81 196.84,10.7 188.3,10.7 188.22,10.79 183.91,10.79 183.74,10.95 178.79,10.95 177.67,12.07 154.84,12.07 154.27,12.65 150.06,12.65 149.83,12.88 130.69,12.88 128.47,15.1 105.43,15.1 104.82,14.49 103.25,14.49 102.07,13.31 99.12,13.31 98.88,13.06 96.7,13.06 96.32,13.44 96.32,14.24 95.44,15.12 91.98,15.12 91.4,15.71 85.48,15.71 85.32,15.54 83.55,15.54 83.36,15.35 78.66,15.35 77.28,13.97 71.05,13.97 69.73,12.64 59.54,12.64 57.6,14.58 54.16,14.58 53.58,15.17 53.58,18.3 54.14,18.87 54.14,19.62 52.38,21.38 v2(51.15,21.38)
  IN4 w0.091: v2(285.73,11.54) 285.73,11.4 284.23,9.9 v2(277.88,9.9)
  BOTTOM w0.14: v2(285.73,11.54) 285.49,11.54 284.53,12.49 284.53,13.62 283.21,14.94 283.21,18.06 v2(283.75,18.6)
PANEL_BKEN_PCH: length 35.6
  TOP w0.127: DV1.3 54.8,25.79 v2(54.8,26.45)
  TOP w0.14: v3(65.9,18.54) 65.79,18.43 v2(65.79,17.84)
  IN2 w0.099: v2(54.8,26.45) 54.8,25.88 58.35,22.33 61.75,22.33 62.93,21.15 62.93,20.7 v2(65.79,17.84)
  IN5 w0.089: 75.06,16.96 77.86,16.96 78.23,16.6 81.07,16.6 v2(81.51,16.15)
  IN5 w0.099: 75.06,16.96 74.23,16.96 74.06,16.8 66.83,16.8 v2(65.79,17.84)
  BOTTOM w0.089: UH2.W35 82.4,16.7 81.85,16.15 v2(81.51,16.15)
PBAT_PRES#: length 318.9
  TOP w0.14: UE3.A49 293.24,19.13 292.9,19.46 v2(292.9,19.65)
  TOP w0.254: v2(59.11,21.07) 59.22,21.18 59.22,21.19 59.23,21.19 59.51,21.47 59.51,22.03 v1(59.31,22.23) 59.12,22.42 PR322.1
  IN1 w0.099: v2(58.2,8.49) 59.43,8.49 62.18,11.24 67.28,11.24 69.61,8.9 71.55,8.9 72.12,8.34 75.87,8.34 76.46,7.76 76.46,7.18 76.8,6.84 78.04,6.84 78.2,6.68 78.94,6.68 80.21,7.95 83.14,7.95 83.54,8.36 85.56,8.36 86.32,9.13 87.4,9.13 87.73,8.8 88.81,8.8 89.14,9.13 91.28,9.13 92.22,10.06 94.09,10.06 94.65,10.63 94.9,10.63 95.01,10.74 97.23,10.74 97.78,10.18 99.66,10.18 100.28,10.81 101.33,10.81 101.82,11.3 104,11.3 104.32,11.62 114.7,11.62 115.74,10.58 146,10.58 147.91,8.67 151.01,8.67 151.57,8.11 154.73,8.11 155.14,7.7 156.81,7.7 157.21,8.1 161.12,8.1 161.69,7.53 172.47,7.53 172.67,7.33 204.74,7.33 206.08,8.68 211,8.68 213.02,6.65 226.94,6.65 227.56,6.03 238.43,6.03 239.63,7.23 251.88,7.23 253.07,6.04 257.79,6.04 258.96,7.22 266.95,7.22 267.35,7.62 272.21,7.62 276.55,11.95 284.89,11.95 v2(285.3,12.36)
  IN1 w0.254: v2(28.61,10.55) 28.61,17.2 29.23,17.81 31.8,17.81 32.89,18.91 32.89,22.11 34.23,23.44 39.43,23.44 40.51,24.52 43.95,24.52 45.43,23.04 47.09,23.04 48.49,24.44 49.82,24.44 50.04,24.23 51.99,24.23 52.55,24.78 56.95,24.78 59.71,22.02 59.71,21.41 59.37,21.07 v2(59.11,21.07)
  IN2 w0.099: v2(58.2,8.49) 57.54,9.14 57.54,11.86 59.5,13.82 59.5,20.67 v2(59.11,21.07)
  BOTTOM w0.14: v2(292.9,19.65) 292.45,20.1 290.83,20.1 290.45,19.72 287.69,19.72 287.29,19.32 287.29,18.02 287.45,17.85 287.45,17.02 286.71,16.28 286.71,15.2 286.01,14.5 286.01,12.71 285.65,12.36 v2(285.3,12.36)
PBAT_SMBCLK: length 352.7
  TOP w0.14: UE3.A56 292.92,15.63 292.71,15.41 v2(292.48,15.41) v1(292.11,15.78) 292.01,15.88 RE18.2
  TOP w0.254: PD101.2 13.21,11.25 v2(12.76,10.8) ; PR106.2 19.92,9.2 v2(20.53,8.58)
  IN3 w0.091: v2(292.48,15.41) 292.48,15.25 290.81,13.58 290.81,10.43 v2(290.18,9.8)
  IN6 w0.089: 76.3,9.14 75.84,9.61 75.06,9.61 ; 101.98,11 99.4,11 99.12,10.72 98.08,10.72 97.58,11.22 95.66,11.22 94.5,10.07 91.78,10.07 91.29,9.57
  IN6 w0.099: 101.98,11 102.38,11 102.58,10.79 106.28,10.79 106.39,10.91 107.81,10.91 108.15,10.57 112.71,10.57 113.57,11.43 115.45,11.43 116.05,10.83 124.94,10.83 125.86,11.75 128.21,11.75 128.85,11.12 145.24,11.12 145.72,10.65 146.81,10.65 147.46,10 150.63,10 151.63,8.99 154.72,8.99 154.9,9.17 155.81,9.17 156.29,8.7 157.21,8.7 158.39,9.87 164.08,9.87 165.09,8.86 170.67,8.86 172.38,10.58 176.33,10.58 176.37,10.62 186.44,10.62 186.77,10.95 201.12,10.95 202.41,12.24 214.31,12.24 216.2,10.36 228.18,10.36 228.63,9.9 233.15,9.9 234.36,8.69 252.47,8.69 252.78,9 261.97,9 262.88,9.91 269.83,9.91 270.48,9.26 270.48,8.91 271.11,8.29 274.49,8.29 275.02,7.76 275.65,7.76 275.78,7.63 275.78,7.19 275.91,7.07 276.13,7.07 276.23,7.17 276.23,7.59 276.33,7.69 276.53,7.69 276.63,7.59 276.63,7.17 276.73,7.07 276.92,7.07 277.02,7.17 277.02,7.59 277.12,7.69 277.32,7.69 277.42,7.59 277.42,7.17 277.52,7.07 277.74,7.07 277.84,7.17 277.84,7.59 277.93,7.69 278.13,7.69 278.23,7.59 278.23,7.17 278.33,7.07 279.65,7.07 279.75,7.17 279.75,7.97 279.84,8.07 280.04,8.07 280.14,7.97 280.14,7.17 280.24,7.07 280.44,7.07 280.54,7.17 280.54,7.97 280.64,8.07 280.84,8.07 280.93,7.97 280.93,7.17 281.03,7.07 282.32,7.07 283.55,8.29 289.08,8.29 290.18,9.39 v2(290.18,9.8) ; 75.06,9.61 73.07,9.61 72.34,10.34 72.34,12.43 69.88,14.89 65.74,14.89 64.37,13.52 58.4,13.52 57.04,14.89 57.04,18.36 54.88,20.52 54.88,21.28 54.18,21.98 51.88,21.98 51.68,22.19 47.21,22.19 46.65,22.75 46.43,22.75 44.86,24.32 38.05,24.32 37.42,23.68 27,23.68 26.79,23.89 23.45,23.89 21.52,21.97 16.76,21.97 14.43,19.64 9.78,19.64 8.2,18.07 8.2,15.43 9.27,14.36 9.27,12.28 10.81,10.74 12.7,10.74 v2(12.76,10.8) 13.21,11.25 15.17,11.25 15.27,11.35 15.27,12.17 15.37,12.26 15.57,12.26 15.67,12.17 15.67,11.35 15.77,11.25 15.97,11.25 16.06,11.35 16.06,12.17 16.16,12.26 16.36,12.26 16.46,12.17 16.46,11.35 16.56,11.25 16.76,11.25 16.86,11.35 16.86,12.17 16.96,12.26 17.15,12.26 17.25,12.17 17.25,11.35 17.35,11.25 17.55,11.25 17.65,11.35 17.65,11.72 17.75,11.82 17.95,11.82 18.05,11.72 18.05,11.35 18.14,11.25 18.37,11.25 19.94,9.68 19.94,9.18 v2(20.53,8.58) ; 76.3,9.14 76.5,8.94 77.42,8.94 78.12,9.65 79.38,9.65 80.05,8.98 84.07,8.98 84.4,9.31 84.4,9.74 84.64,9.99 85.4,9.99 85.9,9.48 87.75,9.48 88.27,8.96 88.72,8.96 89.23,9.47 90.13,9.47 90.23,9.57 91.29,9.57
PBAT_SMBDAT: length 354.7
  TOP w0.14: RE17.2 291.4,16.77 v2(291.77,16.4) ; v2(20.87,9.06) 21.15,9.34 21.15,10.06 v1(21.28,10.19) 21.31,10.19 21.75,10.63 21.75,12.82 22.54,13.6 22.54,14.67 22.2,15.01 PR108.2 ; UE3.B59 294.83,15.88 294.9,15.81 295.38,15.81 v2(295.85,15.34)
  TOP w0.254: v2(10.99,12.07) 11.43,11.63 12.14,11.63 PD101.3
  IN3 w0.091: v2(290.82,9.75) 293.24,12.18 293.24,16.17 292.98,16.44 291.8,16.44 v2(291.77,16.4)
  IN6 w0.089: 101.98,10.76 99.44,10.76 99.23,10.54 98,10.54 97.5,11.05 95.8,11.05 94.64,9.89 91.97,9.89 91.69,9.6
  IN6 w0.099: v2(290.82,9.75) 289.16,8.09 283.67,8.09 282.45,6.87 275.62,6.87 274.4,8.09 271.02,8.09 270.28,8.83 270.28,9.18 269.75,9.71 262.96,9.71 262.05,8.8 252.86,8.8 252.55,8.49 230.15,8.49 229.13,9.51 228.74,9.51 228.09,10.15 216.11,10.15 214.26,12.01 202.48,12.01 201.23,10.75 186.86,10.75 186.52,10.42 176.46,10.42 176.42,10.38 172.47,10.38 170.76,8.66 165,8.66 164,9.67 158.47,9.67 157.3,8.5 156.2,8.5 155.72,8.97 154.98,8.97 154.81,8.79 151.72,8.79 151.55,8.79 151.27,9.07 149.72,9.07 149.5,8.86 148.31,8.86 146.72,10.45 145.63,10.45 145.16,10.92 128.76,10.92 128.13,11.55 125.94,11.55 125.02,10.63 115.97,10.63 115.37,11.23 113.65,11.23 112.79,10.37 107.84,10.37 107.5,10.71 106.47,10.71 106.36,10.59 102.5,10.59 102.33,10.76 101.98,10.76 ; v2(20.87,9.06) 20.84,9.06 18.8,11.1 18.8,11.85 18.7,11.95 18.23,11.95 17.71,12.47 13.03,12.47 12.64,12.07 v2(10.99,12.07) 10.58,12.48 10.58,14.26 9.91,14.93 8.98,14.93 8.4,15.51 8.4,17.98 9.86,19.44 14.52,19.44 16.84,21.77 21.66,21.77 23.58,23.69 26.71,23.69 26.92,23.48 41.4,23.48 41.58,23.31 41.58,23.3 42.48,22.39 46.73,22.39 47.13,21.99 51.6,21.99 51.8,21.78 52.37,21.78 55.69,18.47 55.69,17.88 56.83,16.73 56.83,13.81 57.32,13.32 64.46,13.32 65.09,13.95 70.53,13.95 72.13,12.35 72.13,10.25 72.99,9.4 72.99,8.86 73.47,8.38 74.34,8.38 74.71,8.76 77.5,8.76 77.68,8.94 78.55,8.94 78.65,8.84 78.82,8.84 79.12,9.14 79.63,9.14 80.01,8.76 84.34,8.76 84.69,9.1 85.88,9.1 86.07,9.3 87.67,9.3 88.19,8.78 88.8,8.78 89.21,9.19 90.21,9.19 90.4,9.38 91.47,9.38 91.69,9.6
  BOTTOM w0.14: v2(291.77,16.4) 291.52,16.66 291.52,17.1 291.89,17.47 293.27,17.47 294.92,15.82 295.36,15.82 v2(295.85,15.34)
PBTN_SW#: length 292.2
  TOP w0.14: CE29.1 292.99,3.18 292.48,2.68 285.95,2.68 RE36.2 283.46,5.17 v2(283.46,5.29) ; v2(345.39,111.91) DE2.2 343.75,111.9 v3(340.17,111.9) 338.89,111.9 SW1.1
  IN6 w0.099: v2(345.39,111.91) 344.3,110.82 344.3,105.27 345.13,104.44 345.13,91.92 340.8,87.59 338.58,87.59 337.01,86.01 337.01,83.14 334.56,80.69 334.56,65.44 336.72,63.28 336.72,57.77 331.89,52.95 331.89,50.52 328.01,46.64 328.01,41.04 324.8,37.83 324.8,35.66 324.06,34.92 324.06,31.1 320.62,27.66 320.62,24.9 319.48,23.76 319.48,10.39 315.97,6.88 306.71,6.88 306.12,6.3 302.03,6.3 300.71,4.97 295.57,4.97 295.36,4.77 283.98,4.77 v2(283.46,5.29) 283.27,5.11 274.04,5.11 272.31,6.84 267.79,6.84 267.79,6.83 262.66,6.83 261.99,6.16 253.05,6.16 252.54,6.67 245.9,6.67 244.51,5.28 228.13,5.28 226.94,6.46 214.11,6.46 210.36,10.21 202.96,10.21 201.49,8.74 200.04,8.74 199.28,7.98 179.04,7.98 178.07,7.02 174.14,7.02 v2(173.74,6.61)
  BOTTOM w0.14: v2(173.74,6.61) 173.62,6.73 JAPS.11
PCH_ALW_ON: length 400.3
  TOP w0.14: v2(122.56,51.63) 122.56,42.93 109.4,29.78 109.4,25.57 109.57,25.41 109.57,20.29 110.11,19.75 113.77,19.75 114.57,19.75 116.99,17.34 116.99,16.35 117.59,15.74 122.13,15.74 127.46,10.42 v2(127.46,9.85) ; UE3.A34 302.27,21.59 v2(302.43,21.75) ; UZ23.2 106.62,52.71 106.74,52.59 v2(106.74,50.75) ; RZ46.2 56.96,6.36 57.49,5.83 v2(57.51,5.83)
  TOP w0.254: v2(127.46,9.85) 127.46,8.12 v3(129.03,6.56) 130.04,5.55 130.04,1.82 130.28,1.58 v2(130.65,1.58)
  IN2 w0.089: 75.06,2.58 75.29,2.58 75.66,2.2 81.74,2.2 82.95,3.41 83.73,3.41 84.3,3.98 85.35,3.98 85.81,4.43 88.22,4.43 88.34,4.56 92.19,4.56 92.59,4.96 95.27,4.96 95.96,5.65 96.27,5.65 96.69,6.07 97.88,6.07 98.12,5.83 98.73,5.83 99.87,6.97 100.33,6.97 100.34,6.98 101.98,6.98
  IN2 w0.099: 75.06,2.58 74.55,2.58 73.37,3.76 72.21,3.76 71.43,4.54 69.45,4.54 68.52,5.47 63.35,5.47 62.33,4.44 62.33,4.09 61.6,3.36 59.41,3.36 58.92,2.86 58.28,2.86 57.5,3.65 57.5,5.8 57.51,5.81 v2(57.51,5.83) ; 101.98,6.98 104.07,6.98 104.74,7.65 108.2,7.65 108.48,7.94 110.34,7.94 110.71,7.57 115.77,7.57 118.11,9.91 127.39,9.91 v2(127.46,9.85) 127.86,9.44 135.51,9.44 135.8,9.73 146.62,9.73 147.92,8.43 149.33,8.43 152.35,5.42 155.75,5.42 156.19,5.86 159.48,5.86 159.7,5.63 163.06,5.63 163.53,5.16 171.45,5.16 171.6,5.01 175.06,5.01 175.91,5.86 178.81,5.86 179.71,4.96 180.71,4.96 181.28,5.53 204.62,5.53 206.66,7.58 209.98,7.58 213.1,4.45 213.13,4.45 213.27,4.32 225.96,4.32 226.63,3.64 244.83,3.64 246.25,5.06 257.81,5.06 258.7,4.17 261.94,4.17 262.86,5.1 267.69,5.1 269.56,3.23 269.73,3.23 288.87,3.23 289.6,3.95 296.28,3.95 296.44,4.11 300.91,4.11 301.77,4.97 302.69,4.97 303.64,4.02 309.7,4.02 310.29,4.61 310.91,4.61 313.65,7.34 313.96,7.34 314.5,7.88 v2(315.08,7.88)
  IN3 w0.091: v2(315.08,7.88) 314.63,8.33 314.63,10.23 315.26,10.86 315.26,11.51 315.29,11.54 315.29,11.94 314.56,12.67 314.56,19.75 311.74,22.57 308.25,22.57 307.69,22.02 304.3,22.02 304.17,22.16 302.84,22.16 v2(302.43,21.75)
  BOTTOM w0.14: v2(57.51,5.83) 57.51,5.3 57.28,5.07 57.28,4.52 57.36,4.44 57.36,3.15 56.91,2.7 RZ1140.1 ; v2(122.56,51.63) 121.48,52.71 120.7,52.71 120.25,52.26 111.66,52.26 110.14,50.75 v2(106.74,50.75)
  BOTTOM w0.254: v2(130.65,1.58) 130.65,1.9 PR500.2
PCH_ALW_ON_R: length 12.6
  TOP w0.14: v2(56.29,5.81) 56.08,5.6 UZ4.3
  BOTTOM w0.14: RZ1140.2 58.51,2.21 v1(58.95,2.64) 59.43,3.13 59.43,3.97 59.26,4.15 RZ1133.2 57.96,4.18 57.53,4.62 57.53,4.97 57.96,5.41 57.96,7.75 57.78,7.93 56.95,7.93 56.72,7.7 56.72,6.93 56.29,6.51 v2(56.29,5.81)
PCH_BATLOW#: length 20.7
  IN6 w0.089: v2(94.08,2.98) 94.13,3.03 94.89,3.03 95.52,2.4 98.43,2.4 99.65,3.62 99.65,4.61 99.99,4.96 100.71,4.96 101.02,5.27 101.02,5.5 101.22,5.7 101.98,5.7
  IN6 w0.099: 101.98,5.7 102.11,5.7 102.14,5.72 103.8,5.72 103.94,5.59 103.94,5 104.24,4.7 104.65,4.7 106.34,3.01 v2(107.54,3.01)
  BOTTOM w0.089: v2(94.08,2.98) 93.74,3.32 93.74,4.47 UH2.BD13
  BOTTOM w0.127: v2(107.54,3.01) 108,2.55 RH515.1
PCH_CPU_BCLK_N: length 135.8
  IN6 w0.107: v2(177.07,82.56) 177.35,82.28 177.65,82.28 177.78,82.41 177.78,82.66 178.04,82.92 178.04,84.54 176.21,86.37 173.73,86.37 173.33,85.98 171.54,85.98 171.13,86.38 171.13,87.43 169.52,89.04 156.73,89.04 155.72,90.05 136.29,90.05 134.32,88.08 134.32,81.9 132.53,80.11 132.53,77.94 129,74.42 129,70 128.3,69.29 128.3,66.65 123.74,62.1 122.56,62.1 119.88,59.41 119.88,53.03 118.17,51.32 118.17,43.27 105.06,30.16 103.05,30.16 101.86,28.96 101.86,28.01 102.5,27.36 102.5,25.46 101.98,24.94 101.98,24.34 101.73,24.09 101.73,23.76 v2(101.86,23.63)
  BOTTOM w0.076: v2(177.07,82.56) 177.12,82.61 UH1.A32
  BOTTOM w0.102: v2(101.86,23.63) 101.62,23.63 100.33,22.34 99.91,22.34 99.91,22.34 99.9,22.34 99.61,22.34 99.58,22.3 99.09,22.3 99.07,22.32 UH2.H2
PCH_CPU_BCLK_P: length 135.5
  IN6 w0.107: v2(178.15,82.08) 177.98,82.25 177.98,82.57 178.25,82.84 178.25,84.62 176.29,86.58 173.64,86.58 173.25,86.18 171.62,86.18 171.33,86.47 171.33,87.51 169.61,89.24 156.82,89.24 155.8,90.26 136.21,90.26 134.11,88.16 134.11,81.99 132.32,80.2 132.32,78.02 128.8,74.5 128.8,70.08 128.09,69.38 128.09,66.74 123.66,62.3 122.48,62.3 119.67,59.5 119.67,53.11 117.97,51.41 117.97,43.36 104.97,30.36 102.96,30.36 101.65,29.05 101.65,27.93 102.3,27.28 102.3,25.55 101.78,25.03 101.78,24.43 101.28,23.93 v2(101.28,23.88)
  BOTTOM w0.076: UH1.B31 178.07,82.16 v2(178.15,82.08)
  BOTTOM w0.102: v2(101.28,23.88) 101.28,23.61 100.3,22.62 99.91,22.62 99.91,22.62 99.79,22.62 99.79,22.62 99.49,22.62 99.49,22.61 99.49,22.58 99.47,22.56 99.2,22.56 99.18,22.58 98.86,22.58 98.81,22.62 98.81,22.86 UH2.G2
PCH_CPU_PCIBCLK_N: length 128.1
  IN6 w0.107: v2(101.8,22.49) 102.55,23.24 102.55,24.14 103.5,25.09 103.5,28.55 104.35,29.4 105.16,29.4 118.78,43.02 118.78,51.07 121.51,53.8 121.51,58.64 128.93,66.06 128.93,69.02 129.62,69.71 129.62,74.16 133.21,77.75 133.21,79.14 135.04,80.97 135.04,87.78 136.61,89.35 155.26,89.35 156.34,88.27 169,88.27 170.01,87.26 170.01,86.48 171.68,84.81 173.57,84.81 174.51,85.76 175.43,85.76 175.94,85.25 v2(175.94,84.78)
  BOTTOM w0.076: UH1.C36 176.59,84.78 175.94,84.78 v2(175.94,84.78)
  BOTTOM w0.102: UH2.J1 99.55,21.77 99.61,21.83 100.5,21.83 101.14,22.48 101.79,22.48 v2(101.8,22.49)
PCH_CPU_PCIBCLK_P: length 129.4
  IN6 w0.107: v2(176.7,84.37) 176.37,84.71 176.37,85.1 175.51,85.96 174.43,85.96 173.48,85.01 171.76,85.01 170.22,86.56 170.22,87.35 169.09,88.48 156.43,88.48 155.35,89.56 136.53,89.56 134.84,87.87 134.84,81.06 133.01,79.23 133.01,77.83 129.41,74.24 129.41,69.79 128.73,69.11 128.73,66.14 121.31,58.72 121.31,53.88 118.58,51.15 118.58,43.1 105.08,29.6 104.27,29.6 103.3,28.63 103.3,25.17 102.35,24.22 102.35,23.32 102.12,23.09 101.78,23.09 v2(101.74,23.05)
  BOTTOM w0.076: UH1.D35 176.69,84.39 v2(176.7,84.37)
  BOTTOM w0.102: v2(101.74,23.05) 101.71,23.09 101.35,23.09 100.41,22.15 100.4,22.15 100.36,22.11 99.5,22.11 99.44,22.06 99.2,22.06 98.99,21.85 UH2.J2
PCH_DPWROK: length 250.6
  TOP w0.089: RH309.1 100.68,9.81 v2(100.99,9.5)
  TOP w0.14: v2(301.46,21.75) 301.27,21.56 UE3.A36
  IN2 w0.089: 101.98,9.77 101.26,9.77 v2(100.99,9.5)
  IN2 w0.099: 101.98,9.77 102.16,9.77 102.18,9.75 105.51,9.75 106.68,10.91 113.88,10.91 114.94,11.97 148.34,11.97 148.88,11.44 151.43,11.44 151.91,10.95 151.91,10.66 153.6,8.97 155.89,8.97 156.86,7.99 173.21,7.99 173.37,7.83 199.78,7.83 200.49,8.54 201.94,8.54 202.17,8.31 205.26,8.31 205.93,8.99 211.4,8.99 214.11,6.27 225.71,6.27 227.13,4.85 238.85,4.85 239.8,5.8 245.12,5.8 246.35,7.03 251.94,7.03 252.63,6.33 256.28,6.33 257.26,7.32 262,7.32 262.21,7.11 270.37,7.11 272.33,5.14 282.44,5.14 283.19,5.9 284.6,5.9 285.54,4.96 295.87,4.96 296.03,5.12 300.5,5.12 301.79,6.4 305.87,6.4 306.77,5.51 307.1,5.51 307.72,6.13 309.34,6.13 314.16,10.94 v2(314.69,10.94)
  IN3 w0.091: v2(301.46,21.75) 302.25,20.96 303.26,20.96 303.62,21.32 307.54,21.32 308.41,22.19 311.58,22.19 314.17,19.59 314.17,12.51 314.39,12.29 314.39,11.25 v2(314.69,10.94)
PCH_DPWROK_R: length 8.8
  TOP w0.089: v2(95.1,7.79) 95.36,8.05 96.06,8.05 96.61,8.59 97.64,8.59 98.5,7.73 RH401.2 99.28,8.14 99.28,9.6 RH309.2 99.49,10.49 v3(100.03,11.02)
  BOTTOM w0.089: UH2.AV11 94.84,7.79 v2(95.1,7.79)
PCH_ITP_PMODE: length 146.5
  TOP w0.14: v1(120.41,93.61) 120.08,93.61 v2(119.81,93.87) 119.7,93.87 RH479.1
  IN4 w0.091: v2(111.98,16.7) 111.98,17.51 111.63,17.86 111.63,26.36 112.09,26.82 112.09,34.37 125.03,47.31 125.03,51.44 131.82,58.23 131.82,64.34 129.29,66.88 129.29,68.86 130.79,70.36 130.79,75.87 133.74,78.82 133.74,80.32 135.38,81.96 135.38,84.95 134.52,85.81 134.52,94.65 135.14,95.27 135.14,98.17 133.48,99.83 133.48,100.7 132.98,101.2 121.31,101.2 120,99.88 120,95.72 119.91,95.64 119.91,93.98 v2(119.81,93.87)
  BOTTOM w0.089: 101.98,7.04 101.61,7.41 100.86,7.41 99.96,8.31 99.15,8.31 99.04,8.21 UH2.AT2
  BOTTOM w0.14: v2(111.98,16.7) 112.44,16.23 113.09,16.23 114.57,14.76 114.57,12.45 113.09,10.98 113.09,8.13 112.71,7.75 112.64,7.75 110.91,6.01 108.31,6.01 106.93,7.4 105.1,7.4 104.62,6.92 102.1,6.92 101.98,7.04
PCH_JTAG_TCK: length 131.8
  TOP w0.14: JXDP.55 129.49,99.01 129.81,99.32 130.48,99.32 130.8,99.64 133.31,99.64 v3(133.54,99.86) v2(133.95,100.28) ; RH95.2 102.11,10.17 101.71,9.77 v2(101.71,9.41)
  IN4 w0.089: 134.62,77.12 136.42,77.12 137.15,77.85 137.15,79.78 136.16,80.77 136.16,81.75 135.56,82.34 135.56,85.06 134.71,85.91 134.71,89.23
  IN4 w0.091: 134.71,89.23 134.71,94.57 135.36,95.22 135.36,98.87 v2(133.95,100.28) ; 134.62,77.12 133.1,77.12 131.75,75.78 131.75,70.87 132.48,70.14 132.48,69.14 131.17,67.83 131.17,66.58 132.21,65.54 132.21,57.96 125.42,51.18 125.42,47.13 112.48,34.19 112.48,26.68 113.17,25.98 113.17,17.54 112.57,16.94 112.57,16.35 112.29,16.07 108.93,16.07 v2(108.34,16.66)
  BOTTOM w0.089: UH2.AN3 98.66,9.9 98.85,9.71 100.27,9.71 100.86,9.12 101.37,9.12 101.66,9.41 v2(101.71,9.41)
  BOTTOM w0.127: v2(101.71,9.41) 101.78,9.41 101.88,9.51 106.29,9.51 106.54,9.25 108.67,9.25 109.94,10.53 109.94,13.11 109.46,13.59 109.46,15.2 108.34,16.32 v2(108.34,16.66)
PCH_JTAG_TDI: length 146.6
  TOP w0.14: v2(109.56,16.68) 109.54,16.68 109.07,17.15 v3(108.65,17.15)
  IN4 w0.091: v2(109.56,16.68) 109.56,18.06 111.19,19.69 111.19,26.35 111.09,26.45 111.09,34.07 124.65,47.63 124.65,51.76 131.44,58.55 131.44,64.15 128.84,66.75 128.84,68.96 130.05,70.17 130.05,75.68 133.35,78.98 133.35,80.48 134.62,81.75 134.61,81.75 134.61,84.99 134.62,84.99 134.13,85.48 134.13,94.56 133.46,95.24 133.46,95.77 133.54,95.85 133.54,98.4 130.94,101 121.39,101 120.19,99.8 120.19,95.03 120.17,95 120.17,94.09 120.21,94.04 120.21,93.71 119.98,93.47 118.18,93.47 v2(117.64,94.01)
  BOTTOM w0.089: 101.56,8.77 101.55,8.76 100.71,8.76 100.37,9.1 99.2,9.1 98.97,9.34 UH2.AP2
  BOTTOM w0.14: 101.56,8.77 102.51,8.77 102.77,9.03 106.09,9.03 106.34,8.78 107.25,8.78 107.53,8.5 107.53,8.37 107.94,7.95 RH100.2 107.94,7.41 108.61,6.74 109.83,6.74 110.28,7.19 110.28,9.33 112.71,11.76 112.71,14.41 112.16,14.96 111.03,14.96 109.56,16.42 v2(109.56,16.68) ; v2(117.64,94.01) 118.11,94.48 RH477.2
PCH_JTAG_TDO: length 128.3
  TOP w0.127: RH97.2 109.02,10.35 111.63,10.35 114.25,12.97 114.25,14.76 113.96,15.05 113.96,17.06 113.31,17.71 109.5,17.71 108.91,18.3 107.01,18.3 106.63,18.68 105.87,18.68 105.3,19.25 105.3,19.71 105.33,19.74 105.33,20.37 105.01,20.68 104.79,20.68 104.34,21.13 104.34,21.39 104.05,21.69 103.7,21.69 103.08,21.06 102.43,21.06 101.67,21.82 101.33,21.82 101.22,21.94 101.22,21.94 100.22,22.93 100.13,23.03 100.13,25.69 99.95,25.86 99.95,27.69 102.17,29.91 106.71,29.91 v3(110.03,33.23) 116.41,39.61 116.41,46.85 v2(115.26,48)
  TOP w0.14: RH97.2 107.94,8.56 v2(107.95,8.54)
  IN4 w0.091: v2(115.26,48) 116.78,49.52 116.78,52.38 117.24,52.84 117.24,63.19 121.44,67.39 121.44,68.52 124.27,71.35 124.27,85.37 122.78,86.85 122.78,92.16 121.49,93.45 121.49,94.8 v2(121.03,95.26)
  BOTTOM w0.089: 101.98,9.01 101.52,9.01 101.44,8.94 100.79,8.94 100.39,9.34 UH2.AP1
  BOTTOM w0.14: v2(107.95,8.54) 107.47,9.02 106.44,9.02 106.19,9.27 102.67,9.27 102.41,9.01 101.98,9.01 ; v2(121.03,95.26) 120.85,95.26 120.52,94.93 120.52,94.8 120.21,94.48 RH478.2
PCH_JTAG_TMS: length 145.5
  TOP w0.127: v2(115.09,49.45) 116.71,47.82 116.71,39.35 v3(113.07,35.71) 107.05,29.68 102.27,29.68 100.19,27.6 100.19,25.93 100.34,25.77 100.34,23.12 101.4,22.06 102.31,22.06 103.12,22.87 103.89,22.87 104.62,22.13 104.62,22.04 105.67,21 105.67,20.07 106.3,19.44 106.3,19.3 106.65,18.96 107.67,18.96 108.1,18.53 109,18.53 109.57,17.96 113.73,17.96 114.86,16.83 114.86,12.23 112.9,10.27
  TOP w0.14: 112.9,10.27 112.55,9.91 110.82,9.91 110.63,9.72 RH98.2 111.08,8.82 111.89,8.82 v2(112.54,8.17)
  IN5 w0.099: v2(112.54,8.17) 111.92,8.79 109.73,8.79 108.86,7.92 108,7.92 107.55,8.38 107.55,8.42 107.17,8.79 104.73,8.79 104.42,8.48 v2(104.42,8.31)
  IN6 w0.099: v2(115.09,49.45) 114.68,49.85 114.68,50.38 115.17,50.87 115.17,54.78 117.14,56.74 117.14,62.1 121.23,66.2 123.74,66.2 124.1,66.55 124.1,69.5 126,71.4 126,83.17 122.12,87.05 122.12,95.44 121.67,95.89 119.88,95.89 118.48,94.5 118.48,92.99 v2(118.62,92.85)
  BOTTOM w0.089: 101.09,8.1 100.69,8.1 100.08,8.71 98.92,8.71 UH2.AR2
  BOTTOM w0.14: v2(104.42,8.31) 104.42,8.1 104.22,7.9 102.12,7.9 101.92,8.1 101.09,8.1 ; RH12.2 118.48,93.77 118.48,92.99 v2(118.62,92.85)
PCH_JTAGX: length 124.9
  TOP w0.14: RH491.1 131.89,100.94 v3(131.99,100.83) 132.27,100.55 v2(133.05,100.55)
  IN4 w0.089: 134.62,85.37 135.2,84.78 135.2,82.05 134.62,81.47
  IN4 w0.091: v2(110.81,16.67) 110.68,16.8 110.68,18.91 111.44,19.66 111.44,26.37 111.28,26.53 111.28,33.88 124.84,47.44 124.84,51.68 131.63,58.47 131.63,64.26 129.03,66.86 129.03,68.88 130.59,70.44 130.59,75.95 133.54,78.9 133.54,80.4 134.62,81.47 ; 134.62,85.37 134.33,85.66 134.33,95.1 134.28,95.15 134.28,98.46 133.05,99.69 v2(133.05,100.55)
  BOTTOM w0.089: UH2.AR3 98.53,8.72 98.77,8.96 99.08,8.96 99.11,8.92 100.12,8.92 100.51,8.53 101.98,8.53
  BOTTOM w0.14: v2(110.81,16.67) 110.81,16.66 110.97,16.5 110.97,16.5 112.95,14.51 112.95,11.66 110.52,9.23 110.52,7.09 109.93,6.5 108.51,6.5 107.13,7.88 106.2,7.88 105.3,8.79 102.87,8.79 102.61,8.53 101.98,8.53
PCH_PCIE_WAKE#: length 231.2
  TOP w0.14: RH453.1 108.54,4.33 108.06,4.81 107.4,4.81 v2(107.1,4.5) ; UE3.B46 297.52,19.47 v2(297.66,19.33)
  IN3 w0.089: 101.98,3.61 100.74,3.61 98.69,1.56 94.51,1.56 94.18,1.89 94.18,2.32 v2(94.13,2.37)
  IN3 w0.091: 106.35,3.62 101.99,3.62 101.98,3.61 ; 106.35,3.62 106.35,3.05 106.95,2.45 108.42,2.45 109.01,1.86 117.67,1.86 122.82,7.02 130.24,7.02 130.63,6.63 136.73,6.63 137.79,7.69 144.37,7.69 148.41,3.64 150.29,3.64 151.02,2.91 162.23,2.91 163.39,4.07 168.47,4.07 169.38,3.16 182.35,3.16 182.77,3.59 184.55,3.59 184.98,3.16 200.73,3.16 202.08,1.81 210.58,1.81 213.4,4.62 239.43,4.62 239.77,4.96 256.54,4.96 257.92,6.34 258.85,7.27 266.96,7.27 267.43,6.79 271.72,6.79 273.02,8.1 275.53,8.1 276.25,8.82 276.25,10.2 283.14,17.1 283.14,18.57 284.08,19.5 291.15,19.5 291.66,19 293.96,19 295.97,21.01 296.49,21.01 297.41,20.09 297.46,20.09 297.66,19.89 v2(297.66,19.33) ; 106.35,3.62 106.35,3.75 v2(107.1,4.5)
  BOTTOM w0.089: UH2.BC13 93.68,5 93.42,4.75 93.42,4.43 93.56,4.29 93.56,3.25 93.63,3.19 93.63,2.88 v2(94.13,2.37)
PCH_PECI: length 4.6
  BOTTOM w0.089: UH2.AL3 98.53,10.99 98.77,11.23 99.09,11.23 99.22,11.1 101.22,11.1 v1(101.57,11.44) 101.94,11.82 101.98,11.82
  BOTTOM w0.14: RH539.1 102.41,11.82 101.98,11.82
PCH_PLTRST#: length 37.5
  TOP w0.14: v2(64.79,3.13) 64.69,3.23 64.69,3.62 63.39,4.92 63.39,5.29 v1(61.86,6.82) 61.36,7.31 UH7.1 UH7.2
  IN5 w0.089: v2(87.5,1.69) 87.29,1.9 86.25,1.9 86,2.15 86,2.39 85.21,3.18 84.07,3.18 82.83,1.94 75.86,1.94 75.06,2.74
  IN5 w0.099: v2(64.79,3.13) 65.71,3.13 66.04,2.8 68.45,2.8 69.31,3.66 69.31,3.91 69.62,4.22 71.57,4.22 72.25,3.54 74.25,3.54 75.06,2.74
  BOTTOM w0.089: UH2.BB27 87.09,5.17 87.09,4.61 87.14,4.57 87.14,4.08 87.21,4 87.21,3.69 87.5,3.4 87.5,2.88 87.44,2.82 87.44,2.13 87.5,2.07 v2(87.5,1.69)
PCH_PLTRST#_EC: length 651.8
  TOP w0.127: UE1.17 151.16,8.93 150.92,9.18 150.92,10.2 151.49,10.78 v2(151.49,10.8) ; v2(151.49,10.8) 151.49,10.8 v2(151.49,10.8)
  TOP w0.14: RH77.1 60.68,10.31 v2(60.52,10.15) 60.17,9.8 UH7.4 ; UV19.2 227.27,44.32 v2(226.96,44.63) ; v2(311.97,18) 311.63,17.66 RE31.2 ; v2(230.75,44.59) 231.1,44.59 231.53,44.15 231.53,42.1 231.86,41.77 232.58,41.77 233.96,40.38 250.23,40.38 259.72,30.89 259.72,28.26 260.17,27.81 260.17,24.59 261.99,22.76 261.99,21.64 263.11,20.53 263.11,19.5 263.78,18.83 v3(263.78,17.7) 263.78,15.57 264.03,15.31 264.03,12.73 262.79,11.49 262.79,7.82 v2(261.74,6.77) ; UE3.B30 303.33,17.38 303.01,17.05 302.52,17.05 v2(302.07,16.61)
  IN1 w0.099: v2(342.67,34.69) 339.4,34.69 337.73,36.36 337.73,38.65 335.03,41.35 335.03,44.46 333.91,45.57 333.91,55.85 336.81,58.75 336.81,63.85 333.41,67.25 333.41,82.63 341.07,90.29 v2(341.28,90.29)
  IN2 w0.089: 101.98,9.06 101.91,8.99 99.45,8.99 99.01,8.55 94.84,8.55 93.77,7.48 93.77,7.17 93.5,6.9 92.81,6.9 92.58,7.13 92.58,7.55 92.24,7.9 91.82,7.9 91.5,8.21 91.5,8.84 91.2,9.14 90.6,9.14 90.35,8.89 89.4,8.89 89.07,8.56 89.07,7.37 88.34,6.64 88.34,6.21 87.74,5.61 87.21,5.61 86.64,5.04 85.41,5.04 84.93,4.56 83.6,4.56 83.21,4.17 78.17,4.17 77.89,3.89 75.43,3.89 75.06,4.26
  IN2 w0.099: v2(61.66,4.33) 61.66,5.94 62.03,6.32 63.75,6.32 63.97,6.11 68.82,6.11 69.71,5.22 74.1,5.22 75.06,4.26 ; v2(310.01,5.22) 309.3,5.93 307.8,5.93 307.17,5.29 306.7,5.29 305.79,6.2 303.4,6.2 302.97,5.77 301.44,5.77 300.58,4.92 296.11,4.92 295.95,4.75 285.44,4.75 284.49,5.7 283.28,5.7 282.52,4.94 272.26,4.94 270.8,6.39 v2(270.38,6.39) 270.01,6.77 v2(261.74,6.77) 261.1,6.13 258.28,6.13 258.28,6.13 252.72,6.13 252.55,6.13 251.85,6.83 246.44,6.83 245.15,5.53 245.14,5.53 240.27,5.53 240.14,5.41 240.14,5.41 239.38,4.65 227.05,4.65 225.63,6.06 214.04,6.06 211.31,8.78 206.02,8.78 204.86,7.63 161.23,7.63 161.06,7.79 154.49,7.79 151.49,10.8 151.49,10.8 151.49,10.8 v2(151.49,10.8) 151.1,11.2 150.19,11.2 150.06,11.06 147.27,11.06 146.67,11.67 114.91,11.67 113.96,10.71 106.76,10.71 105.6,9.55 102.47,9.55 101.98,9.06
  IN3 w0.091: v2(317.46,30.01) 319.98,30.01 322.54,32.57 323.38,32.57 324.35,31.59 330.41,31.59 331.62,32.79 338.77,32.79 339.64,33.66 341.64,33.66 v2(342.67,34.69) ; v2(20,21.15) 20,21.49 20.55,22.03 23.46,22.03 24.78,23.36 28.54,23.36 29.37,24.19 39.77,24.19 42.27,21.68 44.83,21.68 46.05,20.46 46.79,20.46 46.92,20.59 51.28,20.59 53.64,18.23 53.64,17.15 56.04,14.75 56.04,14.04 57.09,12.99 59.67,12.99 60.52,12.15 v2(60.52,10.15) 60.52,5.47 v2(61.66,4.33) ; v2(302.07,16.61) 302.54,16.14 303.06,16.14 304.47,14.73 308.26,14.73 308.77,14.23 308.77,12.61 310.16,11.23 310.16,5.36 v2(310.01,5.22)
  IN5 w0.099: v2(20,21.15) 17.85,23.31 16.1,23.31 15.86,23.55 15.86,24.34 20.77,29.25 20.77,30.4 22.05,31.67 22.05,34.19 23.05,35.19 23.05,37.22 23.56,37.73 23.56,38.43 24.77,39.63 24.77,40.9 25.72,41.86 25.72,42.62 27.18,44.08 27.18,45.28 26.05,46.42 26.05,48.64 25.91,48.78 25.91,51.04 27.57,52.7 27.57,55.9 27.28,56.2 27.28,63.28 26.08,64.48 26.08,67.56 23.4,70.24 23.4,78.37 25.91,80.88 25.91,91.51 26.93,92.53 26.93,96.82 v2(26.58,97.16)
  IN6 w0.099: v2(230.75,44.59) 230.06,43.9 227.69,43.9 v2(226.96,44.63) ; v2(302.07,16.61) 302.46,16.99 303.55,16.99 304.15,17.59 311.56,17.59 v2(311.97,18) 312.45,18 315.55,21.09 315.55,27.46 317.46,29.37 v2(317.46,30.01)
  BOTTOM w0.14: JNGFF1.44 341.3,90.32 v2(341.28,90.29) ; v2(342.67,34.69) 342.54,34.56 341.53,34.56 341.38,34.7 UR1.1 ; v2(302.07,16.61) 302.06,16.61 301.31,17.36 301.31,17.9 301.85,18.45 301.85,19.55 299.93,21.47 299.93,25.08 299.7,25.31 298.32,25.31 297.18,26.45 297.18,27.57 296.93,27.82 296.93,30.31 296.99,30.37 296.99,30.6 297.2,30.81 JLPDE1.8 ; JNGFF2.50 269.46,10.29 270.38,9.37 v2(270.38,6.39) ; v2(26.58,97.16) 26.2,96.78 25.85,96.78 25.67,96.96 QT20.1
PCH_PLTRST#_EC_AR: length 63.1
  TOP w0.14: v1(26.94,100.4) 26.67,100.14 v2(26.67,99.89)
  IN5 w0.099: v2(26.67,99.89) 26.67,97.82 25.34,96.49 25.34,91.89 24.72,91.28 24.72,84.01 24.26,83.54 24.26,79.51 23.2,78.45 23.2,70.16 25.88,67.47 25.88,64.39 27.08,63.2 27.08,56.11 27.28,55.91 27.28,52.74 25.71,51.16 25.71,48.69 25.85,48.56 25.85,46.17 26.41,45.61 26.41,44.6 v2(26.06,44.25)
  BOTTOM w0.089: UT1.L4 v2(26.06,44.25)
  BOTTOM w0.14: QT20.6 25.67,100.06 RT435.2 26.26,100.3 v2(26.67,99.89)
PCH_PWROK: length 17.4
  TOP w0.127: RH529.1 109.11,7.64 109.24,7.77 UH14.4
  TOP w0.14: RH529.1 v3(107.44,7.64) 107.44,7.91 v2(107,8.35)
  IN6 w0.089: 101.98,8.5 99.18,8.5 98.57,7.89 97.63,7.89 97.34,7.6 97.34,7.6 97.27,7.54 95.44,7.54 95.12,7.22 v2(95.12,7.22)
  IN6 w0.099: v2(107,8.35) 107,8.65 106.77,8.89 106.07,8.89 105.77,9.19 102.67,9.19 101.98,8.5
  BOTTOM w0.089: v2(95.12,7.22) 95.03,7.22 UH2.AW11
PCH_RSMRST#: length 356.3
  TOP w0.089: v2(96.2,9.43) 96.28,9.51 RH133.1
  TOP w0.14: v2(297.45,22.36) 297.45,22.35 296.77,21.67 UE3.A45 ; RH481.1 v2(131.12,92.74) ; v2(80.47,34.3) 79.35,33.18 75.45,33.18 74.22,31.95 74.22,24.67 74.5,24.39 v2(74.5,22.97)
  IN3 w0.089: 101.98,10.07 101.83,9.91 98.1,9.91 97.7,9.52 96.67,9.52 96.58,9.43 v2(96.2,9.43) 94.83,10.8 91.77,10.8 91.14,11.44 86.85,11.44 86.18,12.11 86.18,12.38 85.29,13.27 85.29,13.83 84.73,14.39 79.88,14.39 78.16,16.11 78.16,16.54 77.78,16.93 76.43,16.93 75.13,18.22 75.13,22.34 75.06,22.41
  IN3 w0.091: v2(131.12,92.74) 129.93,92.74 128.91,91.72 128.91,88.63 124.94,84.66 124.94,73.05 123.14,71.24 123.14,68.47 119.87,65.2 119.22,65.2 117.32,63.3 117.32,57.91 112.37,52.97 112.22,52.97 101.52,42.27 101.52,41.31 98.12,37.91 95.99,37.91 94.9,36.81 87.22,36.81 86.23,35.82 85.37,35.82 83.8,34.25 80.52,34.25 v2(80.47,34.3) ; 101.98,10.07 103.54,11.63 106.42,11.63 106.6,11.45 109.59,11.45 110.5,10.53 112.72,10.53 113.62,9.63 115.02,9.63 117,11.6 118.56,11.6 121.17,14.22 160.61,14.22 162.62,12.2 178.82,12.2 179.5,11.53 186.62,11.53 186.79,11.36 189.44,11.36 191.52,9.28 196.13,9.28 197.02,8.4 199.63,8.4 202.67,11.44 210.03,11.44 213.54,7.93 227.14,7.93 227.63,8.42 230.05,8.42 232.14,10.51 242.52,10.51 243.06,11.05 252.62,11.05 253.9,12.33 254.67,13.1 259.74,13.1 259.9,13.27 266.95,13.27 269.05,15.37 277.95,15.37 279.91,17.33 279.91,17.92 280.97,18.98 280.97,19.72 282.45,21.19 291.68,21.19 291.96,21.47 293.36,21.47 294.64,22.76 297.04,22.76 297.45,22.35 v2(297.45,22.36) ; 75.06,22.41 v2(74.5,22.97)
PCH_RSMRST#_R: length 5.2
  TOP w0.089: RH133.2 94.82,9.94 v1(94.82,9.53) RH88.2 94.82,8.19 94.63,8 94.63,7.12 v2(95.11,6.65)
  BOTTOM w0.089: v2(95.11,6.65) 94.59,6.13 UH2.BA11
PCH_RTCRST#: length 206.9
  TOP w0.089: RH84.2 96.53,3.76 96.34,3.76 95.85,3.27 95.85,2.89 95.5,2.55 v2(94.86,2.55)
  TOP w0.14: v2(271.6,4.02) 271.95,4.36 RT1133.1 ; v3(106.95,2.51) v2(106.95,3.64) 106.19,3.64 CH53.1
  IN1 w0.076: 101.98,3.62 100.75,3.62 98.54,1.41 95.82,1.41 95.56,1.67 95.56,2.21 95.35,2.42 94.99,2.42 v2(94.86,2.55)
  IN1 w0.099: v2(106.95,3.64) 106.92,3.61 101.98,3.61 101.98,3.62
  IN3 w0.091: v2(175.36,4.29) 174.79,3.71 170.06,3.71 169.15,4.62 163.16,4.62 162.01,3.46 156.82,3.46 156.1,4.18 150.45,4.18 150.09,4.54 148.29,4.54 144.6,8.24 136.26,8.24 135.2,7.17 130.86,7.17 130.47,7.57 122.59,7.57 117.44,2.41 111.19,2.41 110.85,2.76 109.05,2.76 108.39,3.42 107.16,3.42 v2(106.95,3.64)
  IN6 w0.099: v2(175.36,4.29) 175.36,4.04 175.79,3.61 178.71,3.61 179.66,4.56 180.62,4.56 181.74,5.67 201.99,5.67 203.62,7.3 205.74,7.3 206.36,7.92 209.94,7.92 213.72,4.14 226.89,4.14 227.43,3.59 237.51,3.59 239.3,1.81 243.76,1.81 244.03,2.08 244.03,2.49 243.92,2.6 243.92,3.01 244.12,3.21 245.54,3.21 246.63,4.3 257.82,4.3 258.57,3.55 262.27,3.55 263.81,5.08 266.7,5.08 268.16,3.62 271.2,3.62 v2(271.6,4.02)
  BOTTOM w0.089: v2(94.86,2.55) 94.67,2.74 94.67,4.81 UH2.BC10
  BOTTOM w0.14: v2(106.95,3.64) 106.95,3.04 CLRP1.1 ; JAPS.9 174.62,5.03 v2(175.36,4.29)
PCH_RTCX1: length 9.7
  TOP w0.14: YH1.1 100.76,2.18 100.67,2.27 99.33,2.27 CH45.1 98.81,2.69 RH70.1 96.56,2.69 v2(95.91,2.04)
  BOTTOM w0.089: v2(95.91,2.04) 95.61,2.35 95.61,2.57 95.02,3.15 95.02,4.17 95.2,4.35 95.2,4.97 UH2.BC9
PCH_RTCX2: length 13.1
  TOP w0.089: v2(95.2,2.06) 95.2,1.84 95.63,1.41
  TOP w0.14: 95.63,1.41 95.66,1.38 v1(97.02,1.38) 97.52,1.38 RH70.2 98.81,1.77 CH46.1 98.86,1.8 99.32,1.34 100.27,1.34 100.56,1.05 103.15,1.05 103.93,1.83 YH1.2
  BOTTOM w0.089: v2(95.2,2.06) 95.35,2.21 95.35,2.57 94.84,3.08 94.84,4.26 94.95,4.37 UH2.BD10
PCH_SATA_LED#: length 7.6
  BOTTOM w0.089: UH2.AD44 77.98,14.18 76.9,14.18 76.76,14.04 v1(75.58,14.04) 75.55,14.07 75.06,14.07
  BOTTOM w0.127: RH512.1 71.15,13.9 72.69,13.9 72.86,14.07 75.06,14.07
PCH_SMBCLK: length 395.1
  TOP w0.127: QH4.1 71.89,6.37 70.7,7.57 RH463.2 70.4,7.3 69.19,7.3 67.8,8.69 v2(67.25,8.69)
  TOP w0.14: JXDP.53 129.6,98.51 130.03,98.93 130.51,98.93 130.98,99.4 134.01,99.4 136.01,97.4 136.01,94.72 136.51,94.22 136.51,91.29 137.76,90.05 137.76,88.4 v2(137.93,88.23) ; v2(171.98,16.87) 172.09,16.76 172.09,12.13 175.16,9.06 175.16,7.93 174.73,7.5 171.64,7.5 171.21,7.07 171.21,6.72 v2(171,6.51) ; v2(237.06,50.81) 236.89,50.64 UF1.4
  IN1 w0.099: v2(174.25,21.28) 174.04,21.08 173.49,21.08 173.27,20.86 173.27,20.15 173.04,19.91 161.38,19.91 160.93,20.36 160.93,24.07 159.4,25.6 158.12,25.6 157.79,25.93 157.08,25.93 155.54,27.47 155.54,28.04 152.88,30.7 145.33,30.7 131.51,44.52 131.51,64.15 129.26,66.4 129.26,69.22 130.81,70.77 136.72,70.77 137.44,71.49 137.44,87.34 137.74,87.64 137.74,88.03 v2(137.93,88.23)
  IN3 w0.091: v2(248.98,27.82) 248.02,26.86 248.02,20.89 247.08,19.95 231.03,19.95 230.48,19.4 229.34,19.4 228.58,18.64 178.29,18.64 176.37,20.55 174.98,20.55 v2(174.25,21.28)
  IN6 w0.089: 75.06,6.31 78.2,6.31 78.73,5.79 78.97,5.79 79.8,4.96 81.44,4.96 82.21,4.19 86.4,4.19 86.63,3.96 87.91,3.96 88.57,4.62 92.05,4.62 92.59,5.15 95.4,5.15 96.14,5.9 97.15,5.9 97.82,6.57 99.07,6.57 99.65,7.15 101.28,7.15 101.31,7.18 101.94,7.18 101.95,7.18 101.98,7.18
  IN6 w0.099: 101.98,7.18 104.13,7.18 104.66,7.7 107.48,7.7 107.91,8.14 110.13,8.14 110.5,7.77 116.01,7.77 117.01,8.77 118.44,8.77 118.45,8.77 134.32,8.77 134.99,9.45 144.61,9.45 147.55,6.5 156.41,6.5 157.12,5.8 161.77,5.8 163.23,7.26 165.22,7.26 166.49,5.99 171.03,5.99 171.13,6.09 171.13,6.38 v2(171,6.51) ; 75.06,6.31 72.38,6.31 70.99,7.71 70.99,8.14 70.81,8.32 69.47,8.32 69.1,8.69 v2(67.25,8.69)
  BOTTOM w0.127: JDIMM1.253 172.38,25.43 ; v2(174.25,21.28) 174.98,20.54 174.98,17.94 175.69,17.23 175.69,16.67 175.27,16.25 172.59,16.25 v2(171.98,16.87)
  BOTTOM w0.14: 172.38,25.43 174.25,23.56 v2(174.25,21.28) ; JDIMM2.253 248.68,27.51 v2(248.98,27.82) 249.62,28.46 249.62,30.62 247.59,32.65 247.59,35.01 241.95,40.65 239.27,40.65 235.33,44.59 235.33,45.59 235.13,45.79 233.9,45.79 233.62,46.07 233.62,47.01 234.16,47.56 234.16,48.43 236.09,50.36 236.62,50.36 236.76,50.5 236.76,50.51 v2(237.06,50.81)
PCH_SMBDATA: length 403.8
  TOP w0.14: v2(137.34,88.23) 137.52,88.4 137.52,89.95 136.27,91.19 136.27,94.12 135.77,94.62 135.77,97.3 133.91,99.16 131.08,99.16 130.61,98.69 130.13,98.69 129.7,98.27 129.5,98.27 129.24,98.01 JXDP.51 ; QH4.4 74.88,5.07 74.94,5.01 RH462.2 75.87,5.01 76.03,4.85 v2(76.06,4.85) ; UF1.6 235.08,48.94 234.14,48 v2(234.14,46.24) ; v2(172.57,16.87) 172.33,16.62 172.33,12.23 175.4,9.16 175.4,7.83 174.83,7.26 171.74,7.26 171.45,6.97 171.45,6.65 v2(171.59,6.51)
  IN1 w0.099: v2(174.25,20.68) 174.04,20.88 173.57,20.88 173.47,20.78 173.47,20.04 173.15,19.71 161.29,19.71 160.73,20.27 160.73,23.99 159.32,25.4 158.03,25.4 157.71,25.73 156.99,25.73 155.34,27.38 155.34,27.96 152.8,30.5 145.25,30.5 131.31,44.44 131.31,45.18 131.13,45.36 130.4,45.36 130.22,45.54 130.22,45.79 130.4,45.97 131.13,45.97 131.31,46.15 131.31,64.07 129.06,66.31 129.06,69.3 130.73,70.97 136.64,70.97 137.24,71.57 137.24,87.43 137.54,87.73 137.54,88.03 v2(137.34,88.23)
  IN3 w0.091: v2(174.25,20.68) 174.58,20.68 174.9,20.36 176.29,20.36 178.21,18.44 228.66,18.44 229.42,19.2 230.56,19.2 231.11,19.76 247.16,19.76 248.21,20.81 248.21,24.29 248.68,24.76 249.21,24.76 249.62,24.35 v2(249.62,20.27)
  IN6 w0.089: v2(76.06,4.85) 76.58,5.37 76.81,5.37 76.94,5.5 77.75,5.5 77.84,5.41 78.49,5.41 78.66,5.58 78.91,5.58 79.64,4.85 79.64,2.22 79.71,2.16 80,2.16 80.07,2.23 80.07,4.64 80.2,4.77 81.36,4.77 82.13,4 82.13,2.15 82.24,2.04 82.38,2.04 82.49,2.15 82.49,3.89 82.59,4 83.07,4 83.17,3.89 83.17,3.28 83.28,3.18 83.42,3.18 83.53,3.28 83.53,3.89 83.63,4 83.78,4 83.88,3.89 83.88,3.28 83.99,3.18 84.14,3.18 84.24,3.28 84.24,3.89 84.34,4 84.49,4 84.6,3.89 84.6,3.28 84.7,3.18 84.85,3.18 84.95,3.28 84.95,3.89 85.05,4 85.2,4 85.31,3.89 85.31,3.28 85.41,3.18 85.56,3.18 85.66,3.28 85.66,3.89 85.77,4 86.32,4 86.55,3.77 87.99,3.77 88.65,4.43 92.13,4.43 92.67,4.96 95.72,4.96 95.82,4.86 97.29,4.86 97.54,5.11 97.88,5.11 99.72,6.94 101.35,6.94 101.4,6.99 101.96,6.99 101.96,6.98 101.98,6.98
  IN6 w0.099: 101.98,6.98 104.22,6.98 104.74,7.5 107.56,7.5 107.99,7.94 110.04,7.94 110.21,7.77 110.21,6.69 110.31,6.59 110.51,6.59 110.61,6.69 110.61,7.47 110.71,7.57 111.45,7.57 111.55,7.47 111.55,6.69 111.65,6.59 111.85,6.59 111.95,6.69 111.95,7.47 112.05,7.57 116.1,7.57 117.09,8.57 118.53,8.57 118.53,8.57 134.4,8.57 135.08,9.25 144.52,9.25 147.47,6.3 153.49,6.3 153.59,6.2 153.59,5.69 153.69,5.59 153.89,5.59 153.99,5.69 153.99,6.2 154.09,6.3 154.28,6.3 154.38,6.2 154.38,5.69 154.48,5.59 154.68,5.59 154.78,5.69 154.78,6.2 154.88,6.3 156.33,6.3 157.04,5.6 161.85,5.6 163.31,7.06 165.13,7.06 166.4,5.79 171.12,5.79 171.33,6 171.33,6.26 v2(171.59,6.51)
  BOTTOM w0.14: v2(172.57,16.87) 172.63,16.92 JDIMM1.254 172.63,19.09 173.55,20.01 173.55,20.44 173.79,20.68 v2(174.25,20.68) ; v2(234.14,46.24) 234.34,46.03 235.23,46.03 235.57,45.69 235.57,44.69 239.37,40.89 242.05,40.89 247.83,35.11 247.83,32.75 249.96,30.62 251.65,30.62 252.79,29.47 252.79,26.02 251.61,24.84 251.08,24.84 249.62,23.38 v2(249.62,20.27) 249.62,19.69 248.93,19 JDIMM2.254
PCH_SPI_CLK: length 10
  BOTTOM w0.14: RP4.1 66.85,1.86 66.83,1.84 v3(66.32,1.84) 66.17,1.99 66.17,2.04 65.27,2.94 65.27,3.26 63.69,4.83 62.93,4.83 62.74,5.03 62.74,6.3 62.42,6.61 UH8.6
PCH_SPI_CLK_R: length 168.8
  TOP w0.14: RH579.2 70.25,1.77 v2(70.26,1.76)
  IN1 w0.099: v2(83.88,1.41) 74.11,1.41 73.36,2.16 71.32,2.16 71.12,2.36 70.86,2.36 v2(70.26,1.76)
  IN3 w0.089: 101.98,7.31 100.5,7.31 98.93,5.75 98.93,4.82 98.13,4.02 95.96,4.02 95.88,4.09 95.54,4.09 94.81,4.82 92.31,4.82 92.06,4.57 91.61,4.57 91.48,4.7 89.88,4.7 89.82,4.64 88.5,4.64 87.95,4.09 87.03,4.09 86.69,4.43 85.81,4.43 84.63,3.25 84.1,3.25 83.44,2.59 83.44,1.93 83.88,1.48 v2(83.88,1.41)
  IN3 w0.091: 101.98,7.31 102.32,7.31 102.92,7.91 105.37,7.91 106.36,8.9 107.34,8.9 107.63,9.19 109.35,9.19 109.77,8.77 111.89,8.77 112.13,8.53 112.13,8.01 112.37,7.77 112.97,7.77 113.42,7.32 114.97,7.32 116.97,9.32 117.76,9.32 118.63,10.18 119.15,10.18 121.76,12.8 146.79,12.8 147.53,12.06 151.72,12.06 152.32,11.46 152.32,10.19 152.56,9.94 154.37,9.94 154.77,9.54 155.89,9.54 156.36,10.01 162.91,10.01 164.16,11.26 178.43,11.26 179.11,10.59 186.23,10.59 186.4,10.41 189.05,10.41 191.57,7.89 195.84,7.89 196.28,7.45 200.84,7.45 203.2,9.81 209.57,9.81 209.78,9.61 v2(210.02,9.61)
  BOTTOM w0.089: v2(83.88,1.41) 84.35,1.87 84.35,2.78 84.79,3.22 84.79,4.35 84.89,4.45 84.89,4.61 84.58,4.92 UH2.BC31
  BOTTOM w0.14: v2(70.26,1.76) 70.17,1.85 69.91,1.85 69.79,1.72 69.79,1.48 69.66,1.36 69.46,1.36 69.32,1.49 69.32,1.72 69.18,1.86 RP4.8 ; JSPI1.14 210.79,12.85 210.71,12.76 210.37,12.76 210.36,12.75 ; 210.36,12.75 210.36,9.94 v2(210.02,9.61) ; 210.36,12.75 210.36,13.12 210.29,13.18 JSPI1.13
PCH_SPI_CS1#: length 1.2
  TOP w0.089: T18.1 84.45,6.78 v2(84.02,7.21)
  BOTTOM w0.089: UH2.AW31 v2(84.02,7.21)
PCH_SPI_CS2#: length 84.4
  TOP w0.14: RE126.1 155.53,10.92 v2(155.22,10.61) ; v2(147.74,13.52) 147.74,11.34 147.9,11.18 v1(147.9,10.8) 147.77,10.66 147.77,9.09 148.26,8.59 RE133.1
  IN3 w0.089: 101.98,9.03 98.91,9.03 98.77,8.89 97.89,8.89 97.57,8.57 94.69,8.57 94.34,8.21 93.92,8.21 93.69,8.45 93.69,8.82 93.37,9.14 92.48,9.14 92.18,9.44 89.71,9.44 88.62,8.36 87.01,8.36 86.44,8.92 85.66,8.92 84.89,8.15 v2(84.89,7.97)
  IN3 w0.091: 101.98,9.03 102.04,9.03 103.75,10.74 105.79,10.74 106.15,11.1 109.44,11.1 110.36,10.19 112.58,10.19 113.48,9.28 115.17,9.28 117.14,11.25 118.7,11.25 121.32,13.87 147.24,13.87 147.59,13.52 v2(147.74,13.52) 148.35,13.52 148.55,13.72 152.11,13.72 v2(155.22,10.61)
  BOTTOM w0.089: UH2.AT31 84.46,8.38 84.87,7.97 v2(84.89,7.97)
PCH_SPI_CS2#_R: length 5.4
  TOP w0.14: UE1.20 150.81,7.43 150.62,7.25 148.77,7.25 RE133.2 148.11,7.68 v3(146.94,8.85)
PCH_SPI_CS#: length 174.2
  IN1 w0.076: 75.06,2.97 75.26,2.97 76.01,2.22 83.8,2.22 v2(83.95,2.37)
  IN1 w0.099: v2(69.84,3.73) 70.06,3.95 73.78,3.95 74.61,3.12 74.87,3.12 74.99,3 75.03,3 75.06,2.97
  IN3 w0.089: 101.98,6.71 100.2,6.71 99.11,5.62 99.11,3.62 98.67,3.18 97.87,3.18 97.22,3.84 95.88,3.84 95.8,3.91 95.47,3.91 94.74,4.65 92.39,4.65 92.13,4.39 91.54,4.39 91.41,4.52 89.95,4.52 89.9,4.47 88.58,4.47 88.02,3.91 86.96,3.91 86.62,4.25 85.89,4.25 84.7,3.07 84.58,3.07 83.95,2.43 v2(83.95,2.37)
  IN3 w0.091: 101.98,6.71 102.57,6.71 103.17,7.31 105.98,7.31 106.6,7.93 107.49,7.93 107.7,8.14 110.42,8.14 110.69,7.88 111.42,7.88 112.58,6.72 115.22,6.72 117.22,8.72 118.01,8.72 118.88,9.58 119.39,9.58 122.01,12.2 146.54,12.2 147.75,10.99 150.14,10.99 151.07,10.06 151.07,9.73 151.73,9.07 154.2,9.07 154.32,8.94 158.28,8.94 158.75,9.41 164.53,9.41 165.75,10.63 178.21,10.63 178.86,9.99 185.98,9.99 186.15,9.81 188.8,9.81 191.32,7.29 195.59,7.29 196.03,6.85 202.31,6.85 v2(204.59,9.13)
  BOTTOM w0.089: UH2.BD31 84.58,3.26 83.95,2.63 v2(83.95,2.37)
  BOTTOM w0.14: 209.79,12.74 209.76,12.71 209.45,12.71 209.29,12.86 JSPI1.11 ; 209.79,12.74 JSPI1.12 ; 209.79,12.74 209.79,12.29 209.71,12.21 209.71,10.25 208.85,9.39 206.19,9.39 205.34,8.55 205.16,8.55 204.59,9.12 v2(204.59,9.13) ; v2(69.84,3.73) 69.84,3.73 69.84,3.75 69.85,3.75 69.85,4.58 69.46,4.97 69.46,5.6 69.34,5.72 69.34,6.3 69.34,6.3 69.34,8.96 69.15,9.15 UH8.1 67.75,9.15 67.57,9.34 67.57,9.79 68.11,10.33 v3(68.11,10.98) 68.03,11.06 RH74.2
PCH_SPI_HOLD#: length 4.4
  TOP w0.14: v2(59.95,4.91) 60.51,4.91 RH576.1
  BOTTOM w0.14: UH8.7 60.6,7.88 59.44,6.72 v1(59.44,6.63) 59.44,6.03 59.95,5.52 v2(59.95,4.91)
