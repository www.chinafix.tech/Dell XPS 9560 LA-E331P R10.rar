# Allegro board Dell XPS 9560 LA-E331P R10.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+VCCIO on BOTTOM (solid shape): outline of 763 points within 171.5,69.17 174.32,79.22
+VCCIO on IN3 (solid shape): outline of 429 points within 171.44,69.63 174.3,79.06
+VCCIO on IN4 (solid shape): outline of 230 points within 171.8,70.38 174.12,78.89
+VCCIO on IN5 (solid shape): outline of 10608 points within 116.9,63.32 174.55,73.68
+VCCSA on TOP (solid shape): 120.5,90.39 120.5,89.34 120.53,89.31 120.53,87.34 120.32,87.13 113.95,87.13 113.47,87.61 113.47,90.08 113.88,90.5 120.4,90.5
+VCCSA on TOP (solid shape): outline of 350 points within 169.9,81.89 179.21,86.62
+VCCSA on BOTTOM (solid shape): 120.56,90.48 120.56,87.49 120.21,87.14 119.07,87.14 119.06,87.13 117.6,87.13 117.6,87.14 115.42,87.14 114.94,86.65 114.94,86.32 114.64,86.02 112.87,86.02 112.38,86.51 112.38,88.35 112.41,88.38 114.48,88.38 114.5,88.4 114.5,89.15 114.49,89.16 112.42,89.16 112.38,89.2 112.38,90.55 112.59,90.75 114.87,90.75 115.58,91.45 115.73,91.45 115.96,91.37 116.17,91.51 119.53,91.51
+VCCSA on BOTTOM (solid shape): outline of 464 points within 166.24,79.57 176.33,94.7
+VCCSA on IN5 (solid shape): outline of 11622 points within 115.29,73.86 179.31,101.35
+VCCST on TOP (solid shape): 180.62,80.15 180.62,79.27 180.65,79.24 181.02,79.24 181.13,79.13 181.13,78.52 181,78.38 180.33,78.38 179.93,78.79 179.93,80.15 179.97,80.19 180.58,80.19
+VCCST on TOP (solid shape): 173.78,81.31 174.29,81.31 174.44,81.47 174.54,81.46 174.6,81.47 175.04,81.47 175.11,81.45 175.17,81.44 175.19,81.44 175.25,81.38 175.25,80.75 175.02,80.52 174.59,80.52 174.58,80.52 174.48,80.54 174.38,80.52 174.37,80.52 173.96,80.52 173.94,80.52 173.66,80.43 173.56,80.15 173.56,80.13 173.38,79.94 173.38,78.29 173.28,78.19 172.78,78.19 172.72,78.25 172.72,78.83 172.53,79.03 172.37,79.03 172.14,79.25 172.14,80.03 172.34,80.22 172.73,80.22 172.9,80.39 172.9,80.9 172.72,81.07 172.72,81.75 172.8,81.82 173.27,81.82
+VCCST on IN2 (solid shape): outline of 1391 points within 173.71,63.15 182.48,81.5
+VCCSTG on BOTTOM (solid shape): 181.88,82.12 183.1,82.12 183.19,82.03 183.19,81.3 183.01,81.12 182.14,81.12 181.42,80.4 181.26,80.4 180.82,80.84 180.82,82.42 180.91,82.5 181.49,82.5
+VCCSTG on IN3 (solid shape): 178.71,83.61 178.89,83.61 179,83.64 179.1,83.7 180,83.7 181.28,82.42 183,82.42 183.25,82.17 183.25,81.37 183.03,81.15 180.78,81.15 179.2,82.73 178.78,82.73 178.74,82.74 178.69,82.73 177.45,82.73 177.37,82.81 177.32,82.81 177.31,82.83 177.07,82.92 176.84,82.83 176.82,82.81 176.7,82.81 176.45,82.92 176.19,82.81 175.75,82.81 174.97,82.03 174.94,82.01 174.86,81.93 174.82,81.97 174.41,82.1 174.22,81.71 174.2,81.63 174.12,81.59 173.27,81.59 173.16,81.7 173.16,82.35 173.26,82.45 173.46,82.45 173.51,82.45 173.68,82.45 173.84,82.6 173.84,82.6 174.02,82.78 174.03,82.78 174.07,82.83 174.24,82.83 174.4,82.98 174.53,82.98 174.79,83.24 174.79,83.37 175.09,83.67 175.26,83.67 175.53,83.94 178.32,83.94
AGND on BOTTOM (solid shape): 15.3,43.1 15.3,41.62 15.24,41.55 13.77,41.55 13.61,41.39 13.23,41.39 13.21,41.4 13.21,41.91 13.29,41.98 13.59,41.98 13.79,42.18 13.79,42.89 14.33,43.43 14.98,43.43
AGND on GND1 (solid shape): outline of 1747 points within 1.1,31.89 15.5,59.06
AGND on GND2 (solid shape): outline of 1749 points within 1.1,31.89 15.5,59.06
AGND on GND3 (solid shape): outline of 1730 points within 1.1,31.89 15.51,59.06
AGND on VCC: 2.07,31.89 2.07,47 7.63,47 7.63,47.54 8.78,47.54 8.78,47 10.89,47 10.89,47.55 11.83,47.55 11.83,47 11.9,47 13.45,48.04 13.07,49.86 13.07,53.88 13.45,55.7 11.9,56.74 10.18,56.74 8.4,58.04 6.62,56.74 2.07,56.74 2.07,58.56 4.51,58.56 4.89,58.94 6.78,58.94 6.89,59.05 9.75,59.05 10.06,58.75 10.73,58.75 11.05,59.06 13.04,59.06 13.29,58.81 14.37,58.81 14.55,58.63 14.55,58.01 14.86,57.69 14.86,55.02 15.11,54.77 15.11,53.28 15.5,52.9 15.5,45.33 14.86,44.69 14.86,40.69 14.69,40.52 13.55,40.52 13.23,40.2 11.54,40.2 11.03,40.71 6.12,40.74 5.78,40.4 5.78,38.09 5.48,37.79 3.9,37.79 3.24,37.13 3.24,32.1 3.06,31.89
DV12S on BOTTOM (solid shape): 333.66,38.62 333.91,38.51 334.18,38.53 334.21,38.54 334.33,38.43 334.33,37.79 334.2,37.66 332.08,37.66 331.99,37.75 331.99,38.52 332.09,38.62
DV33_18 on BOTTOM (solid shape): 338.55,40.85 338.59,40.85 338.86,40.57 338.86,40.08 338.86,40.06 338.79,39.99 338.69,40.02 338.64,40.07 338.3,40.07 338.1,40.27 337.33,40.27 337.24,40.36 337.24,41.06 337.29,41.11 338.29,41.11
GND on TOP (solid shape): 26.27,45.39 26.27,44.74 26.15,44.62 25.22,44.62 24.93,44.91 24.93,45.6 24.98,45.64 26.02,45.64
GND on TOP (solid shape): 45.59,20.96 45.59,19.76 45.47,19.63 42.42,19.63 42.23,19.82 42.23,21.03 42.48,21.28 45.28,21.28
GND on TOP (solid shape): 141.85,53.73 141.85,49.3 141.47,48.92 138.14,48.92 137.49,49.56 137.49,54.21 137.91,54.63 140.94,54.63
GND on TOP (solid shape): 155.56,52.6 155.56,49.78 154.81,49.03 152.4,49.03 152.25,49.18 152.25,52.62 152.46,52.84 155.32,52.84
GND on TOP (solid shape): 168.91,76.97 168.91,74.18 168.78,74.05 165.74,74.05 165.48,74.3 165.48,76.72 165.86,77.1 168.78,77.1
GND on TOP (solid shape): 213.17,72.28 213.17,71 213.11,70.94 212.61,70.94 211.96,71.58 211.96,72.1 212.15,72.29 213.17,72.29
GND on TOP (solid shape): 247.02,102.75 247.02,100.66 246.89,100.53 246.38,100.53 245.54,101.37 245.54,102.69 245.73,102.88 246.89,102.88
GND on TOP (solid shape): 343.66,81.2 330.45,81.2 330.45,64.7 343.64,64.7 343.64,63.9 329.62,63.9 329.62,82 343.66,82
GND on TOP (solid shape): 79.88,32.01 79.88,30.37 79.69,30.18 75.64,30.18 75.2,30.63 75.2,31.92 75.85,32.57 79.33,32.57
GND on TOP (solid shape): 48.02,27.98 48.02,26.99 47.51,26.48 46.47,26.48 46.34,26.61 46.34,28.58 46.51,28.74 47.25,28.74
GND on TOP (solid shape): 161.04,99.64 161.82,99.64 161.95,99.51 161.95,96.66 161.76,96.47 159.62,96.47 159.43,96.66 159.43,100.08 159.5,100.15 160.53,100.15
GND on TOP (solid shape): 168.15,109.67 168.15,108.91 167.51,108.28 167.51,107.32 167.2,107.01 166.13,107.01 165.48,107.65 165.48,109.61 165.86,109.99 167.83,109.99
GND on TOP (solid shape): 172.73,50.44 172.73,44.45 172.31,44.03 169.52,44.03 169.29,44.26 169.29,50.81 169.67,51.19 171.98,51.19
GND on TOP (solid shape): 187.96,103.7 187.96,98.56 187.77,98.37 184.47,98.37 184.41,98.43 184.41,99.77 185.29,100.66 185.29,104.09 185.48,104.28 187.39,104.28
GND on TOP (solid shape): 231.51,119.07 231.51,117.65 231.15,117.29 226.14,117.29 225.78,117.65 225.78,119.05 226,119.26 231.32,119.26
GND on TOP (solid shape): 100.81,5.5 100.81,5.17 100.45,4.81 100.45,3.43 100.36,3.34 100.03,3.34 99.77,3.59 99.77,5.42 99.92,5.57 100.74,5.57
GND on TOP (solid shape): 124.7,69.16 124.7,68.4 124.59,68.28 123.32,68.28 121.79,66.76 120.04,66.76 119.91,66.89 119.91,68.29 120.91,69.29 124.58,69.29
GND on TOP (solid shape): 168.64,115.39 168.97,115.39 169.08,115.28 169.08,114.27 168.35,113.54 167.27,113.54 167.09,113.71 167.09,115.76 167.28,115.95 168.08,115.95
GND on TOP (solid shape): 241.45,106.5 241.45,103.73 241.63,103.56 241.63,102.16 241.4,101.94 241.06,101.94 240.27,102.73 240.27,106.9 240.35,106.97 240.98,106.97
GND on TOP (solid shape): 285.18,32.71 285.18,32.08 284.93,31.82 281.94,31.82 281.69,31.57 281.24,31.57 280.99,31.82 280.99,32.71 281.18,32.9 284.99,32.9
GND on TOP (solid shape): 329.5,22.11 329.5,19.76 329.06,19.31 321.69,19.31 321.57,19.44 321.57,20.2 322.04,20.68 324.45,20.68 326.2,22.42 329.19,22.42
GND on TOP (solid shape): 28.06,46.2 28.06,45.82 28.88,45.01 28.88,44.77 28.73,44.62 27.9,44.62 27.77,44.75 27.77,45.02 27.56,45.23 27.56,46.19 27.6,46.23 28.03,46.23
GND on TOP (solid shape): 135.13,9.97 135.13,8.81 134.85,8.53 133.31,8.53 132.22,7.44 128.91,7.44 128.4,7.95 128.4,9.91 128.65,10.17 134.93,10.17
GND on TOP (solid shape): 184.24,13.34 184.24,11.77 183.94,11.46 179.79,11.46 179.53,11.2 178.37,11.2 178.3,11.27 178.3,12.92 178.56,13.19 182.14,13.19 182.46,13.51 184.07,13.51
GND on TOP (solid shape): 242.4,9.58 242.4,8.27 242.36,8.23 240.2,8.23 240.14,8.28 240.14,8.94 240.19,8.99 240.56,8.99 240.78,9.22 240.78,9.6 240.89,9.7 242.28,9.7
GND on TOP (solid shape): 21.08,110.87 21.08,109.48 20.96,109.36 19.64,109.36 19.51,109.48 19.51,109.74 19.37,109.88 18.67,109.88 18.47,110.08 18.47,110.8 18.6,110.94 21.02,110.94
GND on TOP (solid shape): 31.45,44.36 31.45,43.87 31.52,43.8 31.85,43.8 31.93,43.72 31.93,42.78 31.78,42.63 31.27,42.63 30.99,42.91 30.99,44.36 31.04,44.41 31.4,44.41
GND on TOP (solid shape): 181.78,116.25 181.78,114.56 181.76,114.54 180.67,114.54 180.58,114.62 180.14,114.62 180.06,114.69 180.06,116.25 180.09,116.27 181.76,116.27
GND on TOP (solid shape): 165.99,105.55 165.99,101.35 165.67,101.04 163.51,101.04 162.75,101.8 162.75,104.7 163.09,105.04 163.09,105.47 163.2,105.57 165.97,105.57
GND on TOP (solid shape): 326.26,10.8 326.26,9.09 327.34,8.01 327.72,8.01 327.85,7.88 327.85,6.49 327.66,6.3 321.97,6.3 321.82,6.45 321.82,11.25 322.01,11.44 325.63,11.44
GND on TOP (solid shape): 118.87,59.64 118.87,56.52 118.56,56.21 114.45,56.21 114.27,56.39 114.27,59.64 114.64,60.02 118.49,60.02
GND on TOP (solid shape): 238.56,47.32 238.56,46.95 238.61,46.9 239.1,46.9 239.2,46.8 239.2,46.31 239.07,46.17 237.88,46.17 237.73,46.33 237.73,47.32 237.83,47.42 238.46,47.42
GND on TOP (solid shape): 243.08,119.58 243.08,117.74 241.68,116.34 238.25,116.34 237.49,115.58 236.48,115.58 236.41,115.64 236.41,116.59 236.6,116.79 239.33,116.79 240.73,117.48 242,118.75 242,119.39 242.38,119.77 242.89,119.77
GND on TOP (solid shape): 294.29,6.84 294.29,6.26 294.15,6.12 294.15,4.84 293.96,4.66 292.7,4.66 292.61,4.74 292.61,5.49 292.76,5.64 292.76,6.83 292.91,6.98 294.15,6.98
GND on TOP (solid shape): 6.93,68.77 8.97,68.77 9.08,68.66 9.08,68.45 8.95,68.32 7.16,68.32 7.09,68.26 6.36,68.26 6.25,68.37 6.22,68.44 6.18,68.49 6.18,68.79 6.38,68.99 6.71,68.99
GND on TOP (solid shape): 179.79,82.15 179.79,81.78 180.24,81.33 180.71,81.33 180.88,81.15 180.88,80.57 180.8,80.49 180.14,80.49 179.76,80.87 178.74,80.87 178.44,81.17 178.44,81.88 178.58,82.02 178.96,82.02 179.18,82.24 179.71,82.24
GND on TOP (solid shape): 252.99,29.49 252.99,26.23 252.41,25.66 251.11,25.66 250.92,25.85 250.92,27.01 251.2,27.29 251.2,27.79 251.45,28.04 251.45,28.74 251.93,29.22 251.93,29.74 252.06,29.87 252.6,29.87
GND on TOP (solid shape): 84.94,35.31 85.14,35.31 86.06,34.4 86.06,33.38 85.78,33.11 82.58,33.11 82.22,33.46 82.22,34.07 82.53,34.38 82.88,34.38 83.11,34.6 83.11,35.19 83.24,35.31 83.44,35.31 83.85,35.72 84.53,35.72
GND on TOP (solid shape): 110.81,59.7 110.81,56.33 110.24,55.76 107.89,55.76 107.76,55.89 107.76,56.14 107.89,56.27 107.89,57.1 107.7,57.29 107.7,59.57 108.08,59.95 110.55,59.95
GND on TOP (solid shape): 119.44,86.89 119.44,86.38 119.27,86.21 119.1,86.21 118.62,85.73 118.62,85.16 118.43,84.97 118.42,84.97 118.31,84.86 115.49,84.86 115.19,85.16 115.19,86.81 115.32,86.94 119.39,86.94
GND on TOP (solid shape): 277.3,29.64 277.3,27.47 276.98,27.15 273.66,27.15 273.37,27.44 273.37,29.03 273.5,29.16 274.38,29.16 274.58,28.96 275.4,28.96 275.53,29.09 275.53,29.73 275.72,29.92 277.02,29.92
GND on TOP (solid shape): 57.15,4.39 57.15,3.6 57.05,3.5 55.92,3.5 55.81,3.38 55.81,2.3 56.15,1.96 56.43,1.96 56.45,1.93 56.45,1.41 56.4,1.35 55.84,1.35 55.72,1.48 55.72,1.72 55.03,2.41 55.03,4.29 55.19,4.45 57.09,4.45
GND on TOP (solid shape): 203.58,72.02 203.58,71.83 203.01,71.26 203.01,70.49 203.52,69.99 203.52,69.8 203.33,69.6 203.26,69.6 203.14,69.48 203.14,68.97 202.88,68.72 202.88,66.62 202.76,66.49 202.38,66.49 202.31,66.56 202.31,71.83 201.99,72.14 201.99,72.53 202.25,72.78 202.82,72.78
GND on TOP (solid shape): 122.84,4.49 122.84,2.43 122.72,2.31 120.61,2.31 120.42,2.5 120.42,3.35 120.33,3.44 119.19,3.44 118.99,3.64 118.99,3.95 118.89,4.05 118.39,4.05 118.25,4.19 118.25,5.12 118.31,5.18 122.14,5.18
GND on TOP (solid shape): 11.31,39.68 11.31,38.61 11.56,38.36 12.25,38.36 12.28,38.33 12.28,37.91 12.04,37.67 12.04,36.92 11.89,36.77 11.89,36.26 11.75,36.11 5.94,36.11 5.63,36.43 4.83,36.43 4.57,36.69 4.2,36.69 4.12,36.76 4.12,37.09 4.25,37.22 5.65,37.22 6.35,37.92 6.35,40.14 6.42,40.21 10.78,40.21
GND on TOP (solid shape): 213.3,115.9 213.3,112.59 212.98,112.28 212.28,112.28 211.96,112.59 211.96,113.42 211.9,113.48 211.84,113.48 211.8,113.52 210.08,113.52 209.98,113.53 209.89,113.52 208.76,113.52 208.66,113.53 208.57,113.52 204.43,113.52 204.22,113.74 204.22,115.58 204.66,116.02 213.17,116.02
GND on TOP (solid shape): 112.21,96.47 112.21,96.45 112.43,96.22 112.43,95.13 112.41,94.99 112.43,94.86 112.43,94.65 112.21,94.42 112.21,92.53 111.44,91.77 104.52,91.77 104.46,91.83 104.46,94.24 104.59,94.37 105.09,94.37 105.28,94.18 105.28,93.16 105.54,92.91 107.89,92.91 108.27,93.29 108.27,96.78 108.59,97.1 111.57,97.1
GND on TOP (solid shape): 336.11,18.36 336.11,17.73 336.23,17.6 337.57,17.6 337.82,17.85 337.82,18.36 337.95,18.49 338.71,18.49 338.89,18.31 340.82,18.31 341.06,18.08 341.06,16.01 340.23,15.19 334.27,15.19 333.95,15.5 333.95,16.71 333.76,16.9 332.55,16.9 332.42,16.77 331.79,16.77 331.73,16.84 331.73,17.34 331.98,17.6 332.87,17.6 333.76,18.49 335.98,18.49
GND on TOP (solid shape): 112.1,85.97 112.1,84.23 110.06,82.19 110.06,76.89 110.55,76.4 112.33,76.4 112.52,76.21 112.52,74.62 112.33,74.43 109.92,74.43 107.95,72.46 107,72.46 106.81,72.65 106.81,75.38 107.34,75.92 107.34,76.77 107.88,77.31 107.88,78.34 107.53,78.69 107.53,82.83 107.54,82.83 107.54,82.98 108.01,83.46 108.01,86.05 108.21,86.24 111.82,86.24
GND on TOP (solid shape): 7.35,63.22 8.34,63.22 8.49,63.07 8.49,62.85 8.4,62.76 7.64,62.76 7.34,62.92 7,62.9 6.99,62.9 6.95,62.9 6.92,62.87 6.78,62.78 6.68,62.66 6.39,62.66 6.21,62.84 6.21,63.17 6.24,63.23 6.27,63.3 6.32,63.35 7.21,63.35
GND on TOP (solid shape): 99.15,45.87 99.33,45.75 99.49,45.61 100.77,44.08 101,43.35 100.65,42.67 98.73,41.06 96.16,44.12 95.17,45.12 95.17,45.44 95.81,46.08 96.66,47.62 96.86,47.84 97.17,47.84
GND on TOP (solid shape): 89.27,38.34 91.84,35.28 89.92,33.67 89.19,33.44 88.51,33.79 87.23,35.32 87.02,35.74 87.02,36.2 87.21,38.69 87.61,38.96 88.09,39.1 88.51,39.1
GND on TOP (solid shape): 4.7,44.38 4.7,43.81 4.53,43.64 4.53,43.5 4.5,43.46 4.5,43.15 4.53,43.11 4.53,43.06 4.75,42.84 4.75,42.45 4.62,42.32 3.64,42.32 3.55,42.37 3.56,42.48 3.58,42.8 3.31,42.99 3.26,42.99 3.26,43.04 3.26,44.1 3.6,44.44 4.64,44.44
GND on TOP (solid shape): 32.51,21.46 32.51,17.98 32.45,17.92 30.93,17.92 30.56,17.55 30.56,17.53 30.51,17.48 30.51,16.49 30.74,16.26 30.74,16.07 30.61,15.95 28.89,15.95 28.75,16.09 28.59,16.09 28.09,16.58 28.09,18.83 28.51,19.25 29.21,19.25 29.31,19.15 29.31,18.16 29.45,18.02 30.37,18.02 30.99,18.64 30.99,19.06 31.15,19.22 31.15,21.08 30.94,21.29 30.94,21.87 31.1,22.03 31.94,22.03
GND on TOP (solid shape): 147.29,120.31 151.6,120.31 152.4,119.52 152.4,117.99 152.15,117.74 151.07,117.74 151.05,117.75 149.89,116.59 147.82,116.59 145.1,113.86 145.1,107.68 144.6,107.18 144.6,106.51 144.27,106.18 143.77,106.18 143.7,106.24 143.7,107.59 143.25,108.04 141.59,108.04 141.05,108.58 141.05,111.87 140.97,111.96 140.97,114.05 141.16,114.25 141.16,116.04 140.97,116.23 140.55,116.23 140.52,116.26 140.52,116.8 140.55,116.83 141.01,116.83 141.16,116.98 141.16,117.55 141.07,117.64 140.51,117.64 140.47,117.68 140.47,120.1 140.69,120.32 147.28,120.32
GND on TOP (solid shape): 13.04,20.86 13.04,19.52 13.2,19.36 13.2,18.37 13.04,18.21 12.01,18.21 11.72,18.49 11.69,18.57 11.73,18.65 11.8,19.15 11.29,19.2 11.22,19.18 11.16,19.2 11.12,19.23 11.06,19.26 10.93,19.39 10.93,20.88 11.04,20.99 12.91,20.99
GND on TOP (solid shape): 194.95,109.93 194.95,104.47 194.82,104.34 193.1,104.34 192.91,104.15 192.91,103.13 192.85,103.07 192.85,102.75 192.91,102.69 192.91,102.41 192.88,102.24 192.91,102.08 192.91,101.77 192.88,101.61 192.91,101.45 192.91,101.14 192.88,100.97 192.91,100.81 192.76,100.66 191.52,100.66 191.33,100.85 191.33,102.37 191.45,102.5 191.71,102.5 191.96,102.75 191.96,104.02 190.95,105.04 189.1,105.04 188.91,104.85 185.1,104.85 184.79,105.16 184.79,108.02 184.98,108.21 186.5,108.21 187.52,109.23 187.53,109.23 187.64,109.34 189.32,109.34 189.43,109.23 190.82,109.23 191.07,108.97 192.6,108.97 193.1,109.48 193.1,109.86 193.36,110.12 194.76,110.12
GND on TOP (solid shape): 58.42,31.97 58.51,31.93 58.52,31.83 58.62,31.44 59.03,31.4 59.13,31.4 59.18,31.31 59.18,29.98 59.5,29.66 60.71,29.66 60.95,29.91 60.95,30.28 61.1,30.43 62.42,30.43 62.55,30.3 62.55,29.47 62.2,29.12 58.43,29.12 58.32,29.23 57.69,29.23 57.44,29.49 57.44,29.51 57.33,29.78 57.05,29.86 57.02,29.86 56.64,30.23 56.64,31.82 56.79,31.97
GND on TOP (solid shape): 210.57,66.87 210.57,65.73 210.76,65.54 211.32,65.54 211.57,65.29 211.92,65.29 212.17,65.54 213.95,65.54 214,65.49 214,64.99 213.03,64.02 210.44,64.02 210.37,64.05 210.34,64.14 210.21,64.49 209.83,64.52 209.42,64.52 209.25,64.62 209.05,64.61 208.96,64.62 208.92,64.7 208.92,65.35 209.08,65.52 209.08,66.39 209.12,66.43 209.25,66.43 209.32,66.43 209.61,66.43 210.19,67 210.44,67
GND on TOP (solid shape): 163.46,116.38 163.46,113.71 163.25,113.49 162.32,113.49 162.16,113.34 162.13,113.3 162,113.17 161.83,113.17 161.57,112.91 161.57,112.43 161.29,112.15 160.66,112.15 160.4,111.9 160.4,111.01 160.27,110.88 159.58,110.88 159.45,111.01 159.45,111.9 158.72,112.63 154.59,112.63 153.99,113.23 153.99,113.23 153.91,113.31 153.91,115.49 154.35,115.93 155.05,115.93 155.69,115.29 156.25,115.29 156.35,115.29 156.45,115.33 156.46,115.33 157.45,115.33 157.46,115.33 157.63,115.29 157.79,115.33 157.8,115.33 158.8,115.33 158.81,115.33 158.97,115.29 159.14,115.33 159.17,115.33 159.25,115.41 159.34,115.51 159.34,116.04 159.64,116.34 160.91,116.34 161.29,116.72 163.12,116.72
GND on TOP (solid shape): 208.67,64.27 208.76,64.28 208.82,64.2 208.87,64.08 208.97,63.98 208.97,63.73 208.8,63.26 209.28,63.09 209.38,63.09 209.42,63 209.42,62.37 208.73,61.67 208.73,61.64 208.49,61.41 208.49,61.01 208.45,60.97 208.09,60.97 208.09,60.97 207.84,60.97 207.76,61.05 207.76,61.77 207.76,61.95 207.8,61.99 207.8,62.37 207.81,62.41 207.8,62.45 207.8,63.13 207.84,63.17 207.84,63.27 207.85,63.37 207.84,63.48 207.84,64.14 207.96,64.27
GND on TOP (solid shape): 21.14,49.78 23.87,49.78 23.95,49.71 23.95,47.91 23.8,47.76 23.36,47.76 23.36,47.77 22.85,47.77 22.71,47.9 22.71,47.94 22.73,47.96 22.73,48.71 22.61,48.84 22.47,48.84 21.54,48.84 21.46,48.84 21.21,48.59 21.21,47.13 21.21,47.12 22.24,46.09 22.49,46.09 22.66,45.92 22.66,45.15 22.6,45.1 21.84,45.1 21.83,45.13 21.74,45.26 21.6,45.33 21.59,45.33 21.11,45.8 21.07,45.8 20.86,46.01 20.86,46.05 20.83,46.05 20.07,46.81 20.07,47.36 20.1,47.38 20.29,47.62 20.21,47.92 20.19,47.99 20.21,48.05 20.29,48.36 20.1,48.6 20.07,48.62 20.07,49.41 20.45,49.79 21.14,49.79
GND on TOP (solid shape): 345.95,120 343.2,117.25 340.45,120 340.45,121.1 341.57,121.1 341.63,121.1 344.35,121.1 344.35,121.8 344.64,122.51 345.35,122.8 345.95,122.8
GND on TOP (solid shape): outline of 95 points within 174.9,22.84 177.83,29.31
GND on TOP (solid shape): outline of 95 points within 47.38,1.47 53.91,6.6
GND on TOP (solid shape): 192.02,117.48 194.31,117.48 194.44,117.36 194.44,113.42 194.69,113.17 195.52,113.17 195.77,112.91 195.77,111.22 195.66,111.11 195.64,111.11 195.42,110.98 195.39,110.73 195.4,110.7 195.14,110.44 192.6,110.44 192.36,110.54 192.11,110.44 191.71,110.44 191.52,110.63 190.57,110.63 190.56,110.67 190.24,110.99 189.87,110.74 189.83,110.68 189.76,110.66 189.66,110.66 189.57,110.63 189.56,110.63 189.09,110.63 187.11,110.63 187.1,110.63 186.95,110.66 186.79,110.63 186.78,110.63 186.47,110.63 186.46,110.63 186.31,110.66 186.16,110.63 186.15,110.63 185.99,110.63 185.8,110.82 185.8,112.02 185.99,112.21 189.49,112.21 190.12,112.85 190.12,114.6 190.39,114.87 190.39,116.73 190.13,116.99 188.86,116.99 188.64,117.22 188.64,118.01 188.74,118.1 191.4,118.1
GND on TOP (solid shape): 10.21,77.68 10.67,77.22 12.38,77.22 12.51,77.1 12.51,76.53 12.19,76.21 11.02,76.21 10.69,75.89 9.8,74.95 8.6,75.42 5.72,75.42 4.92,74.62 3.18,74.62 2.38,75.42 1.9,75.42 1.66,75.32 1.56,75.08 1.56,72.91 1.1,72.91 1.1,75.08 1.34,75.64 1.9,75.88 8.88,75.88 10.05,75.58 9.75,76.75 9.75,78.45 10.21,78.45
GND on TOP (solid shape): outline of 119 points within 20.85,36.16 24.41,44.57
GND on TOP (solid shape): outline of 119 points within 6.91,11.85 11.59,15.26
GND on TOP (solid shape): 17.81,20.92 18.46,20.92 18.66,20.72 18.66,20.71 18.85,20.46 19.15,20.54 19.24,20.54 19.51,20.28 19.51,20.09 19.12,19.7 18.94,19.7 18.75,19.52 18.75,19.45 18.75,19.44 18.75,18.23 18.75,18.22 18.75,18 18.99,17.76 21.71,17.76 22.29,17.18 22.29,16.35 21.92,15.99 18.99,15.99 18.47,15.46 18.47,15.45 18.35,15.34 18.35,13.92 17.34,12.9 17.34,11.18 18.67,9.85 18.67,6.49 17.08,4.9 14.1,4.9 12.7,6.3 12,6.3 11.99,6.32 11.89,6.44 11.75,6.49 11.73,6.49 11.62,6.6 11.62,10.04 11.69,10.11 12.57,10.11 14.03,11.57 14.03,12.65 14.61,13.22 15.24,13.22 15.81,13.79 15.81,17.73 16.1,18.01 16.21,18.03 16.27,17.94 16.27,16.12 18.33,16.12 18.33,18.38 17.91,18.38 17.82,18.43 17.83,18.54 17.61,19.58 16.57,19.36 16.46,19.32 16.38,19.41 16.38,20.88 16.43,20.93 17.81,20.93
GND on TOP (solid shape): outline of 204 points within 233.9,51.81 249.18,56.5
GND on TOP (solid shape): outline of 244 points within 201.11,79.73 204.34,82.88
GND on TOP (solid shape): outline of 359 points within 1.1,88.95 23.02,112.8
GND on TOP (solid shape): outline of 532 points within 168.44,94.43 180.34,110.46
GND on TOP (solid shape): outline of 294 points within 0.2,0.2 352.5,109.23
GND on TOP (solid shape): outline of 296 points within 22.94,33.74 351.6,122.6
GND on BOTTOM (solid shape): 102.85,54.95 119.3,54.95 119.3,54.15 102.25,54.15 102.25,56.6 102.85,56.6
GND on BOTTOM (solid shape): 153.49,99.23 153.49,96.62 153.26,96.39 150.35,96.39 150.03,96.71 150.03,98.94 150.49,99.41 153.31,99.41
GND on BOTTOM (solid shape): 165.99,104.72 165.99,101.35 165.61,100.97 163.58,100.97 162.75,101.8 162.75,104.78 162.88,104.91 165.8,104.91
GND on BOTTOM (solid shape): 184.33,13.48 184.33,11.39 184.07,11.13 179.34,11.13 179.03,11.44 179.03,13.25 179.68,13.9 183.91,13.9
GND on BOTTOM (solid shape): 205.47,14.26 205.47,13.04 205.37,12.94 203.58,12.94 203.33,13.19 203.33,14.18 203.53,14.39 205.35,14.39
GND on BOTTOM (solid shape): 21.72,24.46 21.72,23.17 21.61,23.06 20.66,23.06 20.45,23.27 20.45,24.46 20.58,24.58 21.59,24.58
GND on BOTTOM (solid shape): 345.8,81.2 334.4,81.2 334.4,64.7 345.8,64.7 345.8,63.9 333.6,63.9 333.6,82 345.8,82
GND on BOTTOM (solid shape): 28.73,81.99 28.73,76.52 28.01,76.52 27.86,76.67 27.86,79.33 27.67,79.52 26.61,79.52 26.38,79.75 26.38,81.73 26.73,82.08 28.63,82.08
GND on BOTTOM (solid shape): 45.28,21.28 45.54,21.28 45.84,20.98 45.84,19.8 45.67,19.63 42.42,19.63 42.23,19.82 42.23,21.03 42.48,21.28 45.28,21.28
GND on BOTTOM (solid shape): 122.64,4.68 122.64,2.77 122.16,2.28 119.94,2.28 119.77,2.45 118.55,2.45 118,2.99 118,5 118.22,5.22 122.11,5.22
GND on BOTTOM (solid shape): 136.3,118.96 136.3,116.31 135.76,115.77 133,115.77 132.81,115.96 132.81,118.94 132.94,119.07 136.19,119.07
GND on BOTTOM (solid shape): 11.17,68.14 11.95,68.14 12.05,68.04 12.05,67.88 12.37,67.56 12.37,66.61 12.24,66.48 10.6,66.48 9.86,67.23 9.86,67.81 10.39,68.34 10.97,68.34
GND on BOTTOM (solid shape): 201.68,110.05 201.68,107.2 200.92,106.43 200.92,104.09 200.72,103.89 199.9,103.89 199.77,104.02 199.77,106.88 200.72,107.83 200.72,110.18 200.92,110.37 201.36,110.37
GND on BOTTOM (solid shape): 247.02,102.82 247.02,100.66 246.96,100.6 245.71,100.6 245.49,100.82 245.49,102.62 245.75,102.88 246.96,102.88
GND on BOTTOM (solid shape): 69.18,5.54 69.18,4.39 68.96,4.16 68.69,4.16 68.68,4.17 67.86,4.99 67.59,4.99 67.43,5.15 67.43,5.51 67.59,5.68 69.05,5.68
GND on BOTTOM (solid shape): 55.4,20.66 55.49,20.66 55.64,20.51 55.64,19.5 55.55,19.41 54.2,19.41 53.56,18.77 53.37,18.77 52.77,19.36 52.77,19.6 53.83,20.67 55.39,20.67
GND on BOTTOM (solid shape): 177.45,36.74 177.45,27.25 177.23,27.03 176.06,27.03 175.74,27.35 175.74,28.68 176.23,29.16 176.23,30.86 175.23,31.85 172.84,31.85 172.58,32.11 172.58,36.7 172.76,36.88 177.31,36.88
GND on BOTTOM (solid shape): 231.78,119.1 231.78,117.73 231.41,117.36 225.86,117.36 225.62,117.6 225.62,118.88 225.93,119.2 231.67,119.2
GND on BOTTOM (solid shape): 241.01,11.01 241.01,9.94 240.88,9.81 240.7,9.81 240.63,9.74 240.63,9.22 240.49,9.08 239.42,9.08 239.21,9.29 239.21,9.65 239.21,11.08 239.23,11.11 240.91,11.11
GND on BOTTOM (solid shape): 287.97,28.6 287.97,27.12 287.34,26.49 287.02,26.49 286.96,26.55 286.96,26.81 287.75,27.6 287.75,28.59 287.82,28.66 287.91,28.66
GND on BOTTOM (solid shape): 100.82,5.5 100.82,5.24 100.55,4.97 99.77,4.97 99.59,4.8 99.28,4.8 98.92,4.44 98.75,4.44 98.68,4.52 98.68,5.19 99.11,5.63 99.11,6.01 99.22,6.12 100.21,6.12
GND on BOTTOM (solid shape): 118.89,59.75 118.89,56.66 118.11,55.89 114.3,55.89 114.17,56.02 114.17,56.52 114.36,56.71 114.8,56.71 114.91,56.83 114.91,56.96 114.9,56.97 114.9,59.85 115.06,60.02 118.62,60.02
GND on BOTTOM (solid shape): 131.56,118.98 131.56,116.07 131.26,115.77 128.59,115.77 128.59,115.77 128.54,115.77 128.53,115.78 128.17,115.78 128.01,115.94 128.01,118.89 128.19,119.07 131.47,119.07
GND on BOTTOM (solid shape): 188,101.49 188,97.27 187.67,96.94 184.5,96.94 184.48,96.96 184.48,100.24 184.49,100.25 184.49,101 184.82,101.32 187.24,101.32 187.37,101.45 187.37,101.49 187.52,101.63 187.86,101.63
GND on BOTTOM (solid shape): 78.06,26.04 78.25,25.85 78.25,25.46 78.4,25.31 78.4,25.18 78.3,25.08 78.24,25.09 78.01,25.09 77.86,25.24 77.25,25.24 76.57,25.92 76.57,26.23 76.8,26.46 77.63,26.46
GND on BOTTOM (solid shape): 105.28,94.28 105.28,93.59 105.52,93.36 106.08,93.36 106.18,93.26 106.18,92.54 105.95,92.31 104.32,92.31 104.14,92.49 104.14,94.19 104.4,94.45 105.12,94.45
GND on BOTTOM (solid shape): 161.94,81.57 161.94,81.38 161.56,81 161.56,80.37 161.43,80.24 161.21,80.24 161.12,80.34 161.12,81.21 161.29,81.39 161.29,81.42 161.59,81.72 161.8,81.72
GND on BOTTOM (solid shape): 179.38,111.27 179.38,110.41 179.77,110.01 179.77,96.7 179.46,96.39 179.46,93.73 179.07,93.34 176.98,93.34 176.76,93.56 176.76,96.55 177.74,97.52 177.74,103.61 178.37,104.25 178.37,111.31 178.48,111.42 179.23,111.42
GND on BOTTOM (solid shape): 330.31,70.1 330.31,67.46 330.54,67.24 330.54,66.64 330.45,66.54 329.88,66.54 329.78,66.64 329.67,66.64 329.66,66.65 328.71,66.65 328.59,66.76 328.59,68.35 329.24,69 329.24,70.18 329.33,70.27 330.14,70.27
GND on BOTTOM (solid shape): 109.03,36.86 109.03,32.14 108.79,31.9 105.25,31.9 105.14,32 105.14,34.05 105.2,34.24 105.14,34.42 105.14,36.56 105.97,37.39 108.5,37.39
GND on BOTTOM (solid shape): 154.82,81.61 154.82,81.42 154.45,81.05 154.45,80.3 154.38,80.24 154.13,80.24 154,80.37 154,81 153.62,81.38 153.62,81.57 153.75,81.7 153.94,81.7 154.09,81.56 154.35,81.56 154.52,81.72 154.71,81.72
GND on BOTTOM (solid shape): 119.37,86.88 119.37,86.14 119.29,85.98 119.29,85.8 118.35,84.85 115.69,84.85 115.32,85.23 115.32,86.57 115.69,86.94 119.3,86.94
GND on BOTTOM (solid shape): 151.76,81.53 151.95,81.53 152.16,81.73 152.32,81.73 152.48,81.57 152.48,81.38 152.1,81 152.1,80.37 151.97,80.24 151.72,80.24 151.65,80.3 151.65,81.01 151.27,81.4 151.27,81.59 151.41,81.73 151.56,81.73
GND on BOTTOM (solid shape): 157.17,81.59 157.17,81.4 156.8,81.02 156.8,80.3 156.73,80.24 156.48,80.24 156.35,80.37 156.35,81 155.97,81.38 155.97,81.57 156.1,81.7 156.29,81.7 156.44,81.56 156.69,81.56 156.87,81.73 157.03,81.73
GND on BOTTOM (solid shape): 166.85,109.81 167.88,109.81 168.02,109.67 168.02,108.72 167.45,108.15 167.45,107.2 167.26,107.01 166.12,107.01 165.93,107.2 165.93,108.91 165.74,109.1 165.61,109.1 165.48,109.23 165.48,109.49 165.92,109.93 166.74,109.93
GND on BOTTOM (solid shape): 168.94,95.39 168.94,94.85 169.16,94.62 169.16,91.8 169.48,91.48 171.96,91.48 172.03,91.41 172.03,90.78 172.01,90.75 166.94,90.75 166.75,90.56 165.93,90.56 165.61,90.88 165.61,94.37 165.62,94.38 165.62,94.66 166.63,95.68 168.65,95.68
GND on BOTTOM (solid shape): 244.11,13.07 244.11,10.95 243.52,10.36 242.66,10.36 242.45,10.16 242.45,9.31 242.27,9.13 240.91,9.13 240.76,9.28 240.76,9.64 240.81,9.69 241.07,9.69 241.26,9.87 241.26,11.01 240.7,11.56 240.7,13.37 240.9,13.57 243.61,13.57
GND on BOTTOM (solid shape): 78.86,4.71 78.86,4.52 78.74,4.4 78.36,4.4 78.26,4.3 78.26,2.64 78.11,2.49 77.85,2.49 77.71,2.63 77.71,3.17 77.53,3.35 77.53,4.58 77.63,4.67 77.81,4.67 77.9,4.77 78.79,4.77
GND on BOTTOM (solid shape): 112.33,96.15 112.37,96.11 112.37,93.78 111.32,92.72 110.37,92.72 110.2,92.88 109.73,92.88 109.63,92.99 109.63,94.47 109.62,94.48 109.62,94.95 109.34,95.23 108.35,95.23 108.33,95.25 108.33,96.67 108.4,96.74 111.74,96.74
GND on BOTTOM (solid shape): 194.95,110.05 194.95,104.59 194.37,104.02 192.72,104.02 192.6,104.15 192.6,104.78 192.22,105.16 187.39,105.16 187.01,104.78 184.98,104.78 184.91,104.85 184.91,108.28 185.23,108.59 187.01,108.59 187.45,109.04 192.66,109.04 192.79,109.17 192.79,110.31 192.85,110.37 194.63,110.37
GND on BOTTOM (solid shape): 257.81,35.37 258.45,35.37 258.65,35.16 260.88,35.16 261.14,34.91 261.14,33.9 260.91,33.67 260.52,33.67 260.25,33.39 256.82,33.39 256.79,33.43 255.63,33.43 254.92,34.15 254.92,36.46 255.55,37.09 256.08,37.09
GND on BOTTOM (solid shape): 173.17,109.17 173.17,104.21 172.66,103.7 172.66,98.31 172.91,98.05 172.91,94.76 172.65,94.5 171.45,94.5 171.06,94.89 169.32,94.89 169.13,95.08 169.13,96.1 169.36,96.33 169.36,98.12 168.85,98.62 168.85,103.89 169.67,104.72 169.67,108.66 170.05,109.04 170.05,109.29 170.75,109.99 172.34,109.99
GND on BOTTOM (solid shape): 263.26,17.46 263.26,15.78 263.13,15.65 261.53,15.65 261.29,15.89 259.77,15.89 259.69,15.96 259.69,16.13 259.78,16.22 261.37,16.22 261.8,16.65 261.8,17 261.41,17.38 259.79,17.38 259.7,17.47 259.7,17.64 259.78,17.72 261.23,17.72 261.27,17.76 262.95,17.76
GND on BOTTOM (solid shape): 133.99,11.12 133.99,8.14 133.86,8.01 133.41,8.01 132.93,7.52 132.93,5.05 131,5.05 131,5.3 132.28,5.3 132.28,6.93 130.85,6.93 130.55,7.22 130.55,7.94 130.77,8.15 131,8.15 131.19,8.34 131.19,9.28 130.94,9.53 128.76,9.53 128.54,9.76 128.54,11.07 128.84,11.38 133.73,11.38
GND on BOTTOM (solid shape): 163.49,81.63 163.58,81.55 163.77,81.55 163.79,81.57 163.85,81.57 163.97,81.7 164.16,81.7 164.29,81.57 164.29,81.38 163.91,81 163.91,80.37 163.78,80.24 163.53,80.24 163.47,80.3 163.47,80.98 163.07,81.37 163.07,81.59 163.21,81.73 163.4,81.73
GND on BOTTOM (solid shape): 249.15,109.08 249.15,107.28 248.35,106.48 248.35,105.8 248.22,105.67 245.49,105.67 245.3,105.48 245.3,104.69 245.23,104.62 245.09,104.62 244.92,104.78 244.92,106.43 245.05,106.56 246.38,106.56 246.54,106.72 246.54,107.53 246.77,107.77 248.02,107.77 248.23,107.98 248.23,109.17 248.33,109.26 248.97,109.26
GND on BOTTOM (solid shape): 116.65,93.73 117.35,93.73 117.41,93.67 117.41,93.29 117.22,93.1 116.03,93.1 116.03,93.15 115.87,93.42 115.56,93.46 115.53,93.45 115.29,93.7 115.29,94.01 115.37,94.09 116.29,94.09
GND on BOTTOM (solid shape): 144.66,81.54 144.88,81.54 145.05,81.71 145.29,81.71 145.41,81.58 145.41,81.37 145.34,81.31 145.29,81.24 145.29,81.23 145.2,81.14 145.2,80.45 144.98,80.23 144.45,80.23 144.29,80.39 144.29,81.23 144.13,81.4 144.13,81.57 144.27,81.71 144.49,81.71
GND on BOTTOM (solid shape): 32.07,21.55 34.52,21.55 35.75,20.32 35.75,17.09 35.57,16.91 32.4,16.91 32.07,16.58 32.07,16.01 31.81,15.76 29.19,15.76 28.93,16.01 28.93,17.19 29,17.26 30.52,17.26 31.05,17.79 31.05,21.51 31.12,21.57 32.04,21.57
GND on BOTTOM (solid shape): 64.14,16.05 64.14,15.62 64.81,14.94 64.81,12.68 62.47,10.35 61.08,10.35 60.87,10.55 59.44,10.55 59.35,10.64 59.35,11.04 59.08,11.31 59.08,12.3 58.81,12.57 58.81,14.86 58.86,14.92 58.9,14.99 59.04,15.13 59.04,16.09 59.48,16.53 63.65,16.53
GND on BOTTOM (solid shape): 29.26,57.37 29.4,57.34 29.54,57.37 29.57,57.37 29.7,57.23 29.7,56.76 29.96,56.4 29.96,56.14 30.54,54.43 30.54,54.17 30.42,54.05 29.92,54.05 29.91,54.05 29.7,53.83 29.7,53.82 29.67,53.8 29.67,52.85 29.59,52.76 28.96,52.76 28.86,52.87 28.86,57.29 28.93,57.37
GND on BOTTOM (solid shape): 109.86,62.05 109.79,61.98 108.65,61.98 108.65,60.27 109.98,60.27 110.68,59.57 110.68,59.13 110.55,59 109.28,59 109.22,58.94 109.22,58.17 109.41,57.98 110.36,57.98 110.55,57.79 110.55,56.14 110.17,55.76 107.76,55.76 107.7,55.83 107.7,56.17 107.88,56.35 107.88,56.36 107.9,56.39 107.9,57.07 107.7,57.27 107.7,59.38 108.01,59.7 108.01,62.05 108.14,62.18 109.86,62.18
GND on BOTTOM (solid shape): 166.67,81.6 166.67,81.41 166.26,81 166.26,80.3 166.2,80.24 165.94,80.24 165.81,80.37 165.81,81 165.43,81.38 165.43,81.57 165.56,81.7 165.75,81.7 165.88,81.57 165.94,81.57 165.95,81.57 166.03,81.56 166.11,81.57 166.12,81.57 166.17,81.57 166.33,81.73 166.54,81.73
GND on BOTTOM (solid shape): 274.45,29.79 274.45,29.22 274.51,29.16 275.46,29.16 275.53,29.22 275.53,29.73 275.72,29.92 276.77,29.92 277.07,29.62 277.07,28.54 276.61,28.08 276.61,26.3 276.48,26.17 275.65,26.17 275.46,26.36 275.46,27 275.27,27.19 274.28,27.19 273.87,26.77 273.33,26.77 273.24,26.86 273.24,29.54 273.62,29.92 274.32,29.92
GND on BOTTOM (solid shape): 168.16,81.7 168.21,81.63 168.31,81.57 168.39,81.56 168.47,81.57 168.48,81.57 168.55,81.57 168.67,81.7 168.86,81.7 168.99,81.57 168.99,81.38 168.61,81 168.61,80.37 168.48,80.24 168.23,80.24 168.16,80.3 168.16,80.99 167.8,81.36 167.8,81.63 167.92,81.75 168.11,81.75
GND on BOTTOM (solid shape): 28.61,75.99 28.61,75.84 28.45,75.68 28.44,75.68 27.56,75.03 27.23,74 27.23,73.61 27.1,73.48 26.91,73.48 26.84,73.54 26.84,76.07 26.93,76.16 26.98,76.21 28.39,76.21
GND on BOTTOM (solid shape): 124.21,69.54 124.21,67.13 124.04,66.97 123.97,66.94 123.89,66.97 123.52,67.09 123.26,66.79 123.26,66.75 120.09,66.75 119.9,66.94 119.9,68.29 121.35,69.73 124.02,69.73
GND on BOTTOM (solid shape): 19.52,47.74 19.52,47.49 19.51,47.49 19.84,47.16 21.25,47.16 21.63,46.77 21.66,46.74 21.7,46.71 22.17,46.24 22.17,46.24 22.56,45.84 22.56,45.2 22.51,45.14 22.37,45.14 22.29,45.22 22.29,45.41 22.18,45.52 22.17,45.52 21.71,45.52 21.67,45.48 21.44,45.48 20.85,46.07 20.74,46.07 20.58,46.24 19.08,46.24 18.82,45.97 18.28,45.97 18.19,46.07 18.19,46.99 19.03,47.83 19.43,47.83
GND on BOTTOM (solid shape): 48.64,6.1 48.64,5.98 48.71,5.91 53.71,5.91 53.87,5.76 53.87,4.52 53.82,4.47 53.58,4.47 53.58,4.48 53.47,4.49 53.36,4.48 53.35,4.47 52.74,4.47 52.7,4.43 52.5,4.43 52.19,4.13 52.19,2.24 52.07,2.12 52.07,1.6 51.94,1.47 49.85,1.47 49.71,1.61 49.71,1.9 49.85,2.04 49.85,2.74 49.66,2.93 47.44,2.93 47.4,2.96 47.25,2.96 47.02,3.2 47.02,6.16 47.21,6.35 48.4,6.35
GND on BOTTOM (solid shape): 243.02,119.64 243.02,117.29 242.25,116.53 240.79,116.53 240.67,116.4 240.67,114.05 240.48,113.86 239.21,113.86 238.92,113.58 238.92,112.63 238.82,112.53 238.38,112.53 238.25,112.66 238.25,113.93 238.44,114.12 239.9,114.12 240.09,114.31 240.09,115.58 239.97,115.71 238.25,115.71 237.55,116.4 237.55,116.72 237.62,116.79 239.52,116.79 239.78,117.04 240.31,117.04 242.06,118.8 242.06,119.58 242.32,119.83 242.83,119.83
GND on BOTTOM (solid shape): 147.74,81.61 147.74,81.34 147.69,81.29 147.65,81.23 147.41,80.98 147.41,80.37 147.25,80.22 146.85,80.22 146.67,80.4 146.67,81.15 146.62,81.19 146.62,81.21 146.57,81.3 146.49,81.36 146.47,81.38 146.47,81.57 146.61,81.71 146.87,81.71 146.97,81.61 146.99,81.6 147.19,81.57 147.35,81.69 147.36,81.7 147.39,81.73 147.61,81.73
GND on BOTTOM (solid shape): 149.26,81.71 149.27,81.7 149.43,81.57 149.63,81.6 149.65,81.61 149.78,81.73 149.97,81.73 150.1,81.61 150.1,81.42 149.72,81.03 149.72,80.4 149.59,80.27 149.18,80.27 149.07,80.39 149.07,81.14 148.97,81.24 148.97,81.24 148.91,81.32 148.83,81.38 148.83,81.59 148.89,81.63 148.93,81.7 148.97,81.73 149.23,81.73
GND on BOTTOM (solid shape): 159.56,81.6 159.56,81.35 159.5,81.29 159.45,81.21 159.45,81.2 159.23,80.98 159.23,80.37 159.08,80.22 158.67,80.22 158.49,80.39 158.49,81.14 158.43,81.2 158.43,81.21 158.37,81.31 158.29,81.37 158.29,81.56 158.43,81.7 158.7,81.7 158.74,81.66 158.76,81.63 158.81,81.59 159,81.57 159.16,81.68 159.2,81.73 159.43,81.73
GND on BOTTOM (solid shape): 194.5,117.1 194.5,111.2 194.63,111.07 194.63,110.82 194.47,110.66 194.28,110.66 194.25,110.63 190.73,110.63 190.36,110.99 189.8,110.99 189.43,110.63 188.99,110.63 188.93,110.69 185.93,110.69 185.17,111.45 185.17,111.66 185.21,111.67 185.52,112.02 185.21,112.38 185.17,112.38 185.17,114.18 185.43,114.45 185.48,114.49 185.52,114.54 185.74,114.75 185.74,115.08 185.88,115.22 186.6,115.22 186.69,115.12 186.69,113.74 186.56,113.61 185.87,113.61 185.68,113.42 185.68,112.4 185.87,112.21 188.66,112.21 189.23,111.64 189.23,111.45 189.55,111.13 190.82,111.13 191.07,111.39 191.07,116.91 191.58,117.42 194.18,117.42
GND on BOTTOM (solid shape): 345.7,120 343.2,117.5 340.7,120 340.7,121.1 344.35,121.1 344.35,121.8 344.64,122.51 345.35,122.8 345.7,122.8
GND on BOTTOM (solid shape): 12.32,18.16 12.35,18.15 12.4,18.13 12.45,18.12 12.5,18.12 12.55,18.12 12.6,18.14 12.65,18.16 12.67,18.17 14.5,18.17 14.53,18.16 14.59,18.16 14.65,18.16 14.69,18.17 15.26,18.17 15.41,18.03 15.81,18.03 15.95,18.17 18.29,18.17 18.35,18.11 18.35,10.46 18.33,10.44 18.35,10.42 18.35,8.9 18.61,8.64 18.61,6.8 16.89,5.09 14.29,5.09 12.76,6.61 12.13,6.61 11.36,7.38 11.36,10.8 12.41,10.8 12.41,10.75 12.42,10.7 12.44,10.65 12.47,10.6 12.5,10.56 12.54,10.52 12.59,10.49 12.63,10.47 12.69,10.46 12.74,10.45 12.79,10.45 12.84,10.46 12.89,10.47 12.94,10.49 12.99,10.52 13.03,10.56 13.06,10.6 13.09,10.65 13.11,10.7 13.12,10.75 13.12,10.8 13.12,10.86 13.11,10.91 13.09,10.96 13.06,11 13.03,11.05 12.99,11.08 12.94,11.11 12.89,11.14 12.84,11.15 12.79,11.16 12.74,11.16 12.69,11.15 12.63,11.14 12.59,11.11 12.54,11.08 12.5,11.05 12.47,11 12.44,10.96 12.42,10.91 12.41,10.86 12.41,10.8 11.36,10.8 11.36,18.1 11.43,18.17 12.23,18.17
GND on BOTTOM (solid shape): 99.94,25.96 99.94,25.63 99.57,25.26 99.57,25.26 99.57,24.38 99.39,24.2 99.19,24.2 98.93,23.95 98.74,23.95 98.62,24.08 98.62,24.33 98.49,24.46 98.07,24.46 98.01,24.48 97.86,24.63 97.86,24.63 97.63,24.77 97.41,24.61 97.41,24.6 97.37,24.57 97.35,24.57 97.21,24.56 97.08,24.5 97.03,24.48 96.99,24.45 96.95,24.46 96.93,24.49 96.88,24.55 96.82,24.59 96.81,24.59 96.78,24.63 96.79,24.65 96.77,24.85 96.65,25.02 96.64,25.03 96.64,25.08 96.66,25.13 96.68,25.18 97.01,25.5 97.02,25.51 97.1,25.54 97.16,25.59 97.22,25.62 97.28,25.59 97.31,25.56 97.34,25.53 97.57,25.51 97.73,25.69 97.73,25.76 97.88,25.91 99.25,25.91 99.47,26.12 99.78,26.12
GND on BOTTOM (solid shape): outline of 105 points within 153.92,112.28 163.37,116.73
GND on BOTTOM (solid shape): 10.21,77.68 10.67,77.22 12.38,77.22 12.51,77.1 12.51,76.53 12.19,76.21 11.02,76.21 10.69,75.89 9.8,74.95 8.6,75.42 5.72,75.42 4.92,74.62 3.18,74.62 2.38,75.42 1.9,75.42 1.66,75.32 1.56,75.08 1.56,72.91 1.1,72.91 1.1,75.08 1.34,75.64 1.9,75.88 8.88,75.88 10.05,75.58 9.75,76.75 9.75,78.45 10.21,78.45
GND on BOTTOM (solid shape): outline of 171 points within 205.8,111.64 213.42,115.96
GND on BOTTOM (solid shape): 79.24,25.87 79.29,25.84 79.31,25.78 79.31,25.71 79.33,25.63 79.5,25.5 79.71,25.54 79.74,25.56 79.78,25.6 79.8,25.61 79.84,25.61 79.88,25.59 79.93,25.54 79.98,25.52 80.02,25.51 80.05,25.5 80.09,25.51 80.17,25.53 80.21,25.53 80.38,25.36 80.36,25.3 80.36,25.26 80.36,25.21 80.37,25.16 80.39,25.11 80.4,25.07 80.39,25.03 80.16,24.67 80.47,24.38 80.5,24.33 80.49,24.26 80.48,24.23 80.49,24.09 80.57,23.99 80.57,23.86 80.48,23.86 80.47,23.89 80.4,24 80.28,24.08 80.18,24.1 80.07,24.09 80,24.09 79.96,24.13 79.91,24.19 79.84,24.24 79.66,24.23 79.53,24.09 79.53,24.08 79.48,24.03 79.45,24.04 79.37,24.05 79.29,24.04 79.22,24.06 79.18,24.12 79.14,24.2 79.08,24.26 79.05,24.31 79.06,24.36 79.1,24.43 79.12,24.5 79.11,24.72 78.97,24.91 78.95,24.93 78.91,24.98 78.93,25.04 79.09,25.2 79.09,25.57 79.07,25.58 78.95,25.7 78.95,25.81 79.01,25.87
GND on BOTTOM (solid shape): outline of 90 points within 106.39,70.05 115.79,86.1
GND on BOTTOM (solid shape): outline of 105 points within 140.6,103.88 152.44,119.39
GND on BOTTOM (solid shape): outline of 103 points within 21.82,56.73 25.11,60.71
GND on BOTTOM (solid shape): outline of 283 points within 0.2,0.2 352.5,109.23
GND on BOTTOM (solid shape): outline of 3131 points within 1.1,33.74 351.6,122.6
GND on BOTTOM (solid shape): outline of 2762 points within 21.81,35.94 31.75,45.87
GND on BOTTOM (solid shape): outline of 10389 points within 77.91,5.91 98.81,25.43
GND on GND1 (solid shape): 1.89,47.51 1.56,47.51 1.56,31.28 1.1,31.28 1.1,47.67 1.19,47.88 1.4,47.97 1.89,47.97
GND on IN1 (solid shape): 5.09,42.52 5.09,41.86 4.7,41.47 1.24,41.47 1.12,41.59 1.12,42.41 1.21,42.49 3.02,42.49 3.39,42.86 4.75,42.86
GND on IN1 (solid shape): 129.39,98.16 129.48,98.11 129.48,98 129.63,97.5 130.12,97.7 130.19,97.76 130.28,97.74 130.89,97.13 130.91,97.02 130.82,96.96 130.16,96.96 129.77,96.57 129.75,96.57 129.47,96.4 129.44,96.08 129.43,95.99 129.34,95.95 128.89,95.95 126.84,97.99 126.7,97.99 126.7,98.07 126.73,98.09 126.78,98.12 126.83,98.16
GND on IN1 (solid shape): 121.33,96.42 121.39,96.33 121.39,95.64 121.33,95.55 121.23,95.56 120.68,95.26 121.23,94.96 121.33,94.97 121.39,94.88 121.39,94.08 120.99,93.68 120.24,93.68 120.18,93.62 120.11,93.68 120.13,93.71 120.12,94.05 119.85,94.23 119.76,94.3 119.79,94.4 119.97,94.58 119.97,94.59 120.51,95.13 120.51,95.76 120.7,95.95 120.7,96.25 120.75,96.33 120.84,96.34 121.04,96.32 121.22,96.4
GND on IN1 (solid shape): 10.21,77.68 10.67,77.22 12.38,77.22 12.51,77.1 12.51,76.53 12.19,76.21 11.02,76.21 10.69,75.89 9.8,74.95 8.6,75.42 5.72,75.42 4.92,74.62 3.18,74.62 2.38,75.42 1.9,75.42 1.66,75.32 1.56,75.08 1.56,72.91 1.1,72.91 1.1,75.08 1.34,75.64 1.9,75.88 8.88,75.88 10.05,75.58 9.75,76.75 9.75,78.44 10.21,78.44
GND on IN1 (solid shape): outline of 441 points within 137.42,114.13 152.65,119.79
GND on IN1 (solid shape): outline of 281 points within 0.2,0 352.5,109.23
GND on IN1 (solid shape): outline of 17994 points within 1.1,33.74 351.6,122.79
GND on IN2 (solid shape): 10.21,77.68 10.67,77.22 12.38,77.22 12.51,77.1 12.51,76.53 12.19,76.21 11.02,76.21 10.69,75.89 9.8,74.95 8.6,75.42 5.72,75.42 4.92,74.62 3.18,74.62 2.38,75.42 1.9,75.42 1.66,75.32 1.56,75.08 1.56,72.91 1.1,72.91 1.1,75.08 1.34,75.64 1.9,75.88 8.88,75.88 10.05,75.58 9.75,76.75 9.75,78.44 10.21,78.44
GND on IN2 (solid shape): outline of 281 points within 0.2,0 352.5,109.23
GND on IN2 (solid shape): outline of 436 points within 1.1,33.74 351.6,122.8
GND on IN2 (solid shape): outline of 18142 points within 132,19.69 250.17,67.5
GND on IN2 (solid shape): outline of 25556 points within 191.65,50.69 250.89,112.85
GND on GND2 (solid shape): 1.89,47.51 1.56,47.51 1.56,31.28 1.1,31.28 1.1,47.67 1.19,47.88 1.4,47.97 1.89,47.97
GND on GND2 (solid shape): 325.62,77.76 326.32,77.76 328.14,75.95 326.33,74.14 326.33,74.13 325.62,74.13 325.62,74.04 325.16,74.04 325.16,74.13 324.96,74.13 324.96,74.3 325.11,74.65 325.46,74.8 326.33,74.8 326.42,74.8 326.51,74.81 327.09,75.09 327.43,75.64 327.42,76.31 327.03,76.86 326.9,76.95 326.75,77.02 326.56,77.08 326.37,77.1 326.32,77.1 325.46,77.1 325.11,77.25 324.96,77.6 324.96,77.69 325.16,77.69 325.16,77.78 325.62,77.78
GND on GND2 (solid shape): 246.59,1.6 248.4,3.41 250.21,1.6 250.21,0.66 250.28,0.66 250.28,0.2 250.24,0.2 250.24,0 250.05,0 249.98,0.01 249.91,0.02 249.88,0.03 249.82,0.06 249.76,0.09 249.61,0.27 249.55,0.5 249.55,1.6 249.55,1.67 249.54,1.74 249.36,2.23 248.98,2.59 248.52,2.74 248.04,2.69 247.67,2.49 247.39,2.16 247.36,2.1 247.34,2.04 247.29,1.89 247.26,1.74 247.25,1.69 247.25,1.6 247.25,0.5 247.12,0.16 246.79,0 246.75,0 246.6,0 246.6,0.2 246.43,0.2 246.43,0.66 246.59,0.66
GND on GND2 (solid shape): 345.33,122.6 345.36,122.6 345.36,122.14 345.35,122.14 345.11,122.04 345.01,121.8 345.01,120 343.07,118.19 341.41,120.25 341.41,120.44 341.28,120.44 341.28,120.9 341.49,120.9 341.49,121.1 341.57,121.1 341.92,120.95 342.07,120.6 342.07,120.2 342.05,119.95 342.15,119.53 342.23,119.38 342.35,119.22 342.49,119.09 342.69,118.97 342.91,118.89 343.31,118.86 343.7,118.96 343.98,119.16 344.2,119.42 344.3,119.66 344.35,119.91 344.35,120 344.35,121.8 344.44,122.21 344.69,122.55 344.99,122.73 345.33,122.8
GND on IN3 (solid shape): 112.35,85.91 112.35,84.57 112.09,84.31 111.15,84.31 110.72,83.88 110.72,83.14 110.34,82.76 109.83,82.76 109.56,82.5 109.56,79.98 109.73,79.82 110.49,79.82 110.95,79.36 115.16,79.36 115.42,79.1 115.42,75.14 115.01,74.74 110.57,74.74 110.03,75.27 108.9,75.27 108.9,75.26 108.71,75.07 108.71,72.14 108.84,72.02 109.65,72.02 109.93,71.74 109.93,70.32 109.67,70.05 107.82,70.05 107.14,70.74 107.14,71.54 106.83,71.85 106.83,75.36 107.42,75.95 107.42,76.84 108.15,77.58 108.15,77.97 107.57,78.56 107.57,79.84 107.61,79.88 107.61,83.16 107.9,83.45 107.9,85.81 108.18,86.09 112.17,86.09
GND on IN3 (solid shape): 10.21,77.68 10.67,77.22 12.38,77.22 12.51,77.1 12.51,76.53 12.19,76.21 11.02,76.21 10.69,75.89 9.8,74.95 8.6,75.42 5.72,75.42 4.92,74.62 3.18,74.62 2.38,75.42 1.9,75.42 1.66,75.32 1.56,75.08 1.56,72.91 1.1,72.91 1.1,75.08 1.34,75.64 1.9,75.88 8.88,75.88 10.05,75.58 9.75,76.75 9.75,78.44 10.21,78.44
GND on IN3 (solid shape): outline of 281 points within 0.2,0 352.5,109.23
GND on IN3 (solid shape): outline of 441 points within 1.1,33.74 351.6,122.8
GND on IN4 (solid shape): 112.35,85.91 112.35,84.57 112.09,84.31 111.15,84.31 110.72,83.88 110.72,83.14 110.34,82.76 109.83,82.76 109.56,82.5 109.56,79.98 109.73,79.82 110.49,79.82 110.95,79.36 115.16,79.36 115.42,79.1 115.42,75.14 115.01,74.74 110.57,74.74 110.03,75.27 108.9,75.27 108.9,75.26 108.71,75.07 108.71,72.14 108.84,72.02 109.65,72.02 109.93,71.74 109.93,70.32 109.67,70.05 107.82,70.05 107.14,70.74 107.14,71.54 106.83,71.85 106.83,75.36 107.42,75.95 107.42,76.84 108.15,77.58 108.15,77.97 107.57,78.56 107.57,79.84 107.61,79.88 107.61,83.16 107.9,83.45 107.9,85.81 108.18,86.09 112.17,86.09
GND on IN4 (solid shape): 10.21,77.68 10.67,77.22 12.38,77.22 12.51,77.1 12.51,76.53 12.19,76.21 11.02,76.21 10.69,75.89 9.8,74.95 8.6,75.42 5.72,75.42 4.92,74.62 3.18,74.62 2.38,75.42 1.9,75.42 1.66,75.32 1.56,75.08 1.56,72.91 1.1,72.91 1.1,75.08 1.34,75.64 1.9,75.88 8.88,75.88 10.05,75.58 9.75,76.75 9.75,78.44 10.21,78.44
GND on IN4 (solid shape): outline of 1867 points within 0.2,0 352.5,122.54
GND on IN4 (solid shape): outline of 434 points within 1.1,33.74 351.6,122.8
GND on IN4 (solid shape): outline of 16313 points within 114.19,19.48 251.02,67.57
GND on VCC (solid shape): 30,107.31 30,107.15 29.85,106.8 29.5,106.65 29,106.65 28.56,106.56 28.18,106.31 28.11,106.23 28.04,106.14 27.98,106.03 27.95,105.98 27.86,105.33 28.14,104.74 28.27,104.61 28.43,104.5 28.49,104.47 28.57,104.43 28.78,104.37 29,104.35 29.5,104.35 29.85,104.2 30,103.85 30,103.69 29.8,103.69 29.8,103.69 29,103.69 27.19,105.5 29,107.31 29.17,107.31
GND on VCC (solid shape): 345.33,122.6 345.36,122.6 345.36,122.14 345.35,122.14 345.11,122.04 345.01,121.8 345.01,120 343.07,118.19 341.41,120.25 341.41,120.44 341.28,120.44 341.28,120.9 341.49,120.9 341.49,121.1 341.57,121.1 341.92,120.95 342.07,120.6 342.07,120.2 342.05,119.95 342.15,119.53 342.23,119.38 342.35,119.22 342.49,119.09 342.69,118.97 342.91,118.89 343.31,118.86 343.7,118.96 343.98,119.16 344.2,119.42 344.3,119.66 344.35,119.91 344.35,120 344.35,121.8 344.44,122.21 344.69,122.55 344.99,122.73 345.33,122.8
GND on VCC (solid shape): outline of 6335 points within 1.1,59.06 29.8,112.8
GND on IN5 (solid shape): 10.21,77.68 10.67,77.22 12.38,77.22 12.51,77.1 12.51,76.53 12.19,76.21 11.02,76.21 10.69,75.89 9.8,74.95 8.6,75.42 5.72,75.42 4.92,74.62 3.18,74.62 2.38,75.42 1.9,75.42 1.66,75.32 1.56,75.08 1.56,72.91 1.1,72.91 1.1,75.08 1.34,75.64 1.9,75.88 8.88,75.88 10.05,75.58 9.75,76.75 9.75,78.44 10.21,78.44
GND on IN5 (solid shape): 350.32,109.22 350.09,108.39 350.8,107.89 352.24,107.89 352.45,107.68 352.45,106.29 352.24,106.09 350.8,106.09 350.05,105.34 350.8,104.59 352.24,104.59 352.43,104.4 352.44,104.38 352.45,104.36 352.45,102.69 352.24,102.49 350.8,102.49 350.05,101.74 350.8,100.99 352.24,100.99 352.45,100.78 352.45,99.1 352.24,98.89 350.8,98.89 350.05,98.14 350.8,97.39 352.24,97.39 352.45,97.18 352.45,95.5 352.24,95.29 350.8,95.29 350.05,94.54 350.8,93.79 352.24,93.79 352.45,93.58 352.45,91.9 352.24,91.69 350.8,91.69 350.05,91.02 350.63,90.2 350.65,90.2 350.85,89.99 350.85,86.56 350.34,86.56 350.34,89.77 349.56,91.17 350.8,92.2 351.94,92.2 351.94,93.28 350.8,93.28 349.54,94.54 350.8,95.8 351.94,95.8 351.94,96.88 350.8,96.88 349.54,98.14 350.8,99.4 351.94,99.4 351.94,100.48 350.8,100.48 349.54,101.74 350.8,103 351.94,103 351.94,104.08 350.8,104.08 349.54,105.34 350.8,106.6 351.94,106.6 351.94,107.38 350.8,107.38 349.72,107.99 349.68,109.22
GND on IN5 (solid shape): outline of 281 points within 0.2,0 352.5,109.23
GND on IN5 (solid shape): outline of 435 points within 1.1,33.74 351.6,122.8
GND on IN5 (solid shape): outline of 23450 points within 194.09,52.59 244.39,110
GND on IN5 (solid shape): outline of 34213 points within 105.16,1.27 351.43,121.53
GND on IN6 (solid shape): 163.32,116.29 163.32,113.55 162.94,113.17 161.88,113.17 161.62,112.91 161.62,112.48 161.42,112.28 159.41,112.28 158.8,112.89 158.8,113.22 158.57,113.45 155.04,113.45 153.9,114.59 153.9,115.05 154.13,115.27 159.23,115.27 159.94,115.99 160.76,115.99 161.44,116.67 162.94,116.67
GND on IN6 (solid shape): 20.58,38.96 20.58,37.39 20.57,37.38 20.57,36.1 20.14,35.67 18.53,35.67 18.39,35.81 18.39,35.94 18.55,36.1 18.91,36.1 19.04,36.22 19.04,37.26 18.9,37.39 18.77,37.39 18.76,37.4 18.66,37.41 18.56,37.4 18.55,37.39 18.46,37.39 18.36,37.49 18.36,38.7 18.87,39.21 20.33,39.21
GND on IN6 (solid shape): 112.35,85.91 112.35,84.57 112.09,84.31 111.15,84.31 110.72,83.88 110.72,83.14 110.34,82.76 109.83,82.76 109.56,82.5 109.56,79.98 109.73,79.82 110.49,79.82 110.95,79.36 115.16,79.36 115.42,79.1 115.42,75.14 115.01,74.74 110.57,74.74 110.03,75.27 108.9,75.27 108.9,75.26 108.71,75.07 108.71,72.14 108.84,72.02 109.65,72.02 109.93,71.74 109.93,70.32 109.67,70.05 107.82,70.05 107.14,70.74 107.14,71.54 106.83,71.85 106.83,75.36 107.42,75.95 107.42,76.84 108.15,77.58 108.15,77.97 107.57,78.56 107.57,79.84 107.61,79.88 107.61,83.16 107.9,83.45 107.9,85.81 108.18,86.09 112.17,86.09
