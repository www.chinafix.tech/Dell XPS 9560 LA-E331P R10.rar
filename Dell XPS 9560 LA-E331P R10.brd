# Allegro board Dell XPS 9560 LA-E331P R10.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N124752685: length 2.1
  TOP w0.14: CH101.2 RH211.1 120.33,18.32 v1(120,17.99)
N124753277: length 2.2
  TOP w0.127: CH100.2 231.31,18.11
  TOP w0.14: 231.31,18.11 231.42,17.99 RH212.1 230.43,17.42 v1(230.33,17.52)
N124754324: length 18.8
  TOP w0.14: v1(20,65.55) 20.23,65.78 v2(20.23,66.22)
  TOP w0.152: v2(26.54,59.38) 26.61,59.44 RT199.1 RT189.1
  IN2 w0.152: v2(20.23,66.22) 21.63,66.22 22.52,65.32 23.23,65.32 25.12,63.43 25.12,61.06 26.54,59.64 v2(26.54,59.38)
  BOTTOM w0.081: UT4.F10 25.62,59.15 26.32,59.15 26.49,59.32
  BOTTOM w0.152: RT246.1 17.76,65.43 17.93,65.6 19.61,65.6 v2(20.23,66.22) ; 26.49,59.32 v2(26.54,59.38)
N124755309: length 4.8
  TOP w0.14: v1(19.5,59.57) v2(19.5,58.68) 19.81,58.68 20.11,58.98 20.66,58.98 20.97,58.67 RT430.1
  BOTTOM w0.081: UT4.F2 21.37,58.84 21.17,58.65 20.8,58.65 20.8,58.65 20.77,58.65 20.59,58.82 19.64,58.82 v2(19.5,58.68)
N124755351: length 1.7
  TOP w0.14: v2(21.91,59.75) 22.92,59.75 T193.1
  BOTTOM w0.081: UT4.G4 22.26,59.4 v2(21.91,59.75)
N124755352: length 1.6
  TOP w0.14: T194.1 v2(21.93,59.17)
  BOTTOM w0.081: v2(21.93,59.17) 22.2,58.9 UT4.F4
N124759625: length 4.3
  TOP w0.14: v2(21.91,58.58) 21.88,58.58 21.43,59.04 v1(21.43,59.44) 21.43,61.72 21.4,61.75 RT226.2
  BOTTOM w0.081: v2(21.91,58.58) 21.93,58.56 22.21,58.56 UT4.E4
N124759627: length 7.6
  TOP w0.14: RT227.2 25.16,53.43 v1(25.44,53.7) v2(25.44,54.48)
  IN2 w0.099: v2(22.43,57.55) 22.43,57.55 22.43,57.34 22.84,56.93 24.32,56.93 25.06,56.19 25.06,54.86 v2(25.44,54.48)
  BOTTOM w0.081: v2(22.43,57.55) 22.78,57.9 UT4.D5
N124817422: length 1.8
  TOP w0.089: RH580.1 95.51,13.79 v2(95.53,13.76) 95.53,13.31 v1(95.59,13.24)
  BOTTOM w0.089: v2(95.53,13.76) 95.53,13.91 UH2.AD10
N124817429: length 2.5
  TOP w0.089: v2(99.99,12.68) 99.77,12.45 RH581.1
  BOTTOM w0.089: v2(99.99,12.68) 99.74,12.92 99.24,12.92 99.07,12.75 UH2.AG2
N125046794: length 3.5
  TOP w0.14: RZ75.2 RZ76.2 240.87,1.84 241.2,2.17 241.52,2.17 v2(241.85,2.5) 241.99,2.64 UZ7.5
N125173025: length 2
  BOTTOM w0.081: UT4.F1 20.83,58.94 20.71,58.94 20.66,58.99 20.02,58.99 19.79,59.22 19.45,59.22
  BOTTOM w0.14: RT190.1 19.45,59.22
N125233563: length 2
  TOP w0.14: v1(107.52,108.14) 108.59,108.14 PC1138.2
  TOP w0.254: PC1138.2 PR1143.2
N125273664: length 1.5
  BOTTOM w0.089: UT1.E2 23.57,45.51 23.57,46.69 T195.1
N125742089: length 10.5
  TOP w0.14: v2(58.93,9.02) 58.93,8.64 59.07,8.5 UH7.5
  BOTTOM w0.14: v2(58.93,9.02) 59.37,9.02 60.07,9.72 62.13,9.72 64.41,12 v1(65.32,12) 65.43,11.88 RH587.1 RH586.1
N125743729: length 2.5
  TOP w0.14: UE1.29 154.43,4.2 154.64,3.99 154.77,3.99 155.22,3.54 155.53,3.54 RE125.2
N125814346: length 3.2
  TOP w0.14: CN22.1 334.77,103.39 334.52,103.13 334.52,102.05 334.65,101.92 UN3.6
N125836022: length 10.2
  TOP w0.14: RZ90.2 134.05,65.48 134.56,65.99 134.56,67.7 ; 134.56,67.7 UZ16.3 ; 134.56,67.7 135.82,67.7 v3(136.18,68.06) 136.18,68.63 135.8,69.01 134.1,69.01 133.08,70.02 RZ72.2
N125846238: length 3
  BOTTOM w0.081: 26.81,58.1 26.28,58.1 25.98,58.4 UT4.E11
  BOTTOM w0.14: 26.81,58.1 27.76,58.1 RT245.1 RT186.1
N125857121:
  vias: v3(44.51,27.89)
N125861425: length 4.9
  TOP w0.14: v1(44.77,24.27) 44.39,24.65 RZ37.1
  TOP w0.508: QZ9.1 42.94,25.8 RZ37.1
N125925558: length 1.4
  BOTTOM w0.14: CT106.1 15.57,31.7 UT3.6
N125927628: length 1.6
  BOTTOM w0.14: RT240.2 20.15,31.7 UT3.3
N125960908: length 2.3
  TOP w0.14: UZ19.2 120.89,57.43 121.15,57.16 RZ81.2 121.59,56.41 v1(122.25,56.41)
N126729390: length 139.8
  TOP w0.089: v2(101.16,20.79) 99.24,22.72 99.24,24.5 98.19,25.55 v2(98.19,27.12)
  TOP w0.14: v3(122.85,66.92) 123.44,66.92 v2(123.62,66.75) 124.08,66.75 124.52,67.19 124.52,67.83 124.91,68.21 UZ18.2 ; v2(167.23,10.23) 166.72,10.74 165.9,10.74 165.26,10.11 164.35,10.11 163.59,10.86 163.59,11.64 159.74,15.49 145.17,15.49 v2(143.77,16.9)
  IN5 w0.089: 101.98,20.91 101.27,20.91 v2(101.16,20.79)
  IN5 w0.099: v2(143.77,16.9) 143.13,16.26 131.95,16.26 131.73,16.49 129.52,16.49 129.29,16.25 107.61,16.25 106.73,17.14 105.87,17.14 102.1,20.91 101.98,20.91
  IN6 w0.099: v2(123.62,66.75) 121.5,66.75 116.93,62.18 116.93,56.83 113.97,53.86 113.97,49.28 114.2,49.05 114.2,44.65 107.98,38.44 105.06,38.44 99.87,33.25 99.53,33.25 98.19,31.9 v2(98.19,27.12)
  BOTTOM w0.14: v2(167.23,10.23) 167.35,10.36 DZ1.1 169.1,10.36 169.15,10.31 RZ89.2
N126843005: length 14.1
  TOP w0.14: LED6.2 333.71,119.71 333.2,119.2 331.6,119.2 v1(331.15,118.75) 329.38,116.98 RE3.2
N126911279: length 6.2
  TOP w0.14: v2(193.23,11.76) QE19.1 ; v1(196.41,9.79) 196.22,9.98 QE2.1 196.22,11.58 v2(195.91,11.88)
  IN5 w0.099: v2(193.23,11.76) 193.23,11.79 193.71,12.26 195.53,12.26 v2(195.91,11.88)
N127291407: length 2.3
  BOTTOM w0.14: CZ31.1 340.56,44.15 v1(340.67,44.05) 341.1,44.05 341.32,44.27 UZ5.6
N127291517: length 1
  BOTTOM w0.14: 341.72,45.87 341.72,46.43 v3(342.06,46.77)
N127715891: length 3.6
  TOP w0.14: v3(67.71,27.39) 68.72,26.38 UV17.8
  TOP w0.381: RV547.2 70.2,25.75 UV17.8
N127994048: length 2.1
  BOTTOM w0.081: 26.81,58.37 26.28,58.37 26.01,58.65 25.62,58.65 UT4.E10
  BOTTOM w0.14: 26.81,58.37 27.01,58.37 T200.1
N128723303: length 1.9
  TOP w0.14: v1(188.37,101.23) 188.56,101.42 PR1512.1
  vias: v2(189.79,102.43) v2(190.37,102.43)
N128723349: length 1.2
  TOP w0.14: PC1521.1 188.53,102.6 v1(188.52,102.59)
N128725561: length 13.6
  TOP w0.14: v2(174.92,109.97) 174.92,109.55 v1(174.75,109.38)
  TOP w0.254: PR1018.2 169.67,116.34 169.61,116.48 ; 169.61,116.48 169.61,116.69 169.41,116.89 PC1054.1 ; 169.61,116.48 v2(169.71,116.48) ; v2(174.92,109.97) 174.52,110.36 PR1016.2
  IN1 w0.254: v2(169.71,116.48) 169.8,116.48 172.33,113.95 172.33,112.01 173.91,110.43 174.46,110.43 v2(174.92,109.97)
  BOTTOM w0.203: v2(169.71,116.48) 169.18,116.48 169.01,116.32 PU1001.10
N128725563: length 1.2
  BOTTOM w0.14: PC1022.1 v1(162.19,111.07)
N128725569: length 1.2
  BOTTOM w0.14: PC1047.2 v1(174.22,110.63)
N128725595: length 4.6
  TOP w0.14: v2(170.62,114.98) 170.41,114.77 v1(170.41,114.41)
  TOP w0.254: v2(170.62,114.98) 170.84,115.2 PC1055.1
  BOTTOM w0.203: v2(170.62,114.98) 170.4,114.98 170.25,114.84 PU1001.12
  BOTTOM w0.254: v2(170.62,114.98) 171.1,114.98 171.65,114.44 PR1022.1
N128725605: length 3.7
  TOP w0.14: PC1041.1 171.03,117.99 v1(170.87,118.16)
  TOP w0.508: v2(172.09,118.75) PC1041.1
  BOTTOM w0.508: v2(172.09,118.75) 171.93,118.91 PR1014.2 PR1013.1
N128725802: length 4.8
  TOP w0.14: PR1002.1 v1(166.55,116.57)
  TOP w0.254: v2(165.83,115.1) 166.24,115.51 PR1002.1
  BOTTOM w0.203: PU1001.4 166.1,114.84 v2(165.83,115.1) 165.55,115.39 PR1001.1 165.11,115.39 164.86,115.64 PR1000.2
N128726001: length 8.9
  TOP w0.254: PR1005.2 166.64,118.91 166.36,118.63 v1(166.36,118.28) 166.36,117.33 v2(166.46,117.23)
  BOTTOM w0.254: v2(166.46,117.23) 166.3,117.23 164.89,118.64 164.52,118.64 PC1018.1 164.69,119.35 165.98,119.35 PR1007.1 166.37,118.97 PR1006.2
N128726023: length 3.5
  BOTTOM w0.203: PR1013.2 170.5,117.15 v1(170.38,117.03) 170.28,116.94 169.1,116.94 168.61,116.45 PU1001.9
N128726031:
  vias: v1(168.56,111.55)
N128726049: length 7
  IN6 w0.254: v2(168.56,119.39) 169.05,118.91 170.47,118.91 v2(172.02,117.36)
  BOTTOM w0.254: PR1011.1 172.12,115.4 172.12,117.26 v2(172.02,117.36) ; v2(168.56,119.39) 168.59,119.36 PR1008.2
N128726112: length 16.1
  TOP w0.14: v2(177.69,110.24) 177.69,110.1 177.45,109.85 v1(177.45,109.48)
  TOP w0.254: v2(177.69,110.24) 177.72,110.27 PR1023.2 ; PC1054.2 170.63,117.17 170.92,116.87 171.62,116.87 v2(171.64,116.85) 171.64,116.75 171.18,116.29 PR1021.2
  IN1 w0.254: v2(171.64,116.85) 172.23,116.26 172.23,115.62 173.38,114.46 173.38,113.7 175.1,111.98 175.93,111.98 177.68,110.24 v2(177.69,110.24)
  BOTTOM w0.203: v2(171.64,116.85) 171.64,116.65 170.23,115.24 PU1001.11
N128727405: length 1.1
  BOTTOM w0.14: v1(184.33,110.26) 184.34,110.27 PC1519.1
N128727409: length 3.9
  TOP w0.14: v1(179.91,119.78) 180.24,119.45 PC1532.1
  TOP w0.254: PC1532.1 180.24,118.03 v2(180.28,117.99)
  BOTTOM w0.203: PR1519.1 180.18,118.09 v2(180.28,117.99) 180.52,117.74 PU1501.12
N128727430: length 5.9
  TOP w0.14: v1(178.27,116.38) 178.23,116.42 v2(177.76,116.42)
  TOP w0.254: PR1508.2 177.71,116.42 v2(177.76,116.42) ; v2(175.78,115.2) 176.1,114.88 PR1505.2
  BOTTOM w0.254: 176.65,114.33 PR1507.1 ; 176.65,114.33 175.85,115.13 175.84,115.13 v2(175.78,115.2) ; 176.65,114.33 177.17,114.86 PC1517.1 177.31,115.96 v2(177.76,116.42)
N128727456: length 1
  BOTTOM w0.254: PR1511.1 177.23,116.95 PR1509.2
N128727528: length 2.8
  BOTTOM w0.254: PR1515.1 175.77,118.26 175.77,118.09 PR1514.2 175.01,117.32 PC1522.1
N128727776: length 106.7
  TOP w0.381: v2(178.63,118.37) 178.63,118.56 178.13,119.06 PC1531.1 177.49,119.06 177.42,119.13 PR1516.2
  IN2 w0.381: v2(206.73,53.57) 206.73,53.75 204.98,55.49 204.98,56.76 202.69,59.05 202.69,59.8 201.71,60.78 200.94,60.78 199.81,61.91 199.04,62.68 199.04,62.7 198.56,63.17 198.55,63.17 196.64,65.08 195.61,65.08 190.65,70.05 190.65,74.77 190.27,75.15 189.14,75.15 188.87,75.43 188.87,76.42 189.12,76.68 190.27,76.68 190.65,77.06 190.65,78.75 187.54,81.86 186.06,81.86 185.41,82.51 185.41,85.23 182.25,88.39 182.25,89.54 181.64,90.15 178.3,90.15 178.01,89.86 176.26,89.86 175.84,90.28 173.97,90.28 173.47,90.78 172.2,90.78 170.88,92.1 170.88,93.42 169.61,94.69 166.59,94.69 166.21,95.07 166.21,98.09 168.81,100.69 168.81,102.98 169.42,103.59 169.42,109.1 171.91,111.59 171.91,114.2 173.34,115.64 173.34,116.54 174.31,117.51 175.09,117.51 175.6,118.02 177.23,118.02 177.59,118.37 v2(178.63,118.37)
  BOTTOM w0.203: PU1501.10 179.02,116.2 178.82,116.4 178.82,116.96 178.5,117.27 178.5,118.25 v2(178.63,118.37)
  BOTTOM w0.381: v2(206.73,53.57) 206.57,53.73 PR1517.2
N128727796: length 105.5
  TOP w0.102: v2(179.01,117.48) 179.66,117.48 v1(179.79,117.62)
  TOP w0.381: PR1521.2 176.96,118.15 PC1531.2 177.93,118.11 177.99,118.11 178.62,117.48 v2(179.01,117.48)
  IN2 w0.381: v2(207.52,53.6) 207.52,53.92 205.66,55.78 205.66,57.05 203.38,59.33 203.38,60.08 201.97,61.5 201.97,63.09 200.42,64.64 198.06,64.64 197.74,64.96 197.74,64.98 196.93,65.79 196.74,65.79 196.04,66.49 195.17,66.49 191.33,70.33 191.33,79.03 187.58,82.79 187.58,83.6 186.97,84.21 186.97,84.81 189.28,87.12 189.28,92.41 188.47,93.23 184.55,93.23 184.43,93.11 183.91,93.11 182.44,91.64 178.68,91.64 178.06,91.02 178.06,90.88 177.73,90.55 176.54,90.55 176.12,90.97 174.26,90.97 173.66,91.56 173.66,93.1 173.24,93.53 173.24,101.79 172.83,102.2 172.83,104.46 173.36,104.99 173.36,108.53 172.7,109.2 172.7,113.09 173.08,113.47 173.75,113.47 174.07,113.15 175.46,113.15 176.82,114.51 176.82,116.42 177.89,117.48 v2(179.01,117.48)
  BOTTOM w0.203: v2(179.01,117.48) 179.96,117.48 180.12,117.32 PU1501.11
  BOTTOM w0.381: PR1520.2 v2(207.52,53.6)
N128727911: length 4.4
  BOTTOM w0.203: PU1501.9 178.58,115.8 178.22,116.16 v1(178.22,116.83) 177.93,117.13 177.93,118.13 PR1515.2
N128727995: length 4.6
  TOP w0.14: v1(182.32,118.32) 182.31,118.31 v2(182.31,117.74)
  IN2 w0.254: v2(183.77,115.26) 183.77,116.27 182.44,117.61 182.44,117.61 v2(182.31,117.74)
  BOTTOM w0.254: v2(182.31,117.74) PR1513.1
N128735760: length 1.3
  TOP w0.14: UA4.10 9.89,7.94 9.93,7.98 9.93,8.73 CA125.1
N128735764: length 3.6
  TOP w0.102: v1(9.27,10.66) 9.27,10.52 8.75,10 8.75,9.09 8.9,8.94 8.96,8.94 CA124.1
  TOP w0.108: UA4.12 9.09,7.88 8.98,7.99 8.98,8.44 9.11,8.57 CA124.1
N128735809:
  vias: v3(7.24,7.44)
N128735813: length 1.9
  TOP w0.14: 11.14,7.88 11.14,6.8 v1(11.74,6.21)
N128735920: length 3.3
  BOTTOM w0.14: UA3.3 3.94,10.93 3.96,10.91 RA77.2 3.68,10.3 CA137.2 v1(2.57,9.66)
N128737170: length 4.7
  BOTTOM w0.14: v1(225.67,8.06) R1054.1 223.91,8.06 v1(223.06,7.21) 222.97,7.21 222.15,6.38 JFP.1
N128737185:
  vias: v2(218.16,5.06)
N128760761: length 3.2
  BOTTOM w0.254: PU700.21 189.77,115.93 189.36,116.34 189.36,116.84 PR702.2
N128763343: length 3.7
  BOTTOM w0.254: PU700.20 189.76,115.43 188.91,116.28 v1(188.91,116.68) 188.91,116.98 189.61,117.67 PR703.2
N128763348: length 3.3
  BOTTOM w0.14: PR701.2 192.15,118.04 v1(192.43,118.32)
  BOTTOM w0.254: PU700.22 190.22,116.89 190.69,117.36 190.83,117.36 PR701.2
N128763482: length 6.2
  TOP w0.14: v1(187.67,119.6) 188.09,119.19 PR700.2
  TOP w0.254: v2(189.36,115.13) 189.42,115.2 PC700.1 188.09,117.23 PR700.2
  BOTTOM w0.254: PU700.19 189.56,114.93 v2(189.36,115.13)
N128764878: length 4.8
  BOTTOM w0.254: PU700.18 189.37,114.43 v1(188.83,114.96) 188.47,115.32 PC701.2
N128783349: length 4.5
  TOP w0.254: v2(196.34,116.34) 196.69,116.68 v1(196.69,117.12) 196.69,117.26 195.89,118.06 PC1534.1 195.84,118.04 195.82,118.03 194.9,118.03 PR706.2
  BOTTOM w0.254: PU700.2 195.68,115.93 196.09,116.34 v2(196.34,116.34)
N128783984: length 1.3
  TOP w0.14: v1(197.71,111.48) 198.18,111.95 PC714.2
N128849465:
  vias: v2(138.24,111.77)
N128849469: length 2.1
  BOTTOM w0.14: PR1224.1 137.2,109.88 v1(136.55,109.23)
  BOTTOM w0.254: PC1201.1 PR1224.1
N128849471: length 9.3
  BOTTOM w0.14: v3(133.11,104.54) 133.48,104.91 134.68,104.91 135.29,105.52 135.29,107.77 136.29,108.77 137.35,108.77 PR1224.2
  BOTTOM w0.254: PU1200.3 138.29,109.78 138.11,109.61 138.11,109.53 PR1224.2
N128855110: length 0.6
  TOP w0.14: v2(138.39,116.93) v1(137.75,116.93)
N128855114: length 0.8
  BOTTOM w0.254: PR1225.1 PC1228.1
N128855116: length 1.5
  BOTTOM w0.254: PU1201.3 138.27,115.4 PR1225.2
N128856156:
  vias: v2(158.7,118.06)
N128856160: length 0.8
  BOTTOM w0.254: PC1250.1 PR1226.1
N128856162: length 5.8
  BOTTOM w0.14: 156.52,118.88 156.34,119.05 153.57,119.05 v1(152.81,118.3)
  BOTTOM w0.254: PU1202.3 157.16,118.24 156.52,118.88
N128861659: length 3.5
  BOTTOM w0.14: 105.21,82.81 105.64,83.24 105.64,85.94 v1(105.8,86.1)
N128861671: length 0.9
  BOTTOM w0.254: PC1308.1 104.12,81.68 PR1320.1
N128861673: length 2.8
  BOTTOM w0.14: PR1320.2 103.93,79.68 v1(104.14,79.46)
  BOTTOM w0.254: PU1300.3 104.76,81.08 104.69,81.01 104.38,81.01 103.95,80.58 PR1320.2
N128862480: length 0.9
  BOTTOM w0.254: PC1337.1 PR1321.1
N128862482: length 3.7
  BOTTOM w0.254: PR1321.2 v2(103.63,75.15) 103.63,73.67 103.84,73.46 PU1301.3
N128955515: length 4.4
  TOP w0.254: PQ205.1 26.17,32.12 26.07,32.03 26.07,30.58 25.67,30.17 v1(25.67,29.76) 25.67,29.45 26.18,28.94 PR203.2
N128955517: length 7.8
  TOP w0.14: PR205.1 21.59,27.42 v1(21.31,27.14)
  TOP w0.254: PR205.1 PR201.2 20.46,28.13 19.99,28.6 PC200.2 19.78,27.52 v2(19.57,27.31)
  BOTTOM w0.254: PQ200.4 20.04,29.57 19.57,29.11 v2(19.57,27.31)
N128955519: length 36.3
  TOP w0.14: v1(14.31,33.7) 15.95,33.7 PQ204.1
  TOP w0.254: v2(29.3,27.17) 29.29,27.19 28.56,27.19 PC220.2 28.2,27.25 PR200.2 PR203.1 ; PQ204.1 15.15,34.81 v2(14.16,34.81)
  IN3 w0.254: v2(29.3,27.17) 29.3,26.5 27.84,25.05 23.06,25.05 21.73,23.72 19.48,23.72 19.31,23.55 17.87,23.55 17.55,23.23 16.01,23.23 15.58,23.66 15.58,26.27 15.1,26.75 15.1,34.25 14.54,34.81 v2(14.16,34.81)
  BOTTOM w0.254: v2(29.3,27.17) 29.3,27.4 29.08,27.62 PQ201.4
N128955532: length 2.3
  TOP w0.254: PR209.2 26.61,31.3 27.24,31.93 PQ205.2
N128955534: length 3
  TOP w0.102: v1(25.26,1.06) 25.07,1.25 25.07,1.92
  TOP w0.254: PR232.2 24.27,2.73 25.07,1.92 PQ220.1
N128955539: length 33.6
  TOP w0.14: v1(19.81,5.09) 19.88,5.15 PR226.1
  TOP w0.254: PR224.2 22.21,10.12 21.95,9.85 v2(21.95,9.09) 21.95,8.14 21.54,7.73 PQ217.1 PR226.1 ; PC289.2 16.19,27.86 v2(16.19,27.22) 16.22,27.25 PC222.2
  IN1 w0.254: v2(21.95,9.09) 22.23,9.37 22.23,11.37 21.32,12.28 19.27,12.28 16.19,15.35 16.19,21.15 16.36,21.32 16.36,22.7 15.67,23.39 15.67,24.6 16.42,25.35 16.42,26.99 v2(16.19,27.22)
  BOTTOM w0.254: PQ213.4 16.79,27.29 16.61,27.47 16.44,27.47 v2(16.19,27.22)
N128955543: length 5
  TOP w0.102: v1(25.15,5.11) 25.15,5.09 24.86,4.8
  TOP w0.254: PR226.2 22.14,4.85 23.28,4.85 23.6,5.17 24.5,5.17 25.34,4.33 PQ219.1
N128955551: length 56.6
  TOP w0.254: PR232.1 23.01,1.81 v3(22.89,1.69) 22.76,1.56 PR222.2 20.74,1.56 20.64,1.66 PC208.2 17.31,1.66 v2(17,1.98) ; v2(14.08,31.04) 14.15,30.97 PC288.2 ; v2(18.16,26.04) 18.06,26.15 17.6,26.15 PR227.2
  IN3 w0.254: v2(17,1.98) 11.42,7.56 11.42,9.08 11.49,9.15 11.49,13.81 11.23,14.08 8.56,14.08 8.04,14.6 8.04,16.13 8.18,16.27 8.18,17.86 8.73,18.42 8.73,19.04 10.08,20.39 10.08,23.36 10.47,23.75 11.51,23.75 13.45,25.69 13.45,29.88 14.08,30.51 v2(14.08,31.04)
  IN6 w0.254: v2(18.16,26.04) 15.3,26.04 14.4,26.95 14.4,30.72 v2(14.08,31.04)
  BOTTOM w0.254: PQ212.4 15.09,30.2 14.24,31.04 v2(14.08,31.04)
N128955561: length 3.9
  TOP w0.254: PQ219.2 26.01,3.68 25.77,3.44 v1(25.08,3.44) 24.84,3.68 24.13,3.68 PR267.2
N128955562: length 3.7
  TOP w0.102: 29.05,6.84 29.05,6.96 29.59,7.5 v1(29.59,8.26)
  TOP w0.254: PQ232.2 29.7,6.18 29.05,6.84 PR235.2
N128955571:
  vias: v3(20.45,20.16)
N128955602: length 2.3
  TOP w0.254: PQ206.1 29.66,33.53 v1(29.08,34.11) 28.98,34.21 PR206.2
N128955607: length 33.3
  TOP w0.14: PR220.2 22.35,4.21 v1(22.87,3.69)
  TOP w0.254: PR220.2 v2(20.84,4.21) 20.65,4.21 20.48,4.04 20.12,4.04 PR229.1 ; v2(15.94,26.69) 15.71,26.92 15.71,27.67 15.44,27.94 PQ216.2
  IN1 w0.254: v2(20.84,4.21) 21.46,4.83 21.46,9.91 21.87,10.32 21.87,11.22 21.17,11.92 19.12,11.92 15.05,15.99 15.05,19.25 15.56,19.77 15.56,21.86 15.32,22.11 15.32,24.74 15.94,25.37 v2(15.94,26.69)
N128955616: length 4.6
  TOP w0.14: v1(12.99,26.32) 13.82,27.15 PQ216.1
  TOP w0.254: PQ216.1 15.14,27.15 15.36,26.93 15.36,26.59 15.74,26.21 PR227.1
N128955622: length 11.9
  TOP w0.254: PR206.1 27,34.07 24.35,34.07 24.18,34.24 v3(23.24,34.24) 22.19,34.24 21.91,33.96 21.91,32.85 21.66,32.6 20.59,32.6 19.37,31.38 PR202.2 19,32.08 PQ204.2
N128955623: length 6.5
  TOP w0.14: PQ232.1 30.35,7.88 30.67,8.2 v1(31.05,8.2)
  TOP w0.254: PQ219.3 29.04,4.98 29.34,4.69 29.91,4.69 30.35,5.12 PQ232.1
N128955625: length 11
  TOP w0.14: PQ222.1 30.1,1.15 30.23,1.02 v1(31.05,1.02)
  TOP w0.254: v2(29.47,1.85) 29.72,1.6 PQ222.1 ; PR230.2 25.46,6.02 v2(25.97,6.52)
  IN1 w0.254: v2(29.47,1.85) 29.21,2.1 29.21,6.04 28.73,6.52 v2(25.97,6.52)
N128955629: length 4.5
  TOP w0.14: v1(23,5.25) PQ217.2
  TOP w0.254: PR223.2 PR230.1 24.92,6.77 PQ217.2
N128955637: length 2.3
  BOTTOM w0.14: v1(15.5,58.24) 15.7,58.44 PR225.2
  BOTTOM w0.254: PR225.2 16.08,59.7 PQ218.1
N128955643: length 11.2
  TOP w0.381: PR219.2 11.75,62.05 v2(12.38,62.68)
  BOTTOM w0.254: PC221.2 10.82,59.16 11.72,59.16 12.33,59.78 14.35,59.78 14.78,59.34 PR225.1
  BOTTOM w0.381: v2(12.38,62.68) 12.54,62.84 13.4,62.84 13.56,63 PQ214.4
  BOTTOM w0.457: v2(12.38,62.68) v1(11.9,62.2) 11.69,61.98 11.69,61.35 10.73,60.39 PC221.2
N128955656: length 12.2
  TOP w0.254: PR259.1 11.38,22.75 v2(11.01,22.38) 10.93,22.38 10.39,21.85 PR263.1
  IN3 w0.254: v2(11.01,22.38) 11.45,22.38 12.12,21.71 12.12,18.79 11.13,17.8 v2(10.95,17.8)
  BOTTOM w0.14: v1(10.63,17.03) 10.95,17.34 v2(10.95,17.8)
  BOTTOM w0.254: PU202.5 10.4,19.65 10.31,19.57 PC214.2 PR261.2 10.31,18.44 v2(10.95,17.8)
N128955663: length 12.3
  TOP w0.14: v1(11.69,25.79) 11.18,25.28 v2(11.18,24.96)
  TOP w0.254: PR257.1 PR264.2 11.06,24.85 v2(11.18,24.96)
  IN5 w0.254: v2(11.18,24.96) 10.48,24.27 10.48,20.46 11.52,19.41 v2(11.52,18.93)
  BOTTOM w0.254: v2(11.52,18.93) 12.09,18.93 12.64,19.48 12.64,20.04 12.38,20.3 PU202.6
N128955690: length 3.9
  BOTTOM w0.14: v1(12.07,25.02) 11.25,24.2 PQ228.1
  BOTTOM w0.254: PR253.1 10.1,23.12 10.1,23.63 10.67,24.2 PQ228.1
N128955696: length 6.9
  BOTTOM w0.14: PR260.2 18.68,19.06 19.2,19.58 19.53,19.58 v1(19.98,20.02)
  BOTTOM w0.254: PR273.1 17.65,20 PR260.2 ; PR273.1 16.98,20.07 16.76,20.3 PU202.3 ; PR273.1 17.65,20.7 PR258.1 PC215.2
N128955697: length 4.5
  BOTTOM w0.14: PR265.2 v1(14.44,23.97)
  BOTTOM w0.254: PR265.2 PR254.1 15.36,21.86 15.24,21.75 15.24,21.41 15.7,20.95 PU202.2
N128955727: length 2.3
  TOP w0.254: PR268.2 30.29,30.25 v1(29.92,30.62) 29.45,31.09 PQ206.2
N128955733: length 8.3
  TOP w0.14: v2(30.75,4.35) 30.74,4.34 28.98,4.34 v1(28.83,4.49)
  TOP w0.254: PQ222.2 v2(30.75,4.35) ; PR228.2 v2(26.67,5.79)
  BOTTOM w0.254: v2(26.67,5.79) 28.11,4.35 v2(30.75,4.35)
N128955736: length 2.2
  TOP w0.14: PR231.2 17.39,3.03 v1(17.86,2.56)
  TOP w0.254: PR231.2 16.4,3.5 PQ223.2
N128955741: length 1.4
  TOP w0.254: PQ208.1 22.16,28.47 PR205.2
N128955744: length 7.9
  TOP w0.254: PR213.2 20.8,31.3 v1(21.62,31.3) 21.63,31.3 22.07,30.86 PQ211.1 ; PQ208.2 23.89,27.82 23.7,28.01 23.7,28.8 23.31,29.19 23.31,30.58 23.03,30.86 PQ211.1 ; PQ211.1 22.74,30.22 PR217.1
N128955756: length 8.2
  TOP w0.14: PU203.4 25.85,22.24 v1(24.96,21.34)
  TOP w0.254: 28.55,25.95 28.42,26.08 PQ225.1 ; 28.55,25.95 28.55,25.36 28.31,25.12 PR271.1 PR272.1 28.18,23.69 26.73,22.24 PU203.4 ; 28.55,25.95 28.97,26.37 PC299.1
N128955775: length 54.5
  IN5 w0.254: v2(15.77,60.66) 16.26,60.17 16.26,45.04 15.24,44.03 15.24,30.16 12.69,27.61 12.69,26.61 12.2,26.11 11.64,26.11 9.91,24.39 9.91,19.87 8.32,18.27 8.32,14.08 8.72,13.68 8.72,13.17 8.73,13.16 v2(8.73,13.14)
  BOTTOM w0.254: v2(8.73,13.14) 8.56,13.31 v1(8.22,13.31) 8.19,13.28 8.19,12.34 PR290.2 ; v2(15.77,60.66) 16.05,60.93 PQ218.2
N128955822: length 6.8
  TOP w0.14: PQ223.1 15.69,1.09 15.81,0.96 v1(16.47,0.96)
  TOP w0.254: PQ223.1 15.69,1.9 16.24,2.46 17.2,2.46 17.5,2.16 18.15,2.16 19.17,3.17 PR229.2
N128955834: length 9.3
  TOP w0.14: PQ221.2 36.75,26.96 35.79,27.92 35.5,27.92 35.22,28.21 35.22,28.98 35.37,29.13 35.37,30.32 35.18,30.51 35.18,31.4 35.19,31.41 PR275.2 PC223.2 35.15,32.86 PR276.1 v1(36.17,33.78)
N128955845: length 2.7
  TOP w0.14: v1(31.74,29.31) 32.46,29.31 PQ231.2
  TOP w0.254: PR277.2 32.29,30.48 32.75,30.01 PQ231.2
N128955847: length 3.8
  TOP w0.102: v1(34.56,34.84) 34.56,34.1 PR276.2
  TOP w0.14: PQ231.1 33.4,32.19 33.77,32.56 33.77,33.31 PR276.2
N128955848: length 27.2
  TOP w0.254: PQ224.2 15.44,25.21 v2(14.8,25.85) ; v2(19.25,9.8) 19.25,9.88 18.07,11.06 18.07,12.28 18.58,12.79 PR278.2 18.61,13.48 19.22,14.09 PR279.1
  IN1 w0.254: v2(19.25,9.8) 19.25,11.29 14.01,16.53 14.01,19.49 14.85,20.34 14.85,21.57 14.61,21.82 14.61,24.24 14.06,24.79 14.06,25.5 14.42,25.85 v2(14.8,25.85)
  BOTTOM w0.14: v2(14.8,25.85) 15.24,25.85 v1(15.53,25.56)
N128955851: length 2.2
  TOP w0.254: PR279.2 v1(20.26,15.01) 20.26,15.01 PQ233.1
N128955875: length 30.3
  TOP w0.102: v1(14.92,0.96) 14.86,0.96 14.29,1.53
  TOP w0.203: v2(26.86,1.66) 27.25,1.27 PQ220.2
  TOP w0.254: v2(14.76,2.01) 14.29,1.53 PR282.2 PR234.2 ; v2(10.16,3.37) 10.1,3.31 9.78,3.31 9.54,3.07 PR283.2
  IN6 w0.254: v2(10.16,3.37) 11.56,3.37 12.92,2.01 v2(14.76,2.01) 15.28,1.5 26.7,1.5 v2(26.86,1.66)
  BOTTOM w0.254: PD211.2 10.6,7.19 11.75,6.04 11.75,4.52 10.61,3.37 v2(10.16,3.37)
N128955890: length 1.2
  TOP w0.254: PR282.1 13.05,1.45 PU204.4
N128958040: length 1.7
  TOP w0.14: PR705.1 195.26,116.7 v1(194.86,117.1)
N128958698: length 6.9
  TOP w0.14: v2(243.14,112.09) 243.84,112.09 v1(243.85,112.1)
  IN6 w0.254: v2(243.14,112.09) 242.32,112.09 241.71,112.69 v2(240.82,112.69)
  BOTTOM w0.254: v2(240.82,112.69) 240.82,112.88 240.7,113 PU900.4 ; PR905.2 PC907.2 243.55,111.06 PR907.1 v2(243.14,112.09)
N128958708: length 7.5
  TOP w0.254: PR988.2 PR987.2 PR986.2 240.46,110.54 PR902.1 240.14,110.55 v2(239.82,110.86)
  BOTTOM w0.254: PU900.1 239.35,113.06 239.21,112.91 v1(239.21,112.3) 239.21,111.48 v2(239.82,110.86) 240.42,111.46 PC900.1
N128958713: length 21.5
  IN6 w0.254: v2(229.05,115.07) 229.05,112.66 229.68,112.02 240.21,112.02 240.89,111.34 v2(245.95,111.34)
  BOTTOM w0.254: PR905.1 PC907.1 245.58,111.34 v2(245.95,111.34)
  vias: v1(228.07,114.18) v2(226.32,115.07) v2(226.95,115.07) v2(227.65,115.07) v2(228.35,115.07)
N128958738: length 3.9
  BOTTOM w0.254: PU900.5 241.15,113.07 241.24,112.98 241.24,112.97 241.63,112.58 241.83,112.58 242.05,112.37 242.74,112.37 v1(242.96,112.59) 243.7,112.59 PC912.1
N128958750: length 1.5
  TOP w0.14: v1(238.94,113.99) 239.19,114.25 PR904.2
N128967490: length 8
  TOP w0.14: v1(18.85,10.85) 19.59,10.12 PR106.1
  TOP w0.254: v2(20.7,10.09) 20.68,10.12 PR106.1
  BOTTOM w0.254: BAT100.5 22.35,10.7 21.75,10.09 v2(20.7,10.09)
N128967591: length 8.7
  TOP w0.14: PR108.1 21.76,14.09 v1(22.19,14.52)
  TOP w0.254: v2(21.24,10.71) 21.43,10.9 21.43,12.62 21.27,12.77 PR108.1
  BOTTOM w0.254: v2(21.24,10.71) 20.85,11.1 BAT100.6
N128967644: length 13.8
  TOP w0.102: v2(26.04,10.55) 26.23,10.55 v1(26.67,10.11)
  TOP w0.254: v2(26.04,10.55) 26,10.58 PR111.1
  BOTTOM w0.254: BAT100.7 19.35,10.38 20.12,9.61 25.1,9.61 v2(26.04,10.55)
N129647865: length 3.4
  TOP w0.14: v1(198.49,105.88) PR728.2
  TOP w0.254: PQ700.2 198.49,108.49 PR725.2 PR728.2
N129647869: length 3
  TOP w0.14: PR724.2 196.79,108.97 v1(196.8,108.96)
  TOP w0.254: PQ700.1 197.54,110.66 PR724.2
N129673756: length 4.2
  TOP w0.14: PR729.2 191.75,118.04 v1(191.15,118.64)
  TOP w0.254: PR729.2 192.3,118.04 193.22,118.96 PR730.2 v2(193.36,119.64)
  BOTTOM w0.254: PR722.1 v2(193.36,119.64)
N129720076: length 5.6
  TOP w0.14: QV86.1 247.36,100.11 v1(247.75,99.72)
  TOP w0.254: QV86.1 244.16,101.13 RV511.1
N130300832:
  vias: v1(204.81,47.33)
N130300854: length 2.4
  TOP w0.14: UZ24.6 210.98,49.36 211.21,49.12 CZ98.1
N130402545: length 11.8
  TOP w0.14: RV1073.1 221.68,50.42 RV1072.1 220.65,51.47 220.2,51.92 220.2,53.24 v1(218.3,55.14) 217.49,55.95 216.03,55.95 v2(215.39,56.59)
  BOTTOM w0.102: 215.21,57.06 215.21,57.87 UV18.J1
  BOTTOM w0.14: v2(215.39,56.59) 215.21,56.77 215.21,57.06
N130469387: length 4.4
  BOTTOM w0.14: v1(220.26,54.67) 219.42,55.51 RV1077.1 218.82,56.44 218.7,56.57 218.7,58.06 UV18.E1
N130500830: length 7.1
  TOP w0.127: v1(202.77,44.55) 202.52,44.55 201.86,45.2 v2(200.62,45.2)
  TOP w0.381: v2(200.62,45.2) 200.53,45.2 200.15,45.58 QV21.2 ; RV1132.1 RV1131.1 200.15,43.06 QV21.5 200.15,44.43 v2(199.91,44.67)
  IN6 w0.381: v2(199.91,44.67) 200.09,44.67 v2(200.62,45.2)
N130673414: length 1.3
  TOP w0.14: v1(191.11,87.38) 191.11,87.37 191.39,87.09 LV24.2
N130675629: length 5.5
  TOP w0.14: RV1082.2 218.44,43.56 QV91.3 216.58,41.7 v1(215.29,41.7)
N130675694: length 2.5
  TOP w0.14: v1(219.69,41.61) 219.48,41.82 RV1084.2 218.77,42.59 QV91.2
N130775721: length 3.6
  TOP w0.14: RT430.2 20.23,58.61 v2(19.5,57.87)
  BOTTOM w0.081: v2(19.5,57.87) 19.51,57.87 19.56,57.92 19.75,57.92 19.99,58.16 19.99,58.27 20.15,58.43 20.48,58.43 20.6,58.3 20.62,58.3 20.62,58.3 20.77,58.15 21.18,58.15 21.37,58.33 UT4.E2
N130798734: length 4.2
  TOP w0.14: QV91.1 216.65,43.8 216.21,44.24 RV1083.1 216.21,45.61 216.74,46.15 v1(217.06,46.15)
N130986130: length 5.7
  TOP w0.14: RT437.1 29.68,56.52 v1(29.68,57.27) 29.68,57.42 v2(29.4,57.7)
  BOTTOM w0.081: UT4.D10 25.62,58.15 26,58.15 26.35,57.79 26.81,57.79
  BOTTOM w0.14: 26.81,57.79 28.59,57.79 28.69,57.7 v2(29.4,57.7)
N131865475: length 4.3
  TOP w0.14: v2(198.57,118.63) v1(198.57,119.26)
  TOP w0.254: v2(198.57,118.63) 198.59,118.6 PC756.1 198.59,117.26 PR755.2
  BOTTOM w0.254: PC755.1 198.25,118.31 v2(198.57,118.63)
N132121209: length 3.1
  TOP w0.14: CV925.1 v1(221.69,111.32)
  TOP w0.508: RV622.2 RV621.2 221.69,109.15 CV925.1
N132122697: length 2.9
  TOP w0.14: RV627.2 218.38,103.78 v1(218.06,103.46)
  TOP w0.508: RV627.2 RV626.2 219.97,103.8 CV928.1
N132123770: length 3
  BOTTOM w0.14: v1(241.38,72.04) CV987.1 241.38,70.8 RV628.2 RV629.2
N132124417: length 2.9
  BOTTOM w0.14: RV638.2 RV637.2 238.12,75.1 CV990.1 v1(238.09,76.26)
N132190190: length 3.1
  TOP w0.14: PR1800.1 178.86,13.93 v1(178.08,13.15)
  TOP w0.254: PR1800.1 179.04,14.39 179.9,14.39 180.03,14.25 PU1800.5
N132221893: length 1.7
  TOP w0.14: T209.1 229.03,41.44 RV1106.2
N132908405: length 5.5
  TOP w0.127: QZ14.5 221.35,118.39 221.98,119.02 v1(221.98,120.2)
  TOP w0.254: QZ14.5 QZ14.6 220.04,117.74 RV103.2 219.86,116.89 QZ18.2
N132908425: length 2.4
  TOP w0.127: RV1808.2 225.02,119.22 v1(225.34,119.54)
  TOP w0.254: QZ14.3 224.02,119.04 RV1808.2
N132908471: length 7.5
  TOP w0.254: QZ16.5 158.8,119.19 v1(159.4,119.78) 159.65,120.04 161.84,120.04 RV1809.2 163.06,118.81 QZ15.3
N132908541: length 3.8
  TOP w0.14: RV111.2 251.33,43.58 251.67,43.24 QZ17.6 QZ17.5 252.83,42.59 v1(253.2,42.22)
N132908575: length 3
  TOP w0.127: v1(153.62,117.86) 153.62,118.89 RV1810.2
  TOP w0.254: RV1810.2 154.31,119.25 155.02,118.54 QZ16.3
N132908582: length 3.3
  TOP w0.127: v1(219.94,113.45) 219.62,113.76 QZ18.1
  TOP w0.254: RV112.2 220.98,114.58 QZ18.1
N132908588: length 2.5
  TOP w0.14: v1(248.68,41.31) 248.68,41.79 RV1811.2 249.44,41.94 QZ17.3
N132951149: length 3
  TOP w0.14: v1(251.56,57.43) 252.05,56.94 RV8.2 251.32,55.39 QZ6.6
N132951151: length 3.9
  TOP w0.14: v1(253.59,51.75) 253.44,51.9 RV12.2 ; RV12.2 252.62,51.92 QZ6.3 ; RV12.2 252.15,51.9 251.97,52.08 QZ6.2
N132951302: length 2.8
  TOP w0.14: RV11.2 255.35,41.98 QZ7.3 256.81,43 v1(256.82,43.01)
N132957909: length 168
  TOP w0.127: RV1522.1 242.67,41.82 v1(242.67,41.55)
  TOP w0.254: RV1522.1 CV1500.1 244.26,44.27 DA55.2 245.47,44.88 v2(246.01,44.88) ; v2(182.49,116.71) 182.49,114.73 RV1806.2
  IN1 w0.254: v2(225.91,119.87) 232.8,119.87 234.99,117.69 235.57,117.36 235.69,117.34 235.79,117.3 235.89,117.24 235.97,117.16 236.22,116.93 237.13,116.93 237.33,116.73 237.33,116.39 237.66,116.06 240.87,116.06 241.38,116.57 247.69,116.57 249.18,115.08 249.18,110.73 249.51,110.4 249.51,98.27 250.78,96.99 250.78,95.26 252.01,94.03 252.01,60 252.36,59.65 252.36,55.55 253.71,54.2 253.71,52.71 254.33,52.09 254.33,46.88 253.06,45.61 249.21,45.61 248.39,44.79 246.1,44.79 v2(246.01,44.88)
  IN2 w0.254: v2(225.91,119.87) 197.93,119.87 197.03,118.97 197.03,114.72 196.9,114.59 195.4,114.59 195.28,114.72 195.28,117.68 194.51,118.45 189.87,118.45 189.84,118.48 186.6,118.48 186.42,118.3 181.93,118.3 181.59,117.95 181.59,117.37 182.25,116.71 v2(182.49,116.71)
N132958139: length 2.5
  TOP w0.14: RV1129.1 174.8,111.55 174.8,111.88 v1(174.81,111.88)
  TOP w0.254: UV28.1 175.88,111.26 RV1129.1
N132958145: length 4.5
  TOP w0.14: v1(179.59,115.27) 179.59,114.65 RV1807.2
  TOP w0.356: UV28.4 177.18,114.09 177.31,114.22 CV918.1
  TOP w0.381: RV1807.2 179.93,114.13 179.24,114.13 RV1128.1 CV918.1
N132961365: length 6.6
  TOP w0.14: v1(201.69,47.81) 199.72,49.78 199.12,49.78 QV103.2 197.7,51.2 RV590.1
N133374229: length 2.3
  TOP w0.14: QR104.1 RT1133.2 v1(272.86,4.09)
N133508832: length 8.1
  TOP w0.14: v2(162.32,11.17) 162.32,10.89 v1(165.1,8.11) 165.37,7.84 RZ1139.2 RZ1138.2
  BOTTOM w0.14: v2(162.32,11.17) 162.27,11.12 JKB.3
N133541775: length 3.5
  TOP w0.14: QV104.3 225.35,44.15 225.16,44.34 224.89,44.34 224.7,44.15 QV104.2 224.7,42.92 RV1140.2 224.56,42.78 223.86,42.78 v1(223.69,42.95)
N134346262: length 3.5
  TOP w0.14: QV98.2 243.75,47.11 RV1112.2 244.39,45.47 v1(245.54,45.47)
N134700089: length 3.3
  TOP w0.14: RI46.1 317.22,38.75 QI10.1 v1(315.34,39.42)
N1211736753: length 4.8
  BOTTOM w0.089: 75.06,20.83 77.21,18.68 77.93,18.68 UH2.R44
  BOTTOM w0.14: T91.1 74.75,21.14 75.06,20.83
N1211736754: length 5.9
  BOTTOM w0.089: 75.06,20.06 75.45,20.06 77.02,18.5 78.14,18.5 78.51,18.87 UH2.R43
  BOTTOM w0.14: 75.06,20.06 T92.1
N1211736758: length 4.4
  BOTTOM w0.089: T94.1 75.89,19.38 76.94,18.32 77.27,18.32 77.57,18.02 78.65,18.02 78.74,17.92 78.95,17.71 UH2.U42
N1257483751: length 4.3
  TOP w0.14: QE19.4 194.53,13.34 194.82,13.63 v1(195.84,13.63) 197.2,13.63 197.52,13.31 QE2.4
N12017464511: length 3.8
  BOTTOM w0.089: UH2.AL42 78.95,10.89 78.74,11.1 78.42,11.1 78.37,11.15 75.79,11.15 T120.1
N12017464512: length 4
  BOTTOM w0.089: T121.1 76.41,10.08 76.61,9.87 77.86,9.87 78.02,10.03 78.76,10.03 78.89,9.9 UH2.AN42
N12017464513: length 5.4
  BOTTOM w0.089: UH2.AM43 78.68,10.29 78.43,10.54 77.93,10.54 77.67,10.8 76.48,10.8 76.37,10.7 75.06,10.7
  BOTTOM w0.14: T122.1 74.28,10.7 75.06,10.7
N12017464514: length 1.6
  TOP w0.089: v2(82.99,11.28) 83.44,11.73 T123.1
  BOTTOM w0.089: UH2.AJ33 83.39,11.69 v2(82.99,11.28)
N12017464515: length 2.9
  BOTTOM w0.089: UH2.AH44 77.96,12.56 77.79,12.39 75.93,12.39 T124.1
N12017464518: length 5.4
  BOTTOM w0.089: 75.06,12.43 75.32,12.16 77.88,12.16 78.05,12.33 78.16,12.33 78.82,12.33 78.97,12.18 UH2.AJ42
  BOTTOM w0.14: T127.1 74.97,12.52 75.06,12.43
N12117367569: length 1.3
  TOP w0.089: v2(82.99,12.7) 83.44,13.16 T182.1
  BOTTOM w0.089: v2(82.99,12.7) 82.63,13.06 UH2.AG35
N12117367571: length 1.6
  TOP w0.089: v2(82.99,13.74) 82.99,14.14 T104.1
  BOTTOM w0.089: UH2.AD35 v2(82.99,13.74)
N12117367572: length 1.2
  TOP w0.089: v2(84.56,13.74) 84.81,13.48 T105.1
  BOTTOM w0.089: UH2.AD31 v2(84.56,13.74)
N12117367573: length 1.5
  TOP w0.089: T106.1 81.46,14.25 v2(81.46,13.74)
  BOTTOM w0.089: UH2.AD38 v2(81.46,13.74)
N12117367574: length 3.8
  BOTTOM w0.089: T107.1 76.04,15.34 76.2,15.5 77.52,15.5 77.96,15.07 78.43,15.07 78.67,14.84 UH2.AC43
N12117367575: length 4.8
  BOTTOM w0.089: 75.06,15.99 75.22,15.99 75.57,15.64 75.9,15.64 76,15.74 77.67,15.74 UH2.AB44
  BOTTOM w0.14: T108.1 75.06,15.99
N12449474450: length 2.9
  BOTTOM w0.081: 25.24,55.47 25.24,55.52 25.12,55.64 25.12,56.65 UT4.B9
  BOTTOM w0.14: T191.1 25.24,54.9 25.24,55.47
N12449474451: length 1.5
  BOTTOM w0.081: 24.87,55.47 UT4.A9
  BOTTOM w0.14: 24.87,55.47 24.87,55.08 24.73,54.94 T192.1

## Copper pours and planes (outline as drawn)
1.2V_B+ on TOP (solid shape): 278.13,32.84 278.13,30.74 277.56,30.17 275.53,30.17 275.27,29.92 275.27,29.35 275.21,29.28 274.64,29.28 274.58,29.35 274.58,29.54 274.32,29.79 274.07,29.79 273.78,30.07 273.78,32.65 274.1,32.97 278,32.97
1.2V_B+ on BOTTOM (solid shape): 276.06,33.51 276.7,33.42 277.67,33.3 278.65,33.22 278.67,33.21 278.86,33.02 278.86,32.29 279.2,32.29 279.25,32.24 279.25,31.71 279.24,31.71 278.71,31.71 278.69,31.68 278.69,31 278.72,30.97 279.24,30.97 279.25,30.96 279.25,30.52 279.22,30.49 278.7,30.49 278.7,30.49 278.7,29.79 278.71,29.77 279.24,29.77 279.24,29.77 279.24,29.09 278.07,27.91 278.07,26.87 277.94,26.74 276.92,26.74 276.86,26.81 276.86,27.95 277.4,28.49 277.4,29.73 276.89,30.23 275.53,30.23 275.27,29.98 275.27,29.35 275.21,29.28 274.7,29.28 274.64,29.35 274.64,29.98 274.26,30.36 271.93,30.36 271.82,30.47 271.82,33.39 271.97,33.54 275.89,33.54
1V8_3.3V_GFX_RUN on TOP (solid shape): 211.71,50.67 212.95,50.67 213.32,50.31 213.32,49.31 213.17,49.16 211.71,49.16 211.17,49.7 210.27,49.7 210.17,49.8 210.17,50.4 209.97,50.59 209.54,50.59 209.35,50.78 209.35,51.35 209.56,51.57 210.81,51.57
+0.6VS on TOP (solid shape): 174.55,17.93 177.75,17.93 177.9,17.78 177.9,16.85 176.98,15.93 173.89,15.93 173.68,16.15 173.68,17.01 173.5,17.19 173.5,18.03 173.55,18.09 174.4,18.09
+0.6VS on TOP (solid shape): 282.37,28.02 282.87,28.02 282.87,28.56 283.17,28.56 283.17,28.02 283.67,28.02 283.67,28.56 284.44,28.56 284.61,28.39 284.61,25.85 284.04,25.28 282.6,25.28 282.6,25.28 281.7,25.28 281.39,25.6 281.39,28.4 281.55,28.56 282.37,28.56
+0.6VS on TOP (solid shape): outline of 201 points within 249.37,13.36 257.75,17.88
+0.6VS on IN4 (solid shape): 177.09,17.06 177.09,16 176.65,15.56 174.09,15.56 173.65,16 173.65,17.06 173.94,17.36 176.8,17.36
+0.6VS on IN4 (solid shape): 250.9,16.94 250.9,15.16 250.06,14.32 249.81,14.32 248.93,15.2 248.93,15.49 249.33,15.88 249.33,16.93 249.48,17.08 250.77,17.08
+0.6VSP on TOP (solid shape): 286.93,30.98 286.93,30.58 286.86,30.52 286.41,30.52 286.26,30.36 286.26,29.79 286.01,29.54 285.31,29.54 284.45,28.68 283.55,28.68 283.55,28.15 283.29,28.15 283.29,28.68 282.75,28.68 282.75,28.15 282.49,28.15 282.49,28.68 281.54,28.68 281.43,28.79 281.43,30.74 281.75,31.06 286.85,31.06
+0.6VSP on BOTTOM (solid shape): 286.62,30.57 287.21,30.57 287.29,30.5 287.29,30.39 287.22,30.32 285.35,30.32 285.18,30.49 285.18,31 285.24,31.06 286.13,31.06
+0.95VSP on TOP (solid shape): 118.94,61.77 118.94,60.4 118.75,60.21 115.24,60.21 115.12,60.33 115.12,62.93 115.31,63.13 117.57,63.13
+0.95VSP on BOTTOM (solid shape): 117.41,65.82 117.42,65.75 117.42,64.78 117.43,64.78 117.43,64.63 117.97,64.63 117.97,64.33 117.96,64.33 117.96,64.22 117.42,64.22 117.4,64.2 117.4,63.46 117.43,63.43 117.97,63.43 117.97,63.06 117.93,63.03 117.45,63.03 117.42,63 117.42,62.27 117.53,62.16 118.76,62.16 118.94,61.99 118.94,60.33 118.87,60.27 115.25,60.27 115,60.52 115,62.75 114.49,63.25 111.7,63.25 111.34,63.62 111.34,65.99 111.52,66.18 117.06,66.18
+1.0V_+1.8V_PLLVDD on TOP (solid shape): 199.76,100.04 199.76,98.19 199.51,97.95 195.67,97.95 195.11,97.39 195.11,96.38 193.51,94.78 192.54,94.78 192.38,94.95 192.38,95.54 192.56,95.72 193.06,95.72 194.44,97.1 194.44,97.89 195.39,98.84 197.84,98.84 198.25,99.25 198.25,100.15 198.38,100.28 199.52,100.28
+1.0V_+1.8V_PLLVDD on IN2 (solid shape): 193.8,95.32 193.8,95.13 193.61,94.94 192.98,94.94 192.41,94.37 192.34,94.37 192.03,94.69 192.09,94.75 192.15,94.75 192.91,95.51 193.61,95.51
+1.0V_+1.8V_PLLVDD on IN2 (solid shape): outline of 1344 points within 194.32,78.28 213.63,82.19
+1.2V_DDR on TOP (solid shape): 134.18,67.25 134.18,66.25 133.86,65.92 132.62,65.92 132.5,66.05 132.5,66.34 132.66,66.51 133.1,66.51 133.17,66.58 133.17,67.26 133.25,67.33 134.1,67.33
+1.2V_DDR on TOP (solid shape): outline of 31217 points within 109.71,15.86 257.67,68.49
+1.2V_DDR on BOTTOM (solid shape): 258.76,24.62 258.76,23.15 257.87,22.27 255.13,22.27 254.55,22.85 254.55,24.78 254.61,24.84 255.78,24.84 255.78,24.32 256.48,24.32 256.48,24.84 256.98,24.84 256.98,24.32 257.68,24.32 257.68,24.84 257.78,24.84 257.81,24.87 258.51,24.87
+1.2V_DDR on VCC: 248.26,14.99 247.65,15.61 247.65,18.28 246.49,19.44 128,19.44 127.49,19.95 117.96,19.95 117.22,20.69 117.22,25.13 116.06,26.3 114.48,26.3 114.1,26.68 114.1,28.61 114.46,28.96 253.16,28.96 259.59,22.53 259.59,15.48 259.21,15.1 259.21,14.99
+1.2V_MEN_P on BOTTOM (solid shape): 283.81,31.64 283.81,30.64 283.27,30.64 283.27,30.21 283.81,30.21 283.81,29.91 283.76,29.86 282.26,29.86 281.86,30.26 281.86,31.56 282.13,31.82 283.63,31.82
+1.2V_MEN_P on BOTTOM (solid shape): 263.89,33.46 263.89,29.7 263.15,28.95 262.69,28.95 261.05,27.31 261.05,25.92 260.16,25.03 257.57,25.03 257.57,24.96 257.56,24.96 257.56,24.45 257.11,24.45 257.11,24.96 257.08,24.96 257.08,24.97 256.38,24.97 256.38,24.96 256.36,24.96 256.36,24.45 255.91,24.45 255.91,24.96 255.88,24.96 255.88,24.97 255.07,24.97 254.83,25.22 254.83,28.71 255.33,29.22 255.33,31.63 256.16,32.46 260.43,32.46 261.31,33.34 261.31,33.51 261.36,33.57 263.78,33.57
+1.2V_MEN_P on IN1 (solid shape): 283.15,31.44 283.15,30.17 282.83,29.85 282.13,29.85 281.88,30.11 281.88,31.57 281.94,31.63 282.96,31.63
+1.2V_MEN_P on IN1 (solid shape): 263.28,29.29 263.28,29.02 263.78,28.52 263.78,28.27 263.59,28.08 262.76,28.08 262.07,28.77 262.07,29.39 262.23,29.55 263.02,29.55
+1.2V_VCCPLL_OC on IN6 (solid shape): outline of 944 points within 142.09,65.63 175.7,69.69
+1.8V_3.3V_GFX_AON on TOP (solid shape): 246.2,108.62 246.2,107.42 245.91,107.13 245.3,107.13 245.08,107.35 245.08,107.9 243.44,109.54 242.99,109.54 242.85,109.68 242.85,110.1 242.92,110.17 243.58,110.17 243.58,110.17 244.65,110.17
+1.8V_3.3V_GFX_AON on TOP (solid shape): 200.31,56.65 200.31,53.11 200.69,52.74 200.69,51.27 200.63,51.21 199.94,51.21 199.03,52.11 199.03,55.95 197.25,57.73 195.49,57.73 195.24,57.99 194.85,57.99 194.7,58.13 194.7,58.42 194.7,58.64 194.86,58.79 198.17,58.79
+1.8V_3.3V_GFX_AON on TOP (solid shape): 215,49.34 215.1,49.2 215.26,49.13 215.28,49.12 215.45,48.95 215.45,46.98 214.74,46.27 214.74,45.8 214.51,45.57 213.79,45.57 213.65,45.71 213.65,46.43 214.55,47.33 214.55,48.08 214.42,48.2 214.42,49.24 214.56,49.38 214.99,49.38
+1.8V_3.3V_GFX_AON on TOP (solid shape): 206.65,48.79 206.65,48.64 207.37,47.92 207.37,47.4 207.29,47.33 207.05,47.33 206.87,47.15 206.87,44.57 206.33,44.03 203.53,44.03 203.05,44.51 203.05,44.53 202.98,44.74 202.78,44.83 202.76,44.83 202.4,45.19 202.4,46.14 202.48,46.22 203.88,46.22 204,46.11 204,45.59 204.23,45.36 205.49,45.36 205.69,45.56 205.69,48.94 205.85,49.1 206.33,49.1
+1.8V_3.3V_GFX_AON on TOP (solid shape): 199.9,48.11 199.9,46.79 199.8,46.69 199.26,46.69 199.13,46.81 198.96,46.85 198.89,46.87 198.86,46.94 198.58,47.26 198.19,47.08 198.19,47.08 197.94,46.83 197.94,46.52 197.79,46.38 197.79,45.77 197.51,45.48 196.47,45.48 196.28,45.67 196.28,47.78 197.05,48.55 199.46,48.55
+1.8V_3.3V_GFX_AON on TOP (solid shape): 232.25,51.56 232.25,48.94 231.34,48.02 227.38,48.02 226.92,47.57 226.92,47.14 227,47.06 227.42,47.06 227.5,46.98 227.5,46.41 226.92,45.83 226.92,45.49 226.68,45.25 226.12,45.25 226.06,45.31 226.06,46.07 226.12,46.13 226.12,46.88 226.06,46.94 226.06,47.29 225.87,47.48 224.22,47.48 224.21,47.47 224.14,47.47 224.14,47.18 223.67,46.71 223.67,43.62 222.87,42.82 222.87,42.16 222.81,42.09 221.91,42.09 221.77,42.24 221.77,43.75 221.36,44.16 219.41,44.16 219.08,44.49 219.08,45.37 219.19,45.48 219.72,45.48 220.22,44.98 222.49,44.98 222.96,45.45 222.96,46 222.96,46.01 223,46.17 222.96,46.33 222.96,46.35 222.96,48.04 222.24,48.76 222.24,49.31 222.34,49.41 224.87,49.41 225.02,49.26 225.02,48.75 225.03,48.74 225.03,48.64 225.08,48.59 225.09,48.51 225.41,48.04 225.77,48.47 225.8,48.55 225.87,48.59 226.83,48.59 226.88,48.64 226.88,49.14 227.15,49.41 229.89,49.41 231.41,50.93 231.41,51.54 231.5,51.63 232.18,51.63
+1.8V_3.3V_GFX_AON on TOP (solid shape): outline of 294 points within 213.76,60.65 218.06,64.94
+1.8V_3.3V_GFX_AON on BOTTOM (solid shape): 215.24,64.75 215.24,64.64 215.45,64.43 215.45,64.08 215.63,63.9 215.63,63.71 215.49,63.57 214.56,63.57 214.07,64.06 214.07,64.7 214.25,64.88 215.11,64.88
+1.8V_3.3V_GFX_AON on BOTTOM (solid shape): 247.44,98.49 247.95,98.49 247.95,98.95 248.24,98.95 248.24,98.49 248.75,98.49 248.75,98.95 249.92,98.95 250.13,98.75 250.13,98.05 249.65,97.58 246.48,97.58 246.19,97.86 246.19,98.81 246.32,98.94 247.21,98.94 247.21,98.94 247.23,98.95 247.44,98.95
+1.8V_3.3V_GFX_AON on BOTTOM (solid shape): outline of 715 points within 198.34,47.68 216.05,56.25
+1.8V_3.3V_GFX_AON on IN1 (solid shape): 246.8,108.09 246.8,107.31 246.69,107.2 245.88,107.2 245.2,107.88 245.2,108.73 245.43,108.95 245.93,108.95
+1.8V_3.3V_GFX_AON on IN1 (solid shape): 249.03,98.83 249.03,98.37 249.79,97.61 249.79,97.35 249.52,97.08 246.84,97.08 246.68,97.24 246.68,98.63 247.12,99.06 248.8,99.06
+1.8V_3.3V_GFX_AON on IN2 (solid shape): outline of 2708 points within 212.62,39.99 254.15,55.32
+1.8V_3.3V_GFX_AON on IN5 (solid shape): 244.01,110.77 244.01,109.78 243.83,109.6 243.04,109.6 242.88,109.76 242.88,110.82 243.1,111.04 243.73,111.04
+1.8V_3.3V_GFX_AON on IN5 (solid shape): outline of 5950 points within 190.44,41.3 254.13,101.1
+1.8V_3.3V_GFX_AON on IN6 (solid shape): outline of 207 points within 195.71,46.22 200.58,56.42
+1.8V_3.3V_GFX_AON on IN6 (solid shape): outline of 1940 points within 213.79,41.45 254.1,61.3
+1.8V_3.3V_GFX_RUN on TOP (solid shape): 201.38,65.2 201.38,64.48 200.79,63.89 200.11,63.89 199.97,64.03 199.97,65.03 200.16,65.22 200.64,65.22 200.76,65.35 201.23,65.35
+1.8V_3.3V_GFX_RUN on TOP (solid shape): 196.6,97.35 196.6,92.53 193.42,89.35 193.42,86.88 193.43,86.87 193.43,86.53 193.33,86.43 192.36,86.43 192.28,86.52 192.28,89.8 195.39,92.91 195.39,93.99 194.63,94.75 194.63,95.45 195.39,96.21 195.39,97.35 195.52,97.48 196.47,97.48
+1.8V_3.3V_GFX_RUN on TOP (solid shape): outline of 543 points within 209.5,50.91 213.53,63.89
+1.8V_3.3V_GFX_RUN on IN1 (solid shape): outline of 2195 points within 188.66,63.15 213.97,96.15
+1.8VS on BOTTOM (solid shape): 6.62,17.3 6.62,16.57 6.81,16.38 6.81,14.1 6.69,13.98 5.61,13.98 5.45,14.14 5.45,16.43 5.34,16.54 4.78,16.54 4.67,16.65 4.67,17.09 5.59,17.09 5.59,17.04 5.61,16.99 5.63,16.94 5.65,16.89 5.69,16.85 5.73,16.81 5.77,16.78 5.82,16.76 5.87,16.74 5.92,16.73 5.97,16.73 6.03,16.74 6.08,16.76 6.13,16.78 6.17,16.81 6.21,16.85 6.24,16.89 6.27,16.94 6.29,16.99 6.3,17.04 6.3,17.09 6.3,17.14 6.29,17.2 6.27,17.25 6.24,17.29 6.21,17.33 6.17,17.37 6.13,17.4 6.08,17.42 6.03,17.44 5.97,17.45 5.92,17.45 5.87,17.44 5.82,17.42 5.77,17.4 5.73,17.37 5.69,17.33 5.65,17.29 5.63,17.25 5.61,17.2 5.59,17.14 5.59,17.09 4.67,17.09 4.67,17.61 4.77,17.7 6.21,17.7
+1.8VSP on TOP (solid shape): 249.87,105.36 249.87,101.04 249.3,100.47 247.33,100.47 247.17,100.63 247.17,102.69 247.36,102.88 248.35,102.88 248.41,102.94 248.41,105.36 248.6,105.55 249.68,105.55
+1.8VSP on BOTTOM (solid shape): 250.06,102.56 250.06,99.45 249.81,99.2 246.89,99.2 246.83,99.26 246.83,100.28 247.16,100.61 247.16,102.77 247.65,103.26 249.37,103.26
+1.35V_RUN_B+ on TOP (solid shape): 187.77,116.98 187.77,115.96 188.41,115.32 188.91,115.32 189.01,115.23 189.01,115.2 189.11,114.88 189.42,114.78 189.45,114.79 189.57,114.67 189.57,112.88 189.29,112.61 189.29,112.59 189.17,112.47 185.93,112.47 185.87,112.53 185.87,113.17 186.31,113.61 186.31,114.55 186.31,114.69 186.12,114.88 186.12,115.13 186.56,115.13 186.63,115.2 186.63,116.59 186.56,116.66 186.12,116.66 186.12,117.29 186.18,117.36 187.39,117.36
+1.35V_RUN_B+ on BOTTOM (solid shape): 187.96,119.13 187.96,116.15 188.21,115.9 188.21,115.22 188.57,114.87 188.63,114.76 188.73,114.7 189.26,114.17 189.62,114.17 189.74,114.05 190.63,114.05 190.76,113.93 190.76,111.39 190.69,111.32 189.55,111.32 189.49,111.39 189.49,111.77 188.79,112.47 185.93,112.47 185.87,112.53 185.87,113.29 186.03,113.46 186.81,113.46 186.81,113.48 186.82,113.48 186.95,113.61 186.95,116.21 186.69,116.47 186.69,119.2 186.82,119.33 187.77,119.33
+1.35V_VSNS on TOP (solid shape): 218.06,120.09 218.06,117.93 217.62,117.48 214.12,117.48 212.85,116.21 204.41,116.21 203.96,115.77 203.96,113.93 203.65,113.61 201.68,113.61 201.3,113.99 201.3,119.77 201.99,120.47 217.68,120.47
+1.35V_VSNS on BOTTOM (solid shape): 217.87,119.13 217.87,117.8 217.62,117.55 214,117.55 212.66,116.21 206.27,116.21 205.61,115.55 205.61,113.67 205.36,113.42 204.97,113.42 204.75,113.5 204.53,113.42 202.5,113.42 201.87,114.05 201.87,118.63 202.57,119.33 217.68,119.33
+1.35V_VSNS on IN1 (solid shape): 218.12,119.26 218.12,116.47 217.74,116.09 217.65,116.06 217.57,116.13 217.32,116.37 216.99,116.28 216.92,116.25 216.6,116.38 216.28,116.25 215.96,116.38 215.65,116.25 215.33,116.38 215.01,116.25 214.69,116.38 214.38,116.25 214.31,116.28 213.81,116.28 213.8,115.78 213.83,115.71 213.8,115.64 213.78,115.61 213.76,115.58 213.44,115.58 213.36,115.61 213.34,115.69 213.31,115.83 213.23,115.96 212.98,116.06 212.73,115.96 212.62,115.72 212.71,115.47 212.74,115.4 212.71,115.33 212.64,115.21 212.63,115.06 212.63,115.04 212.18,114.58 212.07,114.56 212,114.65 211.78,114.96 211.4,114.88 211.33,114.85 211.01,114.98 210.69,114.85 210.38,114.98 210.06,114.85 209.99,114.88 209.75,114.98 209.5,114.89 209.44,114.87 209.13,114.98 208.83,114.87 208.52,114.98 208.22,114.87 207.92,114.98 207.61,114.87 207.55,114.9 207.05,114.86 207.08,114.36 207.11,114.25 207.01,114.18 206.36,114.18 206.27,114.25 206.29,114.36 206.06,114.98 205.82,114.36 205.85,114.25 205.75,114.18 204.79,114.18 204.22,113.61 202.19,113.61 201.74,114.05 201.74,119.04 202.09,119.39 218,119.39
+1.35V_VSNS on IN2 (solid shape): 218.12,119.26 218.12,116.47 217.74,116.09 217.65,116.06 217.57,116.13 217.32,116.37 216.99,116.28 216.92,116.25 216.6,116.38 216.28,116.25 215.96,116.38 215.65,116.25 215.33,116.38 215.01,116.25 214.69,116.38 214.38,116.25 214.31,116.28 213.81,116.28 213.8,115.78 213.83,115.71 213.8,115.64 213.78,115.61 213.76,115.58 213.44,115.58 213.36,115.61 213.34,115.69 212.86,116.04 212.71,115.47 212.74,115.4 212.71,115.33 212.64,115.21 212.63,115.06 212.63,115.04 212.18,114.58 212.07,114.56 212,114.65 211.78,114.96 211.4,114.88 211.33,114.85 211.01,114.98 210.69,114.85 210.38,114.98 210.06,114.85 209.99,114.88 209.75,114.98 209.5,114.89 209.44,114.87 209.13,114.98 208.83,114.87 208.52,114.98 208.22,114.87 207.92,114.98 207.61,114.87 207.55,114.9 207.05,114.86 207.08,114.36 207.11,114.25 207.01,114.18 206.36,114.18 206.27,114.25 206.29,114.36 206.06,114.98 205.82,114.36 205.85,114.25 205.75,114.18 204.79,114.18 204.22,113.61 202.19,113.61 201.74,114.05 201.74,119.32 201.99,119.58 217.81,119.58
+1.35V_VSNS on IN3 (solid shape): outline of 360 points within 200.96,113.42 217.97,119.39
+1.35V_VSNS on IN4 (solid shape): outline of 377 points within 201.1,113.28 218.07,120.2
+1.35V_VSNS on IN6 (solid shape): 217.94,119.35 217.94,117.65 217.5,117.21 214.11,117.21 212.96,116.06 212.87,116.04 212.79,116.01 206.88,116.01 204.31,113.44 202.41,113.44 201.82,114.04 201.82,118.7 202.78,119.66 217.62,119.66
+1.35VSDGPU on TOP (solid shape): 211.84,113.31 211.84,112.07 211.8,112.03 204.28,112.03 204.1,112.21 204.1,113.2 204.3,113.39 211.75,113.39
+1.35VSDGPU on TOP (solid shape): 214.76,116.78 215.46,116.78 215.46,117.29 215.96,117.29 215.96,116.78 216.66,116.78 216.66,117.29 217.68,117.29 217.87,117.1 217.87,112.85 217.3,112.28 214.06,112.28 213.68,112.66 213.68,116.79 214.19,117.29 214.76,117.29
+1.35VSDGPU on TOP (solid shape): 245.48,63.13 245.49,63.11 245.53,63.07 245.57,63.04 245.61,63.01 245.66,63 245.71,62.99 245.76,62.99 246.19,62.56 246.19,62.18 245.94,61.92 243.9,61.92 243.73,62.1 243.73,62.53 244.59,62.53 244.59,62.48 244.6,62.43 244.61,62.38 244.64,62.33 244.67,62.29 244.7,62.25 244.75,62.22 244.79,62.2 244.84,62.18 244.89,62.17 244.94,62.17 245,62.18 245.05,62.2 245.09,62.22 245.13,62.25 245.17,62.29 245.2,62.33 245.22,62.38 245.24,62.43 245.25,62.48 245.25,62.53 245.24,62.58 245.22,62.63 245.2,62.68 245.17,62.72 245.13,62.76 245.09,62.79 245.05,62.81 245,62.83 244.94,62.84 244.89,62.84 244.84,62.83 244.79,62.81 244.75,62.79 244.7,62.76 244.67,62.72 244.64,62.68 244.61,62.63 244.6,62.58 244.59,62.53 243.73,62.53 243.73,62.72 243.83,62.82 244.55,62.82 244.72,63 244.78,62.97 244.83,62.96 244.88,62.95 244.93,62.95 244.98,62.96 245.03,62.98 245.07,63 245.11,63.03 245.15,63.07 245.18,63.11 245.19,63.13
+1.35VSDGPU on TOP (solid shape): outline of 85 points within 248.48,78.3 251.14,81.99
