# Allegro board Dell XPS 9560 LA-E331P R10.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
SKY-S-PCH_BGA_837P-T
  round 0.305 smd: A2(-0.354,0) A3(-0.854,0) A4(-1.355,0) A42(-20.273,0) A43(-20.773,0) A44(-21.274,0) AA17(-7.715,10.039) AA18(-8.49,10.039) AA20(-9.264,10.039) AA21(-10.039,10.039) AA23(-10.814,10.039) AA25(-11.588,10.039) AA26(-12.363,10.039) AA28(-13.138,10.039) AA29(-13.913,10.039) AB7(-2.638,10.147) AB8(-3.4,10.147) AB10(-4.162,10.147) AB11(-4.924,10.147) AB13(-5.686,10.147) AB14(-6.448,10.147) AB15(-7.007,10.147) AB31(-14.62,10.147) AB32(-15.179,10.147) AB33(-15.941,10.147) AB35(-16.703,10.147) AB36(-17.465,10.147) AB38(-18.227,10.147) AB39(-18.989,10.147) AC17(-7.715,10.814) AC18(-8.49,10.814) AC20(-9.264,10.814) AC21(-10.039,10.814) AC23(-10.814,10.814) AC25(-11.588,10.814) AC26(-12.363,10.814) AC28(-13.138,10.814) AC29(-13.913,10.814) AD7(-2.638,11.481) AD8(-3.4,11.481) AD10(-4.162,11.481) AD11(-4.924,11.481) AD13(-5.686,11.481) AD14(-6.448,11.481) AD15(-7.007,11.481) AD31(-14.62,11.481) AD32(-15.179,11.481) AD33(-15.941,11.481) AD35(-16.703,11.481) AD36(-17.465,11.481) AD38(-18.227,11.481) AD39(-18.989,11.481) AE17(-7.715,11.588) AE18(-8.49,11.588) AE20(-9.264,11.588) AE21(-10.039,11.588) AE23(-10.814,11.588) AE25(-11.588,11.588) AE26(-12.363,11.588) AE28(-13.138,11.588) AE29(-13.913,11.588) AF17(-7.715,12.363) AF18(-8.49,12.363) AF20(-9.264,12.363) AF21(-10.039,12.363) AF23(-10.814,12.363) AF25(-11.588,12.363) AF26(-12.363,12.363) AF28(-13.138,12.363) AF29(-13.913,12.363) AG7(-2.638,12.586) AG8(-3.4,12.586) AG10(-4.162,12.586) AG11(-4.924,12.586) AG13(-5.686,12.586) AG14(-6.448,12.586) AG15(-7.007,12.586) AG31(-14.62,12.586) AG32(-15.179,12.586) AG33(-15.941,12.586) AG35(-16.703,12.586) AG36(-17.465,12.586) AG38(-18.227,12.586) AG39(-18.989,12.586) AH17(-7.715,13.138) AH18(-8.49,13.138) AH20(-9.264,13.138) AH21(-10.039,13.138) AH23(-10.814,13.138) AH25(-11.588,13.138) AH26(-12.363,13.138) AH28(-13.138,13.138) AH29(-13.913,13.138) AJ7(-2.74,13.767) AJ8(-3.502,13.767) AJ10(-4.264,13.767) AJ11(-5.026,13.767) AJ13(-5.788,13.767) AJ14(-6.499,13.767) AJ15(-7.007,13.767) AJ17(-7.715,13.913) AJ18(-8.49,13.913) AJ20(-9.264,13.913) AJ21(-10.039,13.913) AJ23(-10.814,13.913) AJ25(-11.588,13.913) AJ26(-12.363,13.913) AJ28(-13.138,13.913) AJ29(-13.913,13.913) AJ31(-14.62,13.767) AJ32(-15.179,13.767) AJ33(-15.941,13.767) AJ35(-16.703,13.767) AJ36(-17.465,13.767) AJ38(-18.227,13.767) AJ39(-18.989,13.767) AL7(-2.74,14.885) AL8(-3.502,14.885) AL10(-4.264,14.885) AL11(-5.026,14.885) AL13(-5.788,14.885) AL17(-7.861,14.62) AL19(-9.042,14.62) AL22(-10.147,14.62) AL24(-11.481,14.62) AL27(-12.586,14.62) AL29(-13.767,14.62) AL32(-15.154,14.91) AL33(-15.916,14.91) AL35(-16.678,14.91) AL36(-17.44,14.91) AL38(-18.202,14.91) AL39(-18.964,14.91) AM15(-6.718,15.154) AM17(-7.861,15.179) AM19(-9.042,15.179) AM22(-10.147,15.179) AM24(-11.481,15.179) AM27(-12.586,15.179) AM29(-13.767,15.128) AN7(-2.791,15.85) AN8(-3.553,15.799) AN10(-4.315,15.799) AN11(-5.061,15.84) AN15(-6.718,15.916) AN17(-7.861,15.941) AN19(-9.042,15.941) AN22(-10.147,15.941) AN24(-11.481,15.941) AN27(-12.586,15.941) AN29(-13.767,15.84) AN31(-14.885,15.84) AN36(-17.284,15.901) AN38(-18.046,15.901) AN39(-18.808,15.901) AP11(-4.774,16.365) AR7(-2.815,16.851) AR9(-3.73,16.891) AR15(-6.718,16.678) AR17(-7.861,16.703) AR19(-9.042,16.703) AR22(-10.147,16.703) AR24(-11.481,16.703) AR27(-12.586,16.703) AR29(-13.767,16.602) AR31(-14.885,16.602) AR33(-15.84,16.566) AR34(-16.365,16.854) AR38(-18.21,16.882) AR39(-18.972,16.882) AT9(-3.876,17.527) AT10(-4.503,17.477) AT13(-5.727,17.284) AT15(-6.718,17.44) AT17(-7.861,17.465) AT19(-9.042,17.465) AT22(-10.147,17.465) AT24(-11.481,17.465) AT27(-12.586,17.465) AT29(-13.767,17.364) AT31(-14.885,17.364) AT33(-15.799,17.313) AT36(-17.477,17.125) AU7(-2.878,17.808) AU35(-16.891,17.897) AU36(-17.527,17.751) AU39(-18.804,17.955) AV6(-2.577,18.459) AV11(-4.745,18.21) AV13(-5.727,18.046) AV15(-6.718,18.202) AV17(-7.861,18.227) AV19(-9.042,18.227) AV22(-10.147,18.227) AV24(-11.481,18.227) AV27(-12.586,18.227) AV29(-13.767,18.126) AV31(-14.885,18.126) AV33(-15.799,18.075) AW9(-3.673,18.804) AW11(-4.745,18.972) AW13(-5.727,18.808) AW15(-6.718,18.964) AW17(-7.861,18.989) AW19(-9.042,18.989) AW22(-10.147,18.989) AW24(-11.481,18.989) AW27(-12.586,18.989) AW29(-13.767,18.888) AW31(-14.885,18.888) AW33(-15.85,18.837) AW35(-16.851,18.813) AW37(-17.808,18.75) AY5(-2.05,19.399) AY38(-18.459,19.051) B1(0,0.354) B2(-0.484,0.484) B3(-0.99,0.488) B43(-20.614,0.51) B44(-21.144,0.484) B45(-21.628,0.354) BA40(-19.399,19.577) BB1(0,20.273) BB45(-21.628,20.273) BC1(0,20.773) BC2(-0.488,20.637) BC44(-21.118,20.614) BC45(-21.628,20.773) BD1(0,21.274) BD2(-0.484,21.144) BD3(-1.013,21.118) BD43(-20.637,21.139) BD44(-21.144,21.144) BD45(-21.628,21.274) BE2(-0.354,21.628) BE3(-0.854,21.628) BE4(-1.355,21.628) BE42(-20.273,21.628) BE43(-20.773,21.628) BE44(-21.274,21.628) C1(0,0.854) C2(-0.51,1.013) C42(-20.102,0.954) C44(-21.139,0.99) C45(-21.628,0.854) D1(0,1.355) D45(-21.628,1.355) F8(-3.169,2.577) G9(-3.819,2.878) G11(-4.777,2.815) G13(-5.778,2.791) G15(-6.743,2.74) G17(-7.861,2.74) G19(-9.042,2.638) G22(-10.147,2.638) G24(-11.481,2.638) G27(-12.586,2.638) G29(-13.767,2.638) G31(-14.91,2.664) G33(-15.901,2.82) G35(-16.882,2.656) G37(-17.955,2.823) H13(-5.829,3.553) H15(-6.743,3.502) H17(-7.861,3.502) H19(-9.042,3.4) H22(-10.147,3.4) H24(-11.481,3.4) H27(-12.586,3.4) H29(-13.767,3.4) H31(-14.91,3.426) H33(-15.901,3.582) H35(-16.882,3.418) J7(-2.823,3.673) J10(-4.101,3.876) J11(-4.737,3.73) J39(-18.75,3.819) K10(-4.151,4.503) K13(-5.829,4.315) K15(-6.743,4.264) K17(-7.861,4.264) K19(-9.042,4.162) K22(-10.147,4.162) K24(-11.481,4.162) K27(-12.586,4.162) K29(-13.767,4.162) K31(-14.91,4.188) K33(-15.901,4.344) K36(-17.125,4.151) K37(-17.751,4.101) L7(-2.656,4.745) L8(-3.418,4.745) L12(-5.263,4.774) L13(-5.788,5.061) L15(-6.743,5.026) L17(-7.861,5.026) L19(-9.042,4.924) L22(-10.147,4.924) L24(-11.481,4.924) L27(-12.586,4.924) L29(-13.767,4.924) L31(-14.91,4.95) L37(-17.897,4.737) L39(-18.813,4.777) M35(-16.854,5.263) N7(-2.82,5.727) N8(-3.582,5.727) N10(-4.344,5.727) N15(-6.743,5.788) N17(-7.861,5.788) N19(-9.042,5.686) N22(-10.147,5.686) N24(-11.481,5.686) N27(-12.586,5.686) N29(-13.767,5.686) N31(-14.91,5.712) N35(-16.566,5.788) N36(-17.313,5.829) N38(-18.075,5.829) N39(-18.837,5.778) P17(-7.861,6.499) P19(-9.042,6.448) P22(-10.147,6.448) P24(-11.481,6.448) P27(-12.586,6.448) P29(-13.767,6.448) P31(-14.91,6.474) R7(-2.664,6.718) R8(-3.426,6.718) R10(-4.188,6.718) R11(-4.95,6.718) R13(-5.712,6.718) R14(-6.474,6.718) R17(-7.861,7.007) R19(-9.042,7.007) R22(-10.147,7.007) R24(-11.481,7.007) R27(-12.586,7.007) R29(-13.767,7.007) R33(-15.84,6.743) R35(-16.602,6.743) R36(-17.364,6.743) R38(-18.126,6.743) R39(-18.888,6.743) U7(-2.638,7.861) U8(-3.4,7.861) U10(-4.162,7.861) U11(-4.924,7.861) U13(-5.686,7.861) U14(-6.448,7.861) U15(-7.007,7.861) U17(-7.715,7.715) U18(-8.49,7.715) U20(-9.264,7.715) U21(-10.039,7.715) U23(-10.814,7.715) U25(-11.588,7.715) U26(-12.363,7.715) U28(-13.138,7.715) U29(-13.913,7.715) U31(-14.62,7.861) U32(-15.128,7.861) U33(-15.84,7.861) U35(-16.602,7.861) U36(-17.364,7.861) U38(-18.126,7.861) U39(-18.888,7.861) V17(-7.715,8.49) V18(-8.49,8.49) V20(-9.264,8.49) V21(-10.039,8.49) V23(-10.814,8.49) V25(-11.588,8.49) V26(-12.363,8.49) V28(-13.138,8.49) V29(-13.913,8.49) W7(-2.638,9.042) W8(-3.4,9.042) W10(-4.162,9.042) W11(-4.924,9.042) W13(-5.686,9.042) W14(-6.448,9.042) W15(-7.007,9.042) W31(-14.62,9.042) W32(-15.179,9.042) W33(-15.941,9.042) W35(-16.703,9.042) W36(-17.465,9.042) W38(-18.227,9.042) W39(-18.989,9.042) Y17(-7.715,9.264) Y18(-8.49,9.264) Y20(-9.264,9.264) Y21(-10.039,9.264) Y23(-10.814,9.264) Y25(-11.588,9.264) Y26(-12.363,9.264) Y28(-13.138,9.264) Y29(-13.913,9.264)
  round 0.279 smd: A5(-1.855,0) A41(-19.772,0) BA1(0,19.772) BA45(-21.628,19.772) BE5(-1.855,21.628) BE41(-19.772,21.628) E1(0,1.855) E45(-21.628,1.855)
  round 0.254 smd: A6(-2.356,0) A40(-19.272,0) AB4(-1.411,10.331) AB5(-1.876,10.147) AB41(-19.751,10.147) AD4(-1.393,11.323) AD5(-1.876,11.481) AD41(-19.751,11.481) AF5(-1.929,12.535) AF41(-19.7,12.535) AG4(-1.411,12.605) AJ5(-1.978,13.767) AJ41(-19.751,13.767) AL4(-1.411,14.878) AL5(-1.978,14.885) AL41(-19.7,14.91) AN4(-1.393,15.87) AN5(-2.029,15.977) AN41(-19.57,15.901) AR5(-1.927,16.995) AR41(-19.734,16.882) AU41(-19.851,17.904) AV4(-1.585,18.134) AW4(-1.379,19.018) AW42(-20.054,18.629) AY1(0,19.272) AY45(-21.628,19.272) B6(-2.364,0.518) B25(-12.039,0.508) B40(-19.515,0.459) BA4(-1.212,19.933) BA5(-2.047,19.909) BA9(-3.723,19.851) BA11(-4.745,19.734) BA13(-5.727,19.57) BA15(-6.718,19.7) BA17(-7.861,19.751) BA20(-9.092,19.7) BA22(-10.147,19.751) BA24(-11.481,19.751) BA26(-12.535,19.699) BA29(-13.767,19.65) BA31(-14.885,19.65) BA33(-15.977,19.599) BA35(-16.995,19.7) BA41(-19.909,19.581) BB3(-0.652,20.158) BB7(-2.998,20.054) BB38(-18.134,20.043) BB39(-19.018,20.248) BB41(-19.933,20.416) BB43(-20.674,20.102) BC4(-1.526,20.674) BC42(-20.158,20.976) BE6(-2.356,21.628) BE40(-19.272,21.628) C10(-4.089,1.087) C28(-13.183,1.087) C37(-17.729,1.087) D3(-0.954,1.526) D5(-1.694,1.212) D7(-2.61,1.379) D8(-3.493,1.585) D10(-4.476,1.411) D15(-6.75,1.411) D17(-8.031,1.393) D19(-9.023,1.411) D24(-11.296,1.411) D27(-12.578,1.393) D29(-13.569,1.411) D31(-14.851,1.393) D33(-15.843,1.411) D36(-17.124,1.393) D39(-18.629,1.574) D43(-20.976,1.47) E5(-1.719,2.047) E6(-2.229,2.05) E11(-4.632,1.927) E13(-5.651,2.029) E15(-6.743,1.978) E17(-7.861,1.978) E20(-9.092,1.929) E22(-10.147,1.876) E24(-11.481,1.876) E26(-12.535,1.927) E29(-13.767,1.876) E31(-14.91,1.927) E33(-15.901,2.058) E35(-16.882,1.894) E37(-17.904,1.776) E41(-19.581,1.719) E42(-20.416,1.694) F1(0,2.356) F41(-19.577,2.229) F44(-21.11,2.364) F45(-21.628,2.356) G4(-1.574,2.998) G42(-20.248,2.61) H3(-0.926,3.423) H40(-19.051,3.169) H42(-20.043,3.493) J3(-1.087,3.898) J5(-1.776,3.723) K4(-1.393,4.503) K42(-20.217,4.476) K43(-20.54,4.089) L5(-1.894,4.745) L41(-19.7,4.632) N4(-1.411,5.785) N5(-2.058,5.727) N41(-19.599,5.651) R5(-1.927,6.718) R41(-19.65,6.743) U4(-1.411,8.058) U5(-1.876,7.861) U41(-19.65,7.861) V3(-1.087,8.445) W4(-1.393,9.05) Y5(-1.927,9.092) Y41(-19.699,9.092)
  oval 0.203x0.254 smd: A7(-2.92,0) A9(-3.962,0) A12(-5.219,0) A14(-6.261,0) A16(-7.492,0) A18(-8.534,0) A21(-9.766,0) A23(-10.807,0) A25(-12.039,0) A28(-13.08,0) A30(-14.312,0) A32(-15.354,0) A35(-16.586,0) A37(-17.652,0) A39(-18.707,0) AA4(-1.487,9.588) AA42(-20.138,9.766) AE4(-1.489,11.862) AE42(-20.14,12.039) AK4(-1.489,14.135) AK42(-20.14,14.312) AP4(-1.489,16.408) AR42(-20.14,16.586) B7(-2.87,0.508) B8(-3.555,0.386) B10(-4.089,0.579) B11(-4.603,0.418) B12(-5.219,0.508) B13(-5.88,0.386) B14(-6.363,0.579) B15(-6.877,0.418) B16(-7.492,0.508) B18(-8.153,0.386) B19(-8.636,0.579) B20(-9.15,0.418) B21(-9.766,0.508) B22(-10.426,0.386) B23(-10.909,0.579) B24(-11.423,0.418) B27(-12.699,0.386) B28(-13.183,0.579) B29(-13.696,0.418) B30(-14.312,0.508) B31(-14.973,0.386) B32(-15.456,0.579) B33(-15.97,0.418) B35(-16.586,0.508) B36(-17.246,0.386) B37(-17.729,0.579) B38(-18.205,0.418) B39(-18.757,0.508) BB10(-4.503,20.235) BB13(-5.785,20.217) BB15(-6.776,20.235) BB17(-8.058,20.217) BB19(-9.05,20.235) BB22(-10.331,20.217) BB24(-11.323,20.235) BB27(-12.605,20.217) BB29(-13.596,20.235) BB31(-14.878,20.217) BB33(-15.87,20.235) BB36(-17.151,20.217) BC8(-3.423,20.702) BC9(-3.898,20.54) BC10(-4.478,20.743) BC13(-5.658,20.702) BC14(-6.172,20.54) BC15(-6.751,20.743) BC17(-7.931,20.702) BC18(-8.445,20.54) BC19(-9.024,20.743) BC22(-10.204,20.702) BC23(-10.718,20.54) BC24(-11.298,20.743) BC26(-12.478,20.702) BC27(-12.992,20.54) BC29(-13.571,20.743) BC31(-14.751,20.702) BC32(-15.265,20.54) BC33(-15.844,20.743) BC35(-17.024,20.702) BC36(-17.538,20.54) BC38(-18.168,20.743) BD6(-2.113,21.168) BD7(-2.87,21.12) BD8(-3.423,21.21) BD9(-3.898,21.048) BD10(-4.381,21.242) BD11(-5.042,21.12) BD13(-5.658,21.21) BD14(-6.172,21.048) BD15(-6.655,21.242) BD16(-7.315,21.12) BD17(-7.931,21.21) BD18(-8.445,21.048) BD19(-8.928,21.242) BD21(-9.588,21.12) BD22(-10.204,21.21) BD23(-10.718,21.048) BD24(-11.201,21.242) BD25(-11.862,21.12) BD26(-12.478,21.21) BD27(-12.992,21.048) BD28(-13.475,21.242) BD30(-14.135,21.12) BD31(-14.751,21.21) BD32(-15.265,21.048) BD33(-15.748,21.242) BD34(-16.408,21.12) BD35(-17.024,21.21) BD36(-17.538,21.048) BD38(-18.072,21.242) BD39(-18.758,21.12) BE7(-2.92,21.628) BE9(-3.975,21.628) BE11(-5.042,21.628) BE14(-6.274,21.628) BE16(-7.315,21.628) BE18(-8.547,21.628) BE21(-9.588,21.628) BE23(-10.82,21.628) BE25(-11.862,21.628) BE28(-13.094,21.628) BE30(-14.135,21.628) BE32(-15.367,21.628) BE34(-16.408,21.628) BE37(-17.666,21.628) BE39(-18.707,21.628) C8(-3.459,0.885) C11(-4.603,0.926) C13(-5.783,0.885) C14(-6.363,1.087) C15(-6.877,0.926) C17(-8.057,0.885) C19(-8.636,1.087) C20(-9.15,0.926) C22(-10.33,0.885) C23(-10.909,1.087) C24(-11.423,0.926) C27(-12.603,0.885) C29(-13.696,0.926) C31(-14.877,0.885) C32(-15.456,1.087) C33(-15.97,0.926) C36(-17.15,0.885) C38(-18.205,0.926) D13(-5.758,1.393) D22(-10.305,1.393) L4(-1.487,5.042) M42(-20.138,5.219) T4(-1.487,7.315) T42(-20.138,7.492)
  oval 0.254x0.203 smd: AA1(0,9.588) AA2(-0.508,9.588) AA44(-21.12,9.766) AA45(-21.628,9.766) AB2(-0.418,10.204) AB3(-0.926,10.204) AB42(-20.235,10.305) AB43(-20.743,10.33) AB44(-21.242,10.426) AC1(0,10.82) AC2(-0.579,10.718) AC3(-1.087,10.718) AC43(-20.54,10.909) AC44(-21.048,10.909) AC45(-21.628,10.807) AD2(-0.386,11.201) AD3(-0.885,11.298) AD42(-20.217,11.296) AD43(-20.702,11.423) AD44(-21.21,11.423) AE1(0,11.862) AE2(-0.508,11.862) AE44(-21.12,12.039) AE45(-21.628,12.039) AF2(-0.418,12.478) AF3(-0.926,12.478) AG2(-0.579,12.992) AG3(-1.087,12.992) AG42(-20.235,12.578) AG43(-20.743,12.603) AG44(-21.242,12.699) AH1(0,13.094) AH2(-0.386,13.475) AH43(-20.54,13.183) AH44(-21.048,13.183) AH45(-21.628,13.08) AJ3(-0.885,13.571) AJ4(-1.393,13.596) AJ42(-20.217,13.569) AJ43(-20.702,13.696) AJ44(-21.21,13.696) AK1(0,14.135) AK2(-0.508,14.135) AK44(-21.12,14.312) AK45(-21.628,14.312) AL2(-0.418,14.751) AL3(-0.926,14.751) AL42(-20.235,14.851) AL43(-20.743,14.877) AL44(-21.242,14.973) AM1(0,15.367) AM2(-0.579,15.265) AM3(-1.087,15.265) AM43(-20.54,15.456) AM44(-21.048,15.456) AM45(-21.628,15.354) AN2(-0.386,15.748) AN3(-0.885,15.844) AN42(-20.217,15.843) AN43(-20.702,15.97) AN44(-21.21,15.97) AP1(0,16.408) AP2(-0.508,16.408) AR2(-0.418,17.024) AR3(-0.926,17.024) AR44(-21.12,16.586) AR45(-21.628,16.586) AT2(-0.579,17.538) AT3(-1.087,17.538) AT4(-1.411,17.151) AT42(-20.235,17.124) AT43(-20.743,17.15) AT44(-21.242,17.246) AU1(0,17.666) AU43(-20.54,17.729) AU44(-21.048,17.729) AU45(-21.628,17.652) AV2(-0.386,18.072) AV3(-0.885,18.168) AV43(-20.702,18.205) AV44(-21.21,18.205) AW1(0,18.707) AW2(-0.508,18.758) AW44(-21.12,18.757) AW45(-21.628,18.707) AY44(-21.168,19.515) BB11(-5.042,20.14) BB16(-7.315,20.14) BB21(-9.588,20.14) BB25(-11.862,20.138) BB30(-14.135,20.138) BB34(-16.408,20.138) D12(-5.219,1.489) D16(-7.492,1.489) D21(-9.766,1.489) D25(-12.039,1.487) D30(-14.312,1.487) D35(-16.586,1.487) F2(-0.459,2.113) G1(0,2.92) G2(-0.508,2.87) G44(-21.12,2.87) G45(-21.628,2.92) H2(-0.418,3.423) H43(-20.743,3.459) H44(-21.242,3.555) J1(0,3.975) J2(-0.579,3.898) J45(-21.628,3.962) K2(-0.386,4.381) K3(-0.885,4.478) K44(-21.048,4.089) L1(0,5.042) L2(-0.508,5.042) L43(-20.702,4.603) L44(-21.21,4.603) M44(-21.12,5.219) M45(-21.628,5.219) N2(-0.418,5.658) N3(-0.926,5.658) N42(-20.235,5.758) N43(-20.743,5.783) N44(-21.242,5.88) P1(0,6.274) P2(-0.579,6.172) P3(-1.087,6.172) P43(-20.54,6.363) P44(-21.048,6.363) P45(-21.628,6.261) R2(-0.386,6.655) R3(-0.885,6.751) R4(-1.393,6.776) R42(-20.217,6.75) R43(-20.702,6.877) R44(-21.21,6.877) T1(0,7.315) T2(-0.508,7.315) T44(-21.12,7.492) T45(-21.628,7.492) U2(-0.418,7.931) U3(-0.926,7.931) U42(-20.235,8.031) U43(-20.743,8.057) V1(0,8.547) V2(-0.579,8.445) V44(-21.242,8.153) V45(-21.628,8.534) W2(-0.386,8.928) W3(-0.885,9.024) W42(-20.217,9.023) W43(-20.54,8.636) W44(-21.048,8.636) Y43(-20.702,9.15) Y44(-21.21,9.15)
  round 0.368 smd: AY2(-0.518,19.263) BD40(-19.263,21.11) C4(-1.47,0.652)
SSM3K7002FU_SC70-3
  oval 0.508x0.991 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
SW_NTC311-EA1T-A160T_4P
  rect 1.651x1.041 smd: 1(0,0) 2(3.85,0)
  rect 1.651x1.041 hole 0.66: 3(-0.1,-1.525) 4(3.95,-1.525)
SW_SKRBAAE010_4P
  rect 0.889x1.219 smd: 1(0,0) 2(3.9,0) 3(0,4.075) 4(3.9,4.075)
SW_SSAL120100_3P
  rect 0.787x0.787 smd: 1(0,0) 3(3.4,0)
  rect 1.194x0.787 smd: 2(1.7,0)
  rect 1.041x0.889 smd: 4(-2.375,-1.6) 5(5.775,-1.6)
SX34H_SMA2
  rect 2.057x2.057 smd: 1(0,0) 2(3.73,0)
SY6288C20AAC_SOT23-5
  oval 0.559x0.787 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.4) 5(0,2.4)
SYX196DQNC_QFN10_3X3
  oval 0.254x0.61 smd: 1(0,0) 2(0.45,0) 3(0.9,0) 4(1.35,0) 5(1.8,0) 6(2.25,0)
  rect 1.118x0.229 smd: 7(2.215,-0.662)
  rect 0.864x2.007 smd: 8(2.09,-2)
  custom 0.47x0.47 smd: 9(1.077,-1.775)
  rect 0.787x1.143 smd: 10(0.113,-1.6)
T-SOL_156-1051902601_19P-T
  round 0.889 hole 0.889 unplated: (-20.3,-1.65) (0.5,-18.8)
  oval 0.787x1.6 smd: 1(0,0) 2(-1.4,0) 3(-2.8,0) 4(-4.2,0) 5(-5.6,0) 6(-9.75,0) 7(-11.15,0) 8(-12.55,0) 9(-13.95,0) 10(-15.35,0) 11(-16.75,0)
  oval 0.787x1.702 smd: 12(-1.25,-20.92) 13(-2.775,-20.92) 14(-4.275,-20.92) 15(-5.8,-20.92) 16(-8.75,-20.92) 17(-10.275,-20.92) 18(-11.775,-20.92) 19(-13.3,-20.92)
  oval 1.092x2.388 hole 0.559x1.194: 20(4.575,-4.45) 21(4.575,-18.6) 22(-20.875,-4.45) 23(-20.875,-18.6)
TAI-T_HCB2012KF-121T50_2P
  rect 0.991x0.991 smd: 1(0,0) 2(2,0)
TAI-T_VMPI1004AR-3R3M-Z01_2P
  rect 4.089x3.505 smd: 1(0,0) 2(9.5,0)
TAIWI_USB019-107CRL-TWD_10P-T
  round 1.219 hole 0.914: 1(0,0)
  round 1.321 hole 0.914: 2(2.5,0) 3(4.5,0) 4(7,0) 5(7.5,1.5) 6(5.5,1.5) 7(3.5,1.5) 8(1.5,1.5) 9(-0.5,1.5)
  round 1.067 hole 0.762: 10(-1.37,0)
  oval 1.372x2.667 hole 0.61x1.905: 11(-2.9,-0.39) 12(-4.4,-10.98) 13(11.4,-10.98) 14(9.9,-0.39)
TC7SH08FU_SSOP5
  oval 0.406x0.787 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
TOKO_1239AS-H-1R0M-P2_2P
  rect 0.787x2.007 smd: 1(0,0) 2(2,0)
TPC12
  round 0.305 smd: 1(0,0)
TPS2546RTER_QFN16_3X3
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 9(1.5,3.1) 10(1,3.1) 11(0.5,3.1) 12(0,3.1)
  oval 0.889x0.254 smd: 5(2.3,0.8) 6(2.3,1.3) 7(2.3,1.8) 8(2.3,2.3) 13(-0.8,2.3) 14(-0.8,1.8) 15(-0.8,1.3) 16(-0.8,0.8)
  rect 1.651x1.651 smd: 17(0.75,1.55)
TPS22961DNYR_WSON8
  oval 0.305x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,2.7)
  oval 1.6x0.508 smd: 6(0.65,2.7)
  rect 2.388x1.6 smd: 7(0.975,1.35)
TPS51285BRUKR_QFN20_3X3
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 11(3.1,-1.6) 12(3.1,-1.2) 13(3.1,-0.8) 14(3.1,-0.4) 15(3.1,0)
  oval 0.203x0.889 smd: 6(0.75,-2.35) 7(1.15,-2.35) 8(1.55,-2.35) 9(1.95,-2.35) 10(2.35,-2.35) 16(2.35,0.75) 17(1.95,0.75) 18(1.55,0.75) 19(1.15,0.75) 20(0.75,0.75)
  rect 1.702x1.702 smd: 21(1.55,-0.8)
TPS53353DQPR_QFN22_5X6
  oval 0.254x0.991 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5,5) 13(4.5,5) 14(4,5) 15(3.5,5) 16(3,5) 17(2.5,5) 18(2,5) 19(1.5,5) 20(1,5) 21(0.5,5) 22(0,5)
  custom 0.81x0.81 smd: 23(2.5,2.5)
TPS65982_BGA_96P
  round 0.254 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2.001,0) A6(2.501,0) A7(3.001,0) A8(3.501,0) A9(4.001,0) A10(4.501,0) A11(5.001,0) B1(0,-0.5) B2(0.5,-0.5) B3(1,-0.5) B4(1.5,-0.5) B5(2.001,-0.5) B6(2.501,-0.5) B7(3.001,-0.5) B8(3.501,-0.5) B9(4.001,-0.5) B10(4.501,-0.5) B11(5.001,-0.5) C1(0,-1) C2(0.5,-1) C10(4.501,-1) C11(5.001,-1) D1(0,-1.5) D2(0.5,-1.5) D5(2.001,-1.5) D6(2.501,-1.5) D7(3.001,-1.5) D8(3.501,-1.5) D10(4.501,-1.5) D11(5.001,-1.5) E1(0,-2.001) E2(0.5,-2.001) E4(1.5,-2.001) E5(2.001,-2.001) E6(2.501,-2.001) E7(3.001,-2.001) E8(3.501,-2.001) E10(4.501,-2.001) E11(5.001,-2.001) F1(0,-2.501) F2(0.5,-2.501) F4(1.5,-2.501) F5(2.001,-2.501) F6(2.501,-2.501) F7(3.001,-2.501) F8(3.501,-2.501) F10(4.501,-2.501) F11(5.001,-2.501) G1(0,-3.001) G2(0.5,-3.001) G4(1.5,-3.001) G5(2.001,-3.001) G6(2.501,-3.001) G7(3.001,-3.001) G8(3.501,-3.001) G10(4.501,-3.001) G11(5.001,-3.001) H1(0,-3.501) H2(0.5,-3.501) H4(1.5,-3.501) H5(2.001,-3.501) H6(2.501,-3.501) H7(3.001,-3.501) H8(3.501,-3.501) H10(4.501,-3.501) H11(5.001,-3.501) J1(0,-4.001) J2(0.5,-4.001) J10(4.501,-4.001) J11(5.001,-4.001) K1(0,-4.501) K2(0.5,-4.501) K3(1,-4.501) K4(1.5,-4.501) K5(2.001,-4.501) K6(2.501,-4.501) K7(3.001,-4.501) K8(3.501,-4.501) K9(4.001,-4.501) K10(4.501,-4.501) K11(5.001,-4.501) L1(0,-5.001) L2(0.5,-5.001) L3(1,-5.001) L4(1.5,-5.001) L5(2.001,-5.001) L6(2.501,-5.001) L7(3.001,-5.001) L8(3.501,-5.001) L9(4.001,-5.001) L10(4.501,-5.001) L11(5.001,-5.001)
TVNST52302AB0_SOT523-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.5,-1.4) 3(0.5,-1.4)
W25Q32FVSSIQ_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
W25Q80DVSSIG_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
W25Q256FVEIG_WSON8
  oval 0.66x0.991 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,8) 6(2.54,8) 7(1.27,8) 8(0,8)
  rect 4.293x3.404 smd: 9(1.905,4)
Y_7V25000014_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
Y_7V27000011_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
Y_CM7V-12520_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_CM31532768DZFT_2P
  rect 1.092x1.905 smd: 1(0,0) 2(2.5,0)
Y_X3G024000DC1H_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
YUQIU_PJ567-F07J1BE-C_6P
  oval 0.991x1.6 hole 0.61x1.194: 1(0,0) 2(0,5) 3(0,7.6) 4(-9,7.6) 6(-9,5.2) 7(-9,2.6)
  oval 0.991x1.499 hole 0.61x1.092: 5(-9,-0.55)

## Nets
1.2V_B+: PC601.1 PC602.1 PC603.1 PC604.1 PJP600.2 PL601.2 PQ600.5 PR605.1
1.2V_FB: PC612.1 PR604.1 PR607.1 PU600.6
1V8_3.3V_GFX_RUN: RZ92.1 UZ24.7 UZ24.8
1V8_3V3_MAIN_EN: DA56.2 DV16.2 PR1004.2 QV104.5 RV562.1 RV1099.2 RV1119.2 RV1130.2 RZ106.1
1V8_3V3_MAIN_RUN_EN: DV16.1 QZ17.2 RZ106.2 UZ24.3
1V8_EN_LS3V3: DA55.1 QV104.6 RV108.2 RV1129.2
1VS_GFX_PG: DV13.2 PR908.1 UV20.1
1VSP_PG: PR906.2 PR908.2 PU900.2
3.3V_CAM_EN#: QZ9.2 RZ38.1 UH2.BD14
3.3V_MSATA_EN: RH423.1 UH2.BD27
3.3V_TS_EN: RZ39.1 UH2.AR29 UZ5.3
3V/5VALW_EN: PC335.1 PR326.2 PR408.1 PR409.2
5VS_FAN1: JFAN1.2 RE104.2
5VS_FAN2: JFAN2.2 RE105.2
+0.6VS: CD12.1 CD13.1 CD14.1 CD15.1 CD32.1 CD88.1 CD89.1 CD90.1 JDIMM1.258 JDIMM2.258 PJP602.2
+0.6VSP: PC605.1 PC606.1 PJP602.1 PU600.2 PU600.20
+0.95VSP: PC807.1 PC808.1 PC809.1 PC810.1 PC811.1 PJP800.1 PL801.2 PR813.1
+1.0V_+1.8V_PLLVDD: CV855.1 CV856.1 LV23.1 LV26.1 RV574.2 RV575.2 RV576.2 RV582.2
+1.2V_DDR: CD1.1 CD2.1 CD5.1 CD6.1 CD7.1 CD8.1 CD11.1 CD19.1 CD20.1 CD21.1 CD22.1 CD23.1 CD24.1 CD25.1 CD26.1 CD33.1 CD70.1 CD71.1 CD72.1 CD73.1 CD74.1 CD75.1 CD76.1 CD77.1 CD78.1 CD79.1 CD80.1 CD81.1 CD82.1 CD83.1 CD84.1 CD85.1 CD86.1 CD87.1 CH118.1 CH119.1 CH120.1 CH121.1 CH122.1 CH123.1 CH124.1 CH125.1 CH126.1 CH127.1 CH128.1 CH129.1 CH130.1 CH131.1 CH132.1 CH197.1 JDIMM1.12 JDIMM1.33 JDIMM1.54 JDIMM1.75 JDIMM1.96 JDIMM1.111 JDIMM1.112 JDIMM1.117 JDIMM1.118 JDIMM1.123 JDIMM1.124 JDIMM1.129 JDIMM1.130 JDIMM1.135 JDIMM1.136 JDIMM1.141 JDIMM1.142 JDIMM1.147 JDIMM1.148 JDIMM1.153 JDIMM1.154 JDIMM1.159 JDIMM1.160 JDIMM1.163 JDIMM1.178 JDIMM1.199 JDIMM1.220 JDIMM1.241 JDIMM2.12 JDIMM2.33 JDIMM2.54 JDIMM2.75 JDIMM2.96 JDIMM2.111 JDIMM2.112 JDIMM2.117 JDIMM2.118 JDIMM2.123 JDIMM2.124 JDIMM2.129 JDIMM2.130 JDIMM2.135 JDIMM2.136 JDIMM2.141 JDIMM2.142 JDIMM2.147 JDIMM2.148 JDIMM2.153 JDIMM2.154 JDIMM2.159 JDIMM2.160 JDIMM2.163 JDIMM2.178 JDIMM2.199 JDIMM2.220 JDIMM2.241 PJP603.2 RD35.1 RH206.1 RH207.1 RH473.1 RH530.2 UC1.5 UH1.AA6 UH1.AE12 UH1.AF5 UH1.AF6 UH1.AG5 UH1.AG9 UH1.AJ12 UH1.AL11 UH1.AP6 UH1.AP7 UH1.AR6 UH1.AR12 UH1.AT12 UH1.AW6 UH1.AY6 UH1.J5 UH1.J6 UH1.K6 UH1.K12 UH1.L6 UH1.L12 UH1.R6 UH1.T6 UH1.W6 UZ16.1 UZ16.2
+1.2V_MEN_P: PC608.1 PC612.2 PJP601.1 PJP603.1 PL600.1 PR604.2 PU600.5
+1.2V_PWROK: PR609.2 PU600.10
+1.2V_VCCPLL_OC: CZ49.1 RH530.1 RZ67.2 UH1.BH13 UH1.G11
+1.8V_3.3V_GFX_AON: CV363.1 CV794.1 CV796.1 CV798.1 CV853.1 CV892.1 CV893.1 CV894.1 CV895.1 CV917.1 PJ1400.2 PR725.1 PR988.1 PR1000.1 PR1500.1 RV11.1 RV325.1 RV326.1 RV511.2 RV551.2 RV552.2 RV553.2 RV554.2 RV557.2 RV562.2 RV563.2 RV564.2 RV570.2 RV571.2 RV572.2 RV573.2 RV588.1 RV591.1 RV594.2 RV645.2 RV646.2 RV647.2 RV648.2 RV649.2 RV650.2 RV659.1 RV1056.2 RV1074.2 RV1080.1 RV1110.2 RV1111.2 RV1112.1 UV18.J8 UV18.K8 UV19.5 UV20.5 UV21.5 UV28.5
+1.8V_3.3V_GFX_RUN: CV904.1 CV905.1 CV906.1 CV907.1 CZ99.1 LV23.2 RV597.2 RV1068.2 RV1079.2 RV1081.1 RV1811.1 RZ92.2 UV18.L8 UV18.M8
+1.8VS: CA122.1 RA78.2 RA79.1 UA3.5
+1.8VS_AUDIO: RA2.1 RA78.1
+1.8VSP: PC1401.1 PC1402.1 PC1403.1 PC1404.1 PC1405.1 PJ1400.1 PL1400.2 PR1402.1
+1.8VSP_ON: PC1406.1 PR1403.2 PR1404.1 PU1400.7
+1.35V_RUN_B+: PC703.1 PC704.1 PC705.1 PC706.1 PC707.1 PC708.1 PJP700.2 PL700.2 PU700.12 PU700.13 PU700.14 PU700.15 PU700.16 PU700.17
+1.35V_VSNS: PC710.1 PC712.1 PC713.1 PC736.1 PC737.1 PC756.2 PC764.1 PC765.1 PC766.1 PC780.1 PC781.1 PJP701.1 PJP702.1 PL701.2 PR729.1
+1.35VSDGPU: CV862.1 CV863.1 CV864.2 CV870.1 CV871.1 CV872.1 CV873.2 CV883.2 CV884.2 CV885.1 CV886.1 CV887.1 CV888.1 CV889.1 CV890.1 CV896.2 CV897.2 CV898.1 CV899.1 CV900.1 CV901.1 CV902.1 CV903.1 CV929.1 CV930.1 CV931.1 CV932.1 CV933.1 CV934.1 CV935.1 CV936.1 CV937.1 CV938.1 CV939.1 CV940.1 CV941.1 CV942.1 CV943.1 CV944.1 CV945.1 CV946.1 CV947.1 CV948.1 CV949.1 CV950.1 CV951.1 CV952.1 CV953.1 CV954.1 CV955.1 CV956.1 CV957.1 CV958.1 CV959.1 CV960.1 CV961.1 CV962.1 CV963.1 CV964.1 CV965.1 CV966.1 CV967.1 CV968.1 CV969.1 CV970.1 CV971.1 CV972.1 CV973.1 CV974.1 CV975.1 CV976.1 CV977.1 CV978.1 CV979.1 CV980.1 CV981.1 CV982.1 CV983.1 CV984.1 CV985.1 CV986.1 CV991.1 CV992.1 CV993.1 CV994.1 CV995.1 CV996.1 CV997.1 CV998.1 CV999.1 CV1000.1 CV1001.1 CV1002.1 CV1003.1 CV1004.1 CV1005.1 CV1006.1 CV1007.1 CV1008.1 CV1009.1 CV1010.1 CV1011.1 CV1012.1 CV1013.1 CV1014.1 CV1015.1 CV1016.1 CV1017.1 CV1018.1 CV1019.1 CV1020.1 CV1021.1 CV1022.1 CV1023.1 CV1024.1 CV1025.1 CV1026.1 CV1027.1 CV1028.1 CV1029.1 CV1030.1 CV1031.1 CV1032.1 CV1033.1 CV1034.1 CV1035.1 CV1036.1 CV1037.1 CV1038.1 CV1039.1 CV1040.1 CV1041.1 CV1042.1 CV1043.1 CV1044.1 CV1045.1 CV1046.1 CV1047.1 CV1048.1 PJP701.2 PJP702.2 RV8.1 RV600.1 RV605.1 RV606.1 RV607.1 RV608.1 RV618.2 RV623.1 RV630.2 RV634.1 UV18.AA27 UV18.AA30 UV18.AB27 UV18.AB33 UV18.AC27 UV18.AD27 UV18.AE27 UV18.AF27 UV18.AG27 UV18.B13 UV18.B16 UV18.B19 UV18.E13 UV18.E16 UV18.E19 UV18.H8 UV18.H9 UV18.H10 UV18.H11 UV18.H12 UV18.H13 UV18.H14 UV18.H15 UV18.H16 UV18.H18 UV18.H19 UV18.H20 UV18.H21 UV18.H22 UV18.H23 UV18.H24 UV18.L27 UV18.M27 UV18.N27 UV18.P27 UV18.R27 UV18.T27 UV18.T30 UV18.T33 UV18.V27 UV18.W27 UV18.W30 UV18.W33 UV18.Y27 UV23.B1 UV23.B3 UV23.B12 UV23.B14 UV23.C5 UV23.C10 UV23.D1 UV23.D3 UV23.D11 UV23.D12 UV23.D14 UV23.E5 UV23.E10 UV23.F1 UV23.F3 UV23.F12 UV23.F14 UV23.G1 UV23.G2 UV23.G4 UV23.G11 UV23.G13 UV23.G14 UV23.H3 UV23.H12 UV23.K3 UV23.K12 UV23.L1 UV23.L2 UV23.L4 UV23.L11 UV23.L13 UV23.L14 UV23.M1 UV23.M3 UV23.M12 UV23.M14 UV23.N5 UV23.N10 UV23.P1 UV23.P3 UV23.P11 UV23.P12 UV23.P14 UV23.R5 UV23.R10 UV23.T1 UV23.T3 UV23.T12 UV23.T14 UV24.B1 UV24.B3 UV24.B12 UV24.B14 UV24.C5 UV24.C10 UV24.D1 UV24.D3 UV24.D11 UV24.D12 UV24.D14 UV24.E5 UV24.E10 UV24.F1 UV24.F3 UV24.F12 UV24.F14 UV24.G1 UV24.G2 UV24.G4 UV24.G11 UV24.G13 UV24.G14 UV24.H3 UV24.H12 UV24.K3 UV24.K12 UV24.L1 UV24.L2 UV24.L4 UV24.L11 UV24.L13 UV24.L14 UV24.M1 UV24.M3 UV24.M12 UV24.M14 UV24.N5 UV24.N10 UV24.P1 UV24.P3 UV24.P11 UV24.P12 UV24.P14 UV24.R5 UV24.R10 UV24.T1 UV24.T3 UV24.T12 UV24.T14 UV25.B1 UV25.B3 UV25.B12 UV25.B14 UV25.C5 UV25.C10 UV25.D1 UV25.D3 UV25.D11 UV25.D12 UV25.D14 UV25.E5 UV25.E10 UV25.F1 UV25.F3 UV25.F12 UV25.F14 UV25.G1 UV25.G2 UV25.G4 UV25.G11 UV25.G13 UV25.G14 UV25.H3 UV25.H12 UV25.K3 UV25.K12 UV25.L1 UV25.L2 UV25.L4 UV25.L11 UV25.L13 UV25.L14 UV25.M1 UV25.M3 UV25.M12 UV25.M14 UV25.N5 UV25.N10 UV25.P1 UV25.P3 UV25.P11 UV25.P12 UV25.P14 UV25.R5 UV25.R10 UV25.T1 UV25.T3 UV25.T12 UV25.T14 UV26.B1 UV26.B3 UV26.B12 UV26.B14 UV26.C5 UV26.C10 UV26.D1 UV26.D3 UV26.D11 UV26.D12 UV26.D14 UV26.E5 UV26.E10 UV26.F1 UV26.F3 UV26.F12 UV26.F14 UV26.G1 UV26.G2 UV26.G4 UV26.G11 UV26.G13 UV26.G14 UV26.H3 UV26.H12 UV26.K3 UV26.K12 UV26.L1 UV26.L2 UV26.L4 UV26.L11 UV26.L13 UV26.L14 UV26.M1 UV26.M3 UV26.M12 UV26.M14 UV26.N5 UV26.N10 UV26.P1 UV26.P3 UV26.P11 UV26.P12 UV26.P14 UV26.R5 UV26.R10 UV26.T1 UV26.T3 UV26.T12 UV26.T14
+1V_MPHY: CH183.1 CH184.1 RH582.1 RZ70.2 UH2.U21 UH2.U23 UH2.U25 UH2.U26 UH2.V26 UH2.V28
+1V_MPHY_MPHYPLL: CH180.1 CH181.1 CH182.1 RH582.2 UH2.A43 UH2.B43 UH2.C44 UH2.C45
+1V_PCH: CH3.1 JXDP.43 JXDP.44 PJP1302.2 RH71.1 RH196.1 RH492.1 RH584.1 UH2.AC17 UH2.AD15 UH2.AL22 UH2.N17 UH2.R17 UH2.R19 UH2.U20 UH2.V17
+1V_PCH_AZPLL: CH203.1 LH2.2 UH2.AN19
+1V_PCH_CLK5: CH177.1 CH178.1 CH179.1 RH584.2 UH2.K2 UH2.K3
+1V_PCH_PRIM: PJP1303.2 UH2.AA23 UH2.AA26 UH2.AA28 UH2.AC23 UH2.AC26 UH2.AC28 UH2.AE23 UH2.AE26 UH2.AJ20 UH2.AJ21 UH2.AJ23 UH2.AJ25 UH2.Y23 UH2.Y25
+1V_PCH_USBPLL: CH201.1 CH202.1 RH583.2 UH2.AJ5 UH2.AL5
+1V_VCCDSW: CH176.1 RH196.2 UH2.BA29
+1VALW: CZ88.1 CZ96.1 LH2.1 PJP500.2 PJP1302.1 PJP1303.1 RH583.1 RZ70.1 UZ9.1 UZ9.2 UZ9.7 UZ15.1 UZ15.2 UZ15.7
+1VS_GFX: CV859.1 CV860.1 CV861.1 CV865.1 CV866.1 CV867.1 CV868.2 CV869.1 LV26.2 PJP900.2 RV112.1 RV1057.2 RV1067.2 RV1078.2 UV18.AG19 UV18.AG21 UV18.AG22 UV18.AG24 UV18.AH21 UV18.AH25
+1VSP: PC507.1 PC508.1 PC509.1 PC510.1 PC511.1 PJP500.1 PL501.2 PR504.1
+2.5V_MEM: CD3.1 CD4.1 CD9.1 CD10.1 CD27.1 CD28.1 CD30.1 CD31.1 JDIMM1.257 JDIMM1.259 JDIMM2.257 JDIMM2.259 PR1805.2
+2.5V_MEMB: CD34.1 CD35.1
+2.5VSP_ON: PC1800.1 PR1801.2 PU1800.6
+3.3V_ALW_DEG: JDEG1.1 RE60.2
+3.3VDX_SSD: CD36.1 CD38.1 CD39.1 CD40.1 CD41.1 CZ46.1 JNGFF2.2 JNGFF2.4 JNGFF2.12 JNGFF2.14 JNGFF2.16 JNGFF2.18 JNGFF2.62 JNGFF2.64 JNGFF2.66 RD7.1 RD8.2 RZ36.2
+3V_LDO: PC218.1 PQ224.1 PR281.1 PU203.5
+3V_PCH: CH186.1 CH187.1 CH189.1 CH190.1 CH191.1 CH192.1 CH204.1 CZ19.1 JAPS.1 LH1.1 QE19.2 QE19.5 RE121.1 RH82.1 RH110.2 RH119.1 RH120.1 RH130.1 RH136.1 RH458.1 RH459.1 RH460.1 RH461.1 RH493.1 RH501.1 RH502.1 RH503.1 RH504.1 RH505.1 RH506.2 RH523.1 RH524.1 RH536.1 RH546.2 RH552.2 RH553.2 RH554.2 RH555.2 RH557.2 RH558.2 RH564.1 RH566.1 RH571.2 RH585.2 RH586.2 RP8.5 RP8.6 RP8.7 RP8.8 RZ18.2 RZ84.1 UH2.AD41 UH2.AJ41 UH2.AL41 UH2.AN5 UH2.BA20 UH2.BA31 UH2.BA45 UH2.BB45 UH2.BC42 UH2.BC44 UH2.BC45 UH2.BD3 UH2.BD40 UH2.BE3 UH2.BE4 UZ11.5 UZ12.5 UZ19.5 UZ20.5 UZ21.5
+3V_PCH_AZIO: CH200.1 LH1.2 UH2.BA15
+3V_PCH_DSW: CH82.1 RH2.1 RH137.2 RH453.2 RH515.2 RH533.2 RH545.2 UH2.BA24 UH2.W15
+3V_PCH_SPI: RH136.2 UH2.BE41 UH2.BE42 UH2.BE43
+3V_PS8723: CI3.1 CI4.1 RI14.2 RI15.2 RI16.2 RI17.2 RI18.2 RI19.2 RI20.2 RI21.2 RI22.2 RI24.2 RI45.2 UI3.1 UI3.13
+3V_ROM: JSPI1.5 JSPI1.6 RH74.1 RH75.1 RH78.1 RH585.1 UH8.8
+3V_TBT: CT52.1 CT53.1 CT54.1 CT55.1 CT56.1 CT171.1 LT14.2 QT12.2 RT21.1 RT33.1 RT34.1 RT46.2 RT107.1 RT202.1 RT241.2 RT434.1 UT1.A2 UT1.A3 UT1.B3 UT1.H9
+3V_TBT_PWR: CT105.1 CT162.1 RT114.1 UT3.7 UT3.8
+3V_TBT_S0: CT163.1 CT164.1 CT165.1 LT14.1 UT1.R13
+3V_TBT_SPI: CT47.1 RT15.1 RT16.1 RT17.1 RT18.1 RT242.2 RT243.2 UT2.8
+3V_VC: CT161.1 PC223.1 PC225.1 PQ221.3 PQ224.3 PQ233.2 PR251.2 PR252.2 PR253.2 PR254.2 PR255.2 PR257.2 PR275.1 PR278.1 PR281.2 PU202.8 PU204.5 RT1094.1 RZ1135.1 RZ1137.1 RZ1139.1
+3VA_TBT: CT143.1 CT170.1 CT172.1 CT173.1 QT11.2 QT20.2 QT20.5 QV89.2 RT22.1 RT23.1 RT25.1 RT35.1 RT36.1 RT46.1 RT113.1 RT114.2 RT167.1 RT194.1 RT433.1 RT435.1 RT436.1 UT1.F8
+3VA_TBT_LC: CT50.1 RT6.1 RT7.1 RT8.1 RT9.1 RT242.1 UT1.R6
+3VALW: CA127.1 CE15.1 CI21.1 CI22.1 CZ12.1 CZ18.1 CZ26.1 JAPS.3 JAPS.7 PC513.1 PC812.1 PC913.1 PJ1401.1 PJP402.2 PQ221.1 PR101.1 PR112.2 PR510.1 PR811.1 PR909.1 PR1800.2 PU500.7 PU800.7 PU900.7 RA100.1 RE15.1 RE56.1 RE141.1 RH137.1 RH508.2 RH513.2 RI4.1 RI5.1 RI9.1 RI10.1 RI30.1 RI31.1 RI45.1 RT113.2 RT1095.1 RV12.1 RV103.1 RV111.1 RV1809.1 RZ1134.1 RZ1136.1 RZ1138.1 UA4.6 UA4.7 UE2.2 UE6.1 UE6.2 UI4.5 UI5.5 UN3.1 UN3.2 UT3.1 UT3.2 UZ1.6 UZ1.7 UZ4.1 UZ4.2 UZ5.1 UZ5.2 UZ7.6 UZ7.7 UZ8.5 UZ18.5 UZ22.5 UZ23.5
+3VALW_5085: CE18.1 CE19.1 CE20.1 CE21.1 CE23.1 CE24.1 CE25.1 CE26.1 CE27.1 CE28.1 PJP1205.2 RE17.1 RE18.1 RE19.2 RE20.2 RE21.2 RE22.2 RE23.2 RE25.2 RE41.1 RE59.1 RE60.1 RE63.1 RE64.1 RE65.1 RE66.1 RE67.1 RE68.1 RE94.2 RE95.2 RE99.2 RE140.2 RE142.2 RP19.7 RP19.8 RP20.5 RP20.6 RP20.7 RP20.8 UE3.A11 UE3.A22 UE3.A26 UE3.A41 UE3.A52 UE3.A58 UE3.B3 UE3.B35
+3VALW_23017: CE54.1 CE55.1 PJP1206.2 RE71.1 RE72.1 RE73.1 RE76.1 UE4.5
+3VALWP: PC401.1 PC412.1 PJP402.1 PL400.1 PR401.1 PR428.1
+3VLP: PR400.1 RE43.2 RH590.2
+3VS: C2973.1 CD16.1 CD17.1 CD47.1 CH188.1 CZ9.1 CZ43.1 DV12.5 F1.2 JDIMM1.255 JDIMM2.255 JKB.4 JLPDE1.1 JLPDE1.2 PR609.1 PR707.1 PR906.1 PR1019.2 PR1114.1 PR1400.1 QE18.2 QE18.5 QH4.2 QH4.5 QV14.2 QV86.3 QX1.2 QX1.5 QZ9.3 RD1.1 RD2.1 RD3.1 RD4.1 RD5.1 RD6.1 RD10.1 RE52.1 RE81.1 RE83.1 RE100.1 RE101.1 RE129.1 RE136.1 RE137.1 RF1.1 RF3.1 RH5.1 RH85.2 RH91.1 RH111.2 RH383.1 RH424.1 RH425.1 RH462.1 RH463.1 RH510.2 RH511.2 RH512.2 RH516.1 RH518.2 RH520.1 RH525.1 RH527.2 RH535.2 RH537.2 RH547.2 RH548.1 RH549.1 RH550.1 RH551.1 RH561.1 RH562.1 RH563.1 RH569.2 RH572.2 RH587.2 RH588.2 RI14.1 RP1.5 RP1.6 RP1.7 RP1.8 RP2.1 RP2.2 RP2.3 RP2.4 RP22.1 RP22.2 RP22.3 RP22.4 RP23.1 RP23.2 RP23.3 RP23.4 RT241.1 RV108.1 RV121.1 RV122.2 RV658.1 RV1133.2 RV1140.1 RZ15.2 RZ28.1 RZ38.2 UD2.5 UH2.AD13 UH14.5
+3VS_AUDIO: CA121.1 CA129.1 JAUDIO.25 JAUDIO.27 JAUDIO.29 LA4.1 RA17.1 RA18.2 RA77.1 RA82.1 RA84.2 UA3.1
+3VS_CAM: CV183.1 CV184.1 CZ44.1 JEDP1.22 RZ37.2
+3VS_CR: CR1.1 CR4.1 CR11.1 CR12.1 RR1.1 RR9.2 RZ28.2 UR1.11 UR1.27
+3VS_FFS: CF1.1 CF2.1 RF1.2 RF4.1 RF5.1 UF1.1 UF1.7 UF1.8 UF1.14
+3VS_TP: CE2.1 JTP.8 QE2.2 QE2.5 QE13.2 RE7.2 RE9.2 RE24.1 RE26.1 RE87.1 RE93.2
+3VS_TPM: CE12.1 CE13.1 CE14.1 RE14.1 RE77.1 RE86.1 RE121.2 RE128.1 RE134.1 UE1.14 UE1.22
+3VS_TPM_VSB: CE11.1 CE83.1 RE141.2 UE1.1
+3VS_TS: CZ29.1 JTS.1 RZ26.2
+3VS_WLAN: CN1.1 CN2.1 CN6.1 CN7.1 CN8.1 CN9.1 JNGFF1.2 JNGFF1.4 JNGFF1.64 JNGFF1.66 RN34.2
+5V_CHGUSB_1: CI17.1 CI18.1 CI19.1 JUSB2.1 UI2.12
+5V_CHGUSB_2: CI11.1 CI12.1 CI13.1 JUSB1.1 UI1.12
+5VALW: CA126.1 CI1.1 CI2.1 CZ11.1 CZ86.1 CZ97.1 JKB.1 JUART.1 LED1.2 LED2.2 LED3.2 LED4.2 LED5.2 PC607.2 PC1801.1 PC1804.1 PJP403.2 PL1444.1 PR104.2 PR603.1 PU600.12 PU1800.7 PU1800.8 PU1800.9 PU1800.10 RE3.1 RP24.5 RP24.10 RT165.1 RV181.1 RV657.1 UA4.1 UA4.2 UA4.4 UE6.4 UI1.1 UI2.1 UN3.4 UT3.4 UZ1.1 UZ1.2 UZ1.4 UZ4.4 UZ5.4 UZ7.1 UZ7.2 UZ7.4 UZ9.3 UZ15.3 UZ16.4 UZ24.4
+5VALWP: PC402.2 PC413.1 PC456.1 PJP403.1 PL401.2 PR402.2 PU400.14
+5VS: CZ8.1 JKB.2 PC1200.2 PC1227.2 PC1249.2 PC1302.2 PC1336.2 PC1364.2 PR700.1 PR1012.2 PR1101.1 PR1513.2 PU1200.14 PU1201.14 PU1202.14 PU1300.14 PU1301.14 PU1302.6 QV9.2 RE82.1 RE84.1 RE104.1 RE105.1 RF2.1 RZ13.2 UV16.1
+5VS_AUDIO: CA1.1 CA2.1 CA8.1 CA9.1 CA128.1 LA1.2 LA2.1 LA3.2 RA83.2
+5VS_HDD: CS12.1 CS13.1 CS14.1 CS15.1 CZ45.1 JHDD.13 JHDD.14 JHDD.15 RZ34.2
+AVDD1: CA5.1 CA6.1 CA7.1 LA2.2 UA1.45
+AVDD2: CA12.1 CA13.1 CA14.1 CA17.1 RA2.2 UA1.24
+DVDD: CA32.1 CA78.1 LA4.2 RA12.1 RA13.1 RA15.1 UA1.7
+DVDDIO: CA39.1 CA40.1 RA18.1 UA1.19
+VBUS_1: CT120.2 CT121.2 CT122.1 CT123.1 CT153.1 DT10.2 DT10.3 DT28.1 DT174.1 JUSBC1.A4 JUSBC1.A9 JUSBC1.B4 JUSBC1.B9 LT11.2 PD203.2 PQ214.5
+VBUS_DC_SS: PC288.1 PC289.1 PD303.2 PQ212.5 PQ213.5 PR260.1
+VCC0V9_CIO: CT101.1 CT102.1 CT103.1 UT1.R8 UT1.R9 UT1.R11 UT1.R12
+VCC0V9_DP: CT62.1 CT63.1 CT64.1 CT65.1 CT66.1 CT67.1 CT68.1 UT1.L6 UT1.L8 UT1.L11 UT1.L12 UT1.M6 UT1.M8 UT1.T11 UT1.T12 UT1.V11 UT1.V12 UT1.V13
+VCC0V9_PCIE: CT71.1 CT72.1 CT80.1 CT81.1 CT82.1 UT1.L18 UT1.L19 UT1.M13 UT1.M15 UT1.M16 UT1.M18 UT1.N18 UT1.N19
+VCC0V9_USB: CT93.1 CT94.1 UT1.R15 UT1.R16
+VCC_CORE: PC1207.1 PC1208.1 PC1220.1 PC1221.1 PC1222.1 PC1223.1 PC1224.1 PC1225.1 PC1226.1 PC1229.1 PC1230.1 PC1231.1 PC1232.1 PC1233.1 PC1239.1 PC1240.1 PC1241.1 PC1242.1 PC1243.1 PC1244.1 PC1245.1 PC1246.1 PC1247.1 PC1248.1 PC1261.1 PC1262.1 PC1263.1 PC1264.1 PC1265.1 PC1269.1 PC1271.1 PC1274.1 PC1276.1 PC1397.1 PL1200.2 PL1201.2 PL1202.2 PR1219.1 PR1221.1 PR1223.1 RH197.1 UH1.AA13 UH1.AA31 UH1.AA32 UH1.AA33 UH1.AA34 UH1.AA35 UH1.AA36 UH1.AA37 UH1.AA38 UH1.AB29 UH1.AB30 UH1.AB31 UH1.AB32 UH1.AB35 UH1.AB36 UH1.AB37 UH1.AB38 UH1.AC13 UH1.AC14 UH1.AC29 UH1.AC30 UH1.AC31 UH1.AC32 UH1.AC33 UH1.AC34 UH1.AC35 UH1.AC36 UH1.AD13 UH1.AD14 UH1.AD31 UH1.AD32 UH1.AD33 UH1.AD34 UH1.AD35 UH1.AD36 UH1.AD37 UH1.AD38 UH1.AE13 UH1.AE14 UH1.AE30 UH1.AE31 UH1.AE32 UH1.AE35 UH1.AE36 UH1.AE37 UH1.AE38 UH1.AF35 UH1.AF36 UH1.AF37 UH1.AF38 UH1.K13 UH1.K14 UH1.L13 UH1.L14 UH1.N13 UH1.N14 UH1.N30 UH1.N31 UH1.N32 UH1.N35 UH1.N36 UH1.N37 UH1.N38 UH1.P13 UH1.P14 UH1.P29 UH1.P30 UH1.P31 UH1.P32 UH1.P33 UH1.P34 UH1.P35 UH1.P36 UH1.R13 UH1.R31 UH1.R32 UH1.R33 UH1.R34 UH1.R35 UH1.R36 UH1.R37 UH1.R38 UH1.T29 UH1.T30 UH1.T31 UH1.T32 UH1.T35 UH1.T36 UH1.T37 UH1.T38 UH1.U29 UH1.U30 UH1.U31 UH1.U32 UH1.U33 UH1.U34 UH1.U35 UH1.U36 UH1.V13 UH1.V14 UH1.V31 UH1.V32 UH1.V33 UH1.V34 UH1.V35 UH1.V36 UH1.V37 UH1.V38 UH1.W13 UH1.W14 UH1.W29 UH1.W30 UH1.W31 UH1.W32 UH1.W35 UH1.W36 UH1.W37 UH1.W38 UH1.Y29 UH1.Y30 UH1.Y31 UH1.Y32 UH1.Y33 UH1.Y34 UH1.Y35 UH1.Y36
+VCCGT: PC1300.1 PC1301.1 PC1303.1 PC1304.1 PC1305.1 PC1306.1 PC1307.1 PC1309.1 PC1310.1 PC1311.1 PC1312.1 PC1314.1 PC1320.1 PC1321.1 PC1322.1 PC1323.1 PC1324.1 PC1325.1 PC1326.1 PC1327.1 PC1328.1 PC1329.1 PC1330.1 PC1331.1 PC1332.1 PC1333.1 PC1334.1 PC1335.1 PC1338.1 PC1339.1 PC1340.1 PC1341.1 PC1342.1 PC1348.1 PC1349.1 PC1350.1 PC1351.1 PC1352.1 PC1353.1 PC1354.1 PC1359.1 PC1360.1 PC1361.1 PC1362.1 PC1363.1 PC1366.1 PC1367.1 PC1368.1 PC1369.1 PC1370.1 PC1372.1 PC1373.1 PC1374.1 PC1375.1 PC1376.1 PC1377.1 PC1378.1 PC1379.1 PL1300.2 PL1301.2 PR1313.1 PR1315.1 RH203.1 UH1.AJ29 UH1.AJ30 UH1.AJ31 UH1.AJ32 UH1.AJ33 UH1.AJ34 UH1.AJ35 UH1.AJ36 UH1.AK31 UH1.AK32 UH1.AK33 UH1.AK34 UH1.AK35 UH1.AK36 UH1.AK37 UH1.AK38 UH1.AL13 UH1.AL29 UH1.AL30 UH1.AL31 UH1.AL32 UH1.AL35 UH1.AL36 UH1.AL37 UH1.AL38 UH1.AM13 UH1.AM14 UH1.AM29 UH1.AM30 UH1.AM31 UH1.AM32 UH1.AM33 UH1.AM34 UH1.AM35 UH1.AM36 UH1.AN13 UH1.AN14 UH1.AN31 UH1.AN32 UH1.AN33 UH1.AN34 UH1.AN35 UH1.AN36 UH1.AN37 UH1.AN38 UH1.AP13 UH1.AP14 UH1.AP29 UH1.AP30 UH1.AP31 UH1.AP32 UH1.AP35 UH1.AP36 UH1.AP37 UH1.AP38 UH1.AR29 UH1.AR30 UH1.AR31 UH1.AR32 UH1.AR33 UH1.AR34 UH1.AR35 UH1.AR36 UH1.AT14 UH1.AT31 UH1.AT32 UH1.AT33 UH1.AT34 UH1.AT35 UH1.AT36 UH1.AT37 UH1.AT38 UH1.AU14 UH1.AU29 UH1.AU30 UH1.AU31 UH1.AU32 UH1.AU35 UH1.AU36 UH1.AU37 UH1.AU38 UH1.AV29 UH1.AV30 UH1.AV31 UH1.AV32 UH1.AV33 UH1.AV34 UH1.AV35 UH1.AV36 UH1.AW14 UH1.AW31 UH1.AW32 UH1.AW33 UH1.AW34 UH1.AW35 UH1.AW36 UH1.AW37 UH1.AW38 UH1.AY29 UH1.AY30 UH1.AY31 UH1.AY32 UH1.AY35 UH1.AY36 UH1.AY37 UH1.AY38 UH1.BA13 UH1.BA14 UH1.BA29 UH1.BA30 UH1.BA31 UH1.BA32 UH1.BA33 UH1.BA34 UH1.BA35 UH1.BA36 UH1.BB13 UH1.BB14 UH1.BB31 UH1.BB32 UH1.BB33 UH1.BB34 UH1.BB35 UH1.BB36 UH1.BB37 UH1.BB38 UH1.BC29 UH1.BC30 UH1.BC31 UH1.BC32 UH1.BC35 UH1.BC36 UH1.BC37 UH1.BC38 UH1.BD13 UH1.BD14 UH1.BD29 UH1.BD30 UH1.BD31 UH1.BD32 UH1.BD33 UH1.BD34 UH1.BD35 UH1.BD36 UH1.BE31 UH1.BE32 UH1.BE33 UH1.BE34 UH1.BE35 UH1.BE36 UH1.BE37 UH1.BE38 UH1.BF13 UH1.BF14 UH1.BF29 UH1.BF30 UH1.BF31 UH1.BF32 UH1.BF35 UH1.BF36 UH1.BF37 UH1.BF38 UH1.BG29 UH1.BG30 UH1.BG31 UH1.BG32 UH1.BG33 UH1.BG34 UH1.BG35 UH1.BG36 UH1.BH33 UH1.BH34 UH1.BH35 UH1.BH36 UH1.BH37 UH1.BH38 UH1.BJ37 UH1.BJ38 UH1.BL36 UH1.BL37 UH1.BM36 UH1.BM37 UH1.BN36 UH1.BN37 UH1.BN38 UH1.BP37 UH1.BP38 UH1.BR37 UH1.BT37
+VCCIO: CH102.1 CH103.1 CH104.1 PJP800.2 RE69.1 RH24.1 RH30.2 RH483.1 UH1.AG12 UH1.G15 UH1.G17 UH1.G19 UH1.G21 UH1.H15 UH1.H16 UH1.H17 UH1.H19 UH1.H20 UH1.H21 UH1.H26 UH1.H27 UH1.J15 UH1.J16 UH1.J17 UH1.J19 UH1.J20 UH1.J21 UH1.J26 UH1.J27
+VCCSA: CH111.1 CH112.1 CH113.1 CH114.1 CH115.1 CH116.1 CH117.1 CH133.1 CH134.1 CH135.1 CH136.1 CH138.1 PC1380.1 PC1382.1 PC1383.1 PC1384.1 PC1385.1 PC1386.1 PC1388.1 PC1389.1 PC1390.1 PC1391.1 PC1393.1 PC1394.1 PC1395.1 PC1396.1 PL1306.4 RH201.2 UH1.J30 UH1.K29 UH1.K30 UH1.K31 UH1.K32 UH1.K33 UH1.K34 UH1.K35 UH1.L31 UH1.L32 UH1.L35 UH1.L36 UH1.L37 UH1.L38 UH1.M29 UH1.M30 UH1.M31 UH1.M32 UH1.M33 UH1.M34 UH1.M35 UH1.M36
+VCCST: CE34.1 CH107.1 CH108.1 CH109.1 CH110.1 PC1137.1 PR1131.1 PR1145.1 RH97.1 RH98.1 RH100.1 RH151.1 RH152.1 RH156.1 RH163.1 RH164.1 RH570.1 RZ66.2 UE3.B51 UH1.H28 UH1.H30 UH1.J28
+VCCSTG: CH105.1 CH106.1 CZ47.1 RH165.1 RH494.1 RH495.1 RH496.1 RZ48.1 UH1.G30 UH1.H29
AGND: CA5.2 CA6.2 CA7.2 CA12.2 CA13.2 CA14.2 CA17.2 CA20.2 CA21.2 CA24.2 CA25.2 CA26.2 CA27.2 CA28.2 CA29.2 CA30.2 CA31.2 CA41.1 CA42.1 CA43.2 CA44.2 JHP1.5 JHP1.7 RA73.2 RA74.1 RA94.2 RA95.2 UA1.20 UA1.30 UA1.42
DV12S: CR2.1 CR5.1 CR6.1 UR1.10 UR1.14
DV33_18: CR3.1 UR1.18
