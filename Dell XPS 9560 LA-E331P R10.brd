# Allegro board Dell XPS 9560 LA-E331P R10.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
B++: length 12.6
  TOP w0.508: PR415.2 v2(339.66,22.61)
  BOTTOM w0.508: v2(329.76,17.66) 332.93,20.84 336.61,20.84 337.19,21.41 338.46,21.41 v2(339.66,22.61)
  vias: v3(320.31,18.3)
B+_0.95V: length 1.6
  TOP w0.14: v1(104.6,60.91) 105.09,60.41 PL800.2
  vias: v2(106.24,60.08) v2(106.24,59.44) v2(106.24,58.81) v2(106.24,58.17) v2(106.24,57.54)
B+_1V: length 4.7
  TOP w0.14: PC503.1 137.97,5.96 v1(137.99,5.98)
  TOP w0.508: PC504.1 136.17,7.67 v2(136.49,7.34) 136.86,6.98 PC503.1
B+_1VSP: length 1.3
  BOTTOM w0.14: 244.21,116.29 244.77,116.29 v1(245.28,116.8)
  vias: v2(242.25,115.9) v2(242.25,115.26) v2(244.6,118.31) v2(244.6,117.67)
B_DE0: length 2.8
  TOP w0.14: v1(315.89,31.25) 316.18,31.54 v2(316.55,31.54)
  BOTTOM w0.14: RI21.1 316.14,31.54 v2(316.55,31.54) 316.65,31.54 317.25,32.14 UI3.3
B_DE1: length 3.2
  BOTTOM w0.14: UI3.6 317.14,33.64 v1(316.33,34.45) 316.33,35.06 315.66,35.73 RI22.1
B_EQ0: length 4.4
  BOTTOM w0.14: UI3.2 317.26,31.64 316.49,30.87 RI17.1 315.38,30.32 314.64,30.32 314.33,30.64 v1(313.93,30.64)
B_EQ1: length 2.8
  TOP w0.14: v2(316.84,32.42) 316.84,32.11 v1(317.29,31.67)
  BOTTOM w0.14: UI3.4 317.07,32.64 v2(316.84,32.42) 316.16,32.42 RI18.1
B_PWM_EC: length 33.3
  TOP w0.14: v2(301.68,31.4) 301.27,31 301.07,31 RE122.2 302.13,30.11 v1(302.18,30.06) ; UE3.B25 v2(302.93,14.88)
  IN4 w0.091: v2(302.93,14.88) 302.5,15.3 301.65,15.3 301.1,15.85 295.34,15.85 295.34,15.84 294.93,15.84 294.3,16.48 294.3,19.24 295.71,20.66 295.71,21.09 294.96,21.85 294.96,22.18 295.19,22.41 295.46,22.41 295.66,22.61 295.66,25.66 295.4,25.92 295.4,27.69 296.29,28.58 297.36,28.58 299.62,30.84 301.12,30.84 v2(301.68,31.4)
BAT1_LED#: length 174.4
  TOP w0.14: v2(299.42,24.88) 299.98,24.32 RE118.1 ; v2(167.79,9.37) v1(167.79,10.55)
  IN2 w0.099: v2(167.79,9.37) 168.64,10.22 177.97,10.22 179.19,8.99 183.9,8.99 184.54,9.64 187.51,9.64 188.46,8.68 199.5,8.68 200.3,9.48 201.89,9.48 202.85,10.44 211.2,10.44 214.48,7.16 226,7.16 227.46,5.7 238.52,5.7 240.76,7.93 252.17,7.93 252.97,7.13 255.94,7.13 256.93,8.12 262.34,8.12 262.53,7.92 271.91,7.92 273.88,5.95 282.07,5.95 282.82,6.7 284.94,6.7 285.69,5.95 288.2,5.95 288.79,6.54 292.34,6.54 292.68,6.2 295.77,6.2 296.19,6.62 299.06,6.62 v2(299.35,6.33)
  BOTTOM w0.14: v2(299.35,6.33) 299.21,6.47 299.21,10.18 299.02,10.37 299.02,12.72 299.55,13.25 299.55,16.88 300.91,18.25 300.91,19.59 298.93,21.57 298.93,22.84 299.42,23.33 v2(299.42,24.88) ; v2(167.79,9.37) 167.04,8.62 167.04,8.13 166.47,7.55 164.99,7.55 164.4,8.14 163.89,8.14 163.57,7.81 160.3,7.81 159.9,8.21 159.67,8.21 158.77,9.11 JKB.10
BAT2_LED#: length 167.6
  TOP w0.14: v1(303.86,30.11) 303.86,29.24 RE119.1 302.69,28.91 v2(301.92,28.14)
  IN1 w0.099: v2(167.2,9.38) 167.23,9.38 167.63,9.77 168.51,9.77 168.9,10.16 173.32,10.16 174.54,8.94 177.94,8.94 178.75,8.13 199.66,8.13 200.42,8.89 201.8,8.89 203.24,10.32 211.17,10.32 214.04,7.46 227.18,7.46 227.88,8.16 229.02,8.16 229.25,7.93 233.56,7.93 233.66,8.03 252.21,8.03 253.4,6.84 257.44,6.84 258.61,8.02 266.61,8.02 267.02,8.42 271.88,8.42 276.9,13.44 282.48,13.44 284.14,15.1 v2(284.51,15.1)
  IN3 w0.091: v2(301.92,28.14) 301.19,28.86 296.72,28.86 296.5,29.09 v2(296.5,29.32)
  BOTTOM w0.14: v2(284.51,15.1) 284.51,17.63 284.89,18.01 284.89,20.19 288.16,23.47 289.61,23.47 290.27,24.12 290.93,24.12 291,24.19 293,24.19 293.26,24.46 294.46,24.46 294.84,24.85 294.84,25.92 295.68,26.76 295.68,28.23 296.5,29.04 v2(296.5,29.32) ; JKB.9 159.27,8.95 159.77,8.45 160,8.45 160.4,8.05 163.47,8.05 163.79,8.38 164.5,8.38 165.07,7.81 166.38,7.81 166.8,8.23 166.8,8.98 v2(167.2,9.38)
BAT_LED#_LV1: length 5.8
  TOP w0.14: LED1.1 347.92,108.09 v1(347.28,107.45) 347.28,106.05 346.52,105.29 RL5.2
BAT_LED#_LV2: length 3.9
  TOP w0.14: LED2.1 348.91,104.4 v1(347.22,104.4) RL4.2
BAT_LED#_LV3: length 4.9
  TOP w0.14: RL3.2 346.5,103.39 v1(347.15,102.74) LED3.1
BAT_LED#_LV4: length 7.5
  TOP w0.14: LED4.1 347.73,98.56 v1(347.73,100.08) 347.73,101.1 346.46,102.37 RL2.2
BAT_LED#_LV5: length 9.8
  TOP w0.14: LED5.1 347.04,95.65 v1(347.04,96.85) 347.04,100.34 346.03,101.35 RL1.2
BATBTN#: length 158.3
  TOP w0.14: SW2.3 SW2.4 349.06,115.36 348.1,115.36 346.71,113.98 DL1.2 345.17,113.98 v2(345.05,113.85) ; UE3.A63 293.22,12.13 292.67,11.58 292.67,9.99 v3(292.55,9.86) 292.55,9.76 v2(292.14,9.36) 291.53,9.36 291.32,9.14 RP19.4
  IN6 w0.099: v2(345.05,113.85) 344.1,112.9 344.1,105.18 344.93,104.35 344.93,92 340.78,87.85 338.49,87.85 335.98,85.34 335.98,82.4 334.36,80.78 334.36,65.35 336.52,63.2 336.52,57.86 331.69,53.03 331.69,50.6 327.81,46.72 327.81,41.12 324.4,37.71 324.4,35.54 323.86,35 323.86,31.18 319.11,26.43 319.11,25.99 319.33,25.77 319.64,25.77 319.95,25.46 319.95,24.8 318.72,23.57 318.72,20.11 314.78,16.17 314.78,12.91 311.58,9.7 303.46,9.7 303.12,10.04 295.05,10.04 294.26,10.83 293.48,10.83 292.14,9.48 v2(292.14,9.36)
BATDRV#: length 39.8
  TOP w0.254: PR319.2 55.18,22.49 v2(55.44,22.74)
  IN2 w0.254: v2(30.35,25.41) 31.5,26.55 31.87,26.55 32.26,26.95 32.26,28.21 33.68,29.63 36.06,29.63 36.68,29.01 36.68,28.54 37.16,28.07 42.34,28.07 45.08,25.33 47.17,25.33 47.8,24.7 54.21,24.7 55.5,23.41 55.5,22.81 v2(55.44,22.74)
  IN5 w0.254: v2(30.35,25.41) 30.35,24.84 30.22,24.7 30.22,20.97 v2(28.88,19.63)
  BOTTOM w0.14: v1(56.26,23.88) 55.44,23.06 v2(55.44,22.74)
BATT++: length 3.8
  TOP w0.14: v1(28.07,15.76) 27.56,16.26 PC110.1
  TOP w0.508: PC110.1 PC109.1 27.14,17.7 26.61,18.23 v2(26.61,18.68)
BATT_LED#_LV1: length 156
  TOP w0.14: UE4.25 274.17,14.11 v2(273.71,13.65) ; RP24.9 340.39,102.55 340.17,102.76 340.17,104.66 340.49,104.97 343.9,104.97 RL5.1 344.22,105.47 344.55,105.8 345.06,105.8 345.25,105.99 345.25,106.56 v1(344.92,106.89) 344.87,106.94 344.3,106.94 343.69,106.33 v2(343.16,106.33)
  IN6 w0.099: v2(273.71,13.65) 275.1,15.04 282.56,15.04 284.3,16.78 284.3,17.44 285.11,18.25 287.62,18.25 287.77,18.4 291,18.4 291.38,18.78 293.28,18.78 293.71,19.21 293.71,19.32 293.71,19.32 293.71,19.99 293.71,19.99 293.71,20.39 294.33,21 296.65,21 297.09,20.56 303.49,20.56 304.3,21.36 307.85,21.36 308.71,22.22 309.85,22.22 311.3,23.68 311.3,26.46 311.06,26.7 311.06,28.74 310.52,29.27 310.52,34.78 313.42,37.68 314.63,37.68 319.23,42.29 319.57,42.29 320.09,42.28 321.55,43.75 321.55,43.93 321.55,44.6 323.57,46.62 323.57,48.07 324.37,48.86 324.37,50.42 326.14,52.19 326.14,53.46 328.55,55.87 328.55,61.38 327.57,62.36 327.57,69.74 327,70.3 327,71.9 327.41,72.31 328.96,72.31 329.34,72.69 329.34,73.2 329.73,73.59 329.73,79.99 330.68,80.95 330.68,85.09 342.2,96.61 342.2,105.38 v2(343.16,106.33)
BATT_LED#_LV2: length 145.4
  TOP w0.14: RL4.1 343.67,103.85 v2(343.28,103.85) RP24.4 ; v2(272.54,11.97) 272.54,12.34 v1(273.09,12.89) 273.37,13.17 273.93,13.17 274.22,13.46 UE4.26
  IN6 w0.099: v2(272.54,11.97) 273.23,12.66 273.55,12.66 275.73,14.84 282.64,14.84 284.5,16.7 284.5,17.36 285.19,18.05 287.7,18.05 287.86,18.2 291.19,18.2 291.5,17.89 292.96,17.89 295.22,20.16 303.66,20.16 304.46,20.96 309.16,20.96 312.42,24.23 312.42,26.9 314.79,29.27 314.79,31.56 317.16,33.92 317.16,39.06 319.57,41.47 320.43,41.47 322.36,43.41 322.36,44.27 325.18,47.09 325.18,50.05 326.84,51.7 326.84,53.01 331.29,57.47 331.29,59.05 330.23,60.11 330.23,68.21 331.5,69.47 331.5,73.71 330.61,74.6 330.61,79.72 331.5,80.61 331.5,85.5 342.46,96.46 342.46,103.02 v2(343.28,103.85)
BATT_LED#_LV3: length 143.6
  TOP w0.14: v1(272.35,11.44) 272.73,11.44 v2(273.23,11.93) 274.1,12.81 UE4.27 ; RP24.3 v2(343.22,103.2) 343.66,103.2 343.85,103.39 RL3.1
  IN6 w0.099: v2(343.22,103.2) 342.71,102.69 342.71,96.43 331.7,85.42 331.7,80.53 330.81,79.64 330.81,74.68 331.7,73.79 331.7,69.39 330.43,68.13 330.43,60.2 331.5,59.13 331.5,55.83 328.07,52.4 328.07,50.84 325.39,48.15 325.39,47.01 322.57,44.19 322.57,43.33 320.51,41.27 319.65,41.27 317.36,38.98 317.36,33.84 315,31.48 315,29.18 312.63,26.81 312.63,24.15 309.24,20.76 304.55,20.76 303.74,19.96 295.31,19.96 293.04,17.69 291.42,17.69 291.11,18 287.94,18 286.37,16.43 284.52,16.43 282.73,14.64 275.93,14.64 v2(273.23,11.93)
BATT_LED#_LV4: length 142.4
  TOP w0.14: UE4.28 274.15,12.16 v2(273.95,11.96) 273.72,11.73 v1(273.72,11.25) ; RL2.1 343.35,102.37 v2(343.17,102.55) RP24.2
  IN6 w0.099: v2(343.17,102.55) 342.91,102.29 342.91,96.35 331.9,85.33 331.9,69.31 330.64,68.05 330.64,60.28 331.7,59.22 331.7,55.74 328.27,52.32 328.27,50.75 325.9,48.38 325.9,47.23 322.77,44.1 322.77,43.25 320.59,41.07 319.74,41.07 317.56,38.9 317.56,33.72 315.2,31.36 315.2,29.1 312.87,26.77 312.87,21.79 310.43,19.36 304.14,19.36 303.74,19.76 296.54,19.76 296.41,19.63 296.41,18.87 296.09,18.54 294.31,18.54 293.26,17.49 291.33,17.49 291.1,17.72 289.16,17.72 288.5,17.06 287.35,17.06 286.52,16.23 284.61,16.23 282.81,14.44 276.43,14.44 v2(273.95,11.96)
BATT_LED#_LV5: length 148.8
  TOP w0.14: UE4.1 275.93,10.7 v2(275.15,9.91) ; RP24.1 343.22,101.9 343.76,101.35 RL1.1 v1(344.22,99.7) 344.22,99.22 344.36,99.08 v2(344.36,99.07)
  IN6 w0.099: v2(275.15,9.91) 275.74,10.51 281.88,10.51 282.24,10.87 285,10.87 286.51,9.36 287.96,9.36 288.4,9.8 288.4,10.19 289.05,10.84 292.34,10.84 293.14,11.63 294.59,11.63 295.38,10.85 303.76,10.85 304.11,10.5 311.14,10.5 313.96,13.33 313.96,16.5 317.92,20.45 317.92,24.63 318.4,25.12 318.4,26.58 321.84,30.01 321.84,32.15 323.46,33.77 323.46,35.21 324,35.75 324,37.88 325.54,39.42 325.54,43.71 327.61,45.78 327.61,47.67 331.49,51.55 331.49,53.11 336.32,57.94 336.32,63.11 334.16,65.27 334.16,80.86 335.78,82.48 335.78,85.42 344.17,93.82 344.17,98.88 v2(344.36,99.07)
BBS_BIT0: length 2.5
  TOP w0.089: v2(84.88,8.73) v1(84.49,9.11) 84.41,9.2 84.41,9.85 RH130.2
  BOTTOM w0.089: v2(84.88,8.73) 84.88,8.73 UH2.AT29
BC_CLK_ECE1117: length 174.2
  TOP w0.14: UE3.A20 v2(305.29,13.13)
  IN1 w0.099: v2(166.68,9.66) 166.8,9.79 167.36,9.79 167.54,9.97 168.43,9.97 169.03,10.57 176.31,10.57 177.74,9.14 178.03,9.14 178.84,8.33 199.58,8.33 200.37,9.13 201.7,9.13 203.11,10.54 211.24,10.54 214.11,7.67 227.1,7.67 227.8,8.36 229.1,8.36 229.33,8.13 233.48,8.13 233.58,8.23 252.3,8.23 253.49,7.04 257.36,7.04 258.53,8.22 266.53,8.22 268.06,9.75 270.79,9.75 271.53,10.49 273.66,10.49 274.88,11.7 274.88,11.84 273.93,12.79 273.93,12.93 274.07,13.07 274.21,13.07 275.16,12.12 275.3,12.12 275.49,12.31 275.49,12.45 274.55,13.39 274.55,13.55 274.67,13.67 274.83,13.67 275.77,12.73 275.91,12.73 276.05,12.87 276.05,13.01 275.19,13.87 275.19,14.04 275.3,14.15 275.47,14.15 276.33,13.29 276.47,13.29 276.84,13.66 277.38,13.66 277.47,13.76 277.47,14.06 277.57,14.15 277.77,14.15 277.87,14.06 277.87,13.76 277.97,13.66 278.22,13.66 278.31,13.76 278.31,14.06 278.41,14.15 278.61,14.15 278.71,14.06 278.71,13.76 278.81,13.66 279.01,13.66 279.11,13.76 279.11,14.06 279.21,14.15 279.4,14.15 279.5,14.06 279.5,13.76 279.6,13.66 279.92,13.66 280.02,13.76 280.02,14.06 280.12,14.15 280.31,14.15 280.41,14.06 280.41,13.76 280.51,13.66 280.71,13.66 280.81,13.76 280.81,14.06 280.91,14.15 281.11,14.15 281.21,14.06 281.21,13.76 281.31,13.66 281.5,13.66 281.6,13.76 281.6,14.06 281.7,14.15 281.9,14.15 282,14.06 282,13.76 282.1,13.66 282.34,13.66 282.42,13.74 282.42,13.99 282.59,14.15 282.88,14.15 284.97,16.24 285.56,16.24 286.09,16.78 286.09,17.3 286.51,17.71 288.85,17.71 289.14,18 290.56,18 291.26,17.3 293.16,17.3 294.03,16.43 294.03,15.81 294.91,14.93 301.5,14.93 301.98,14.46 303.26,14.46 304.59,13.13 v2(305.29,13.13)
  BOTTOM w0.14: JKB.8 159.77,9.83 160.25,9.34 160.25,8.54 160.5,8.3 163.37,8.3 163.72,8.64 CE81.1 165.72,8.07 166.31,8.07 166.56,8.33 166.56,9.54 v2(166.68,9.66)
BC_DAT_ECE1117: length 179.9
  TOP w0.14: UE3.B21 v2(302.83,12.88) ; v3(165.27,11.74) 165.1,11.58 v2(165.1,10.56) ; RP19.1 290.59,7.64 290.01,7.06 288.99,7.06 288.38,6.45 v2(288.06,6.45)
  IN2 w0.099: v2(288.06,6.45) 287.61,6.9 282.74,6.9 281.99,6.15 273.96,6.15 271.99,8.12 262.62,8.12 262.42,8.32 256.85,8.32 255.87,7.34 253.04,7.34 252.25,8.13 240.67,8.13 238.46,5.92 227.52,5.92 226.08,7.36 214.56,7.36 211.28,10.64 202.67,10.64 201.74,9.71 200.24,9.71 200.09,9.56 197.32,9.56 196.65,8.88 188.54,8.88 187.58,9.85 183.69,9.85 183.56,9.99 178.48,9.99 178.05,10.42 177.17,10.42 177.07,10.52 177.07,10.78 176.97,10.88 176.78,10.88 176.68,10.78 176.68,10.52 176.58,10.42 176.38,10.42 176.28,10.52 176.28,10.78 176.18,10.88 175.98,10.88 175.89,10.78 175.89,10.52 175.79,10.42 175.59,10.42 175.49,10.52 175.49,10.78 175.39,10.88 175.19,10.88 175.09,10.78 175.09,10.52 174.99,10.42 174.8,10.42 174.7,10.52 174.7,10.78 174.6,10.88 174.4,10.88 174.3,10.78 174.3,10.52 174.2,10.42 174,10.42 173.9,10.52 173.9,10.78 173.8,10.88 173.61,10.88 173.51,10.78 173.51,10.52 173.41,10.42 173.21,10.42 173.11,10.52 173.11,10.78 173.01,10.88 172.81,10.88 172.72,10.78 172.72,10.52 172.62,10.42 172.42,10.42 172.32,10.52 172.32,10.78 172.22,10.88 172.02,10.88 171.92,10.78 171.92,10.52 171.82,10.42 171.63,10.42 171.53,10.52 171.53,10.78 171.43,10.88 171.23,10.88 171.13,10.78 171.13,10.52 171.03,10.42 170.83,10.42 170.61,10.64 165.18,10.64 v2(165.1,10.56)
  IN3 w0.091: v2(302.83,12.88) 304,12.88 304.93,11.95 304.93,10.87 305.52,10.27 307.16,10.27 308.4,9.03 308.4,8.17 v2(308.53,8.04)
  IN6 w0.099: v2(308.53,8.04) 308.53,7.48 308.19,7.13 306.66,7.13 306.15,6.61 302.06,6.61 300.65,5.2 293.51,5.2 292.05,6.67 288.28,6.67 v2(288.06,6.45)
  BOTTOM w0.14: v2(165.1,10.56) 165.15,10.51 CE82.1 164.5,8.89 163.62,8.89 163.27,8.54 160.6,8.54 160.49,8.64 160.49,9.44 160.27,9.67 JKB.7
BC_INT#_ECE1117: length 160.9
  TOP w0.14: v2(160.92,8.96) 160.92,9.81 v3(160.78,9.94) ; UE3.A19 305.23,12.63 v2(305.36,12.49)
  IN1 w0.099: v2(305.36,12.49) 304.94,12.49 303.18,14.26 301.89,14.26 301.42,14.73 297.63,14.73 296.98,14.08 294.54,14.08 293.82,14.8 291.75,14.8 291.02,15.53 291.02,16.77 290.27,17.52 289.06,17.52 288.9,17.36 287.58,17.36 286.93,16.7 286.58,16.7 285.54,15.65 285.54,14.64 284.99,14.09 283.47,14.09 282.61,13.24 276.98,13.24 271.96,8.22 267.1,8.22 266.7,7.82 258.7,7.82 257.52,6.64 253.32,6.64 252.13,7.83 237.66,7.83 236.48,6.64 227.83,6.64 227.22,7.26 213.95,7.26 211.09,10.12 203.34,10.12 201.88,8.66 200.47,8.66 199.74,7.93 178.67,7.93 177.86,8.74 173.83,8.74 173.41,8.32 172.53,8.32 171.89,8.96 163.7,8.96 163.13,9.53 161.49,9.53 v2(160.92,8.96)
  BOTTOM w0.14: v2(160.92,8.96) 160.92,9.36 160.77,9.51 JKB.6
BEEP: length 354.2
  TOP w0.14: v3(5,28.01) 4.51,28.51 v2(3.51,28.51) 3.34,28.51 2.9,28.06 RA4.1 ; UE3.B19 302.95,11.88 v2(302.9,11.93)
  IN3 w0.091: v2(5.95,17.09) 5.83,17.21 5.83,19.87 7.75,21.79 7.75,25.1 4.34,28.51 3.51,28.51 v2(3.51,28.51)
  IN6 w0.099: v2(308.59,16.98) 308.37,17.19 304.32,17.19 303.29,16.16 300.96,16.16 300.58,15.78 295.02,15.78 294.08,14.84 291.72,14.84 291.22,15.34 291.22,16.03 289.73,17.52 289.24,17.52 288.58,16.86 287.43,16.86 286.6,16.03 284.69,16.03 282.9,14.23 276.8,14.23 273.31,10.74 262.57,10.74 261.64,9.81 250.51,9.81 249.33,10.98 237.28,10.98 236.83,10.53 234.89,10.53 234.5,10.92 230.94,10.92 230.77,10.92 228.19,13.5 186.85,13.5 185.17,11.82 175.71,11.82 175.68,11.8 161.02,11.8 160.66,12.16 152.13,12.16 152.07,12.21 149.31,12.21 149.17,12.07 146.28,12.07 145.82,12.53 129.43,12.53 128.62,13.33 125.45,13.33 124.35,12.24 116.64,12.24 116.04,12.83 112.98,12.83 112.18,12.03 108.71,12.03 107.86,12.88 101.19,12.88 100.93,13.14 99.44,13.14 99.3,13 96.38,13 95.99,13.39 91.87,13.39 91.67,13.19 79.22,13.19 77.87,11.84 77.87,11.34 77.53,11 75.67,11 74.87,10.21 73.32,10.21 72.94,10.59 72.94,12.44 70.09,15.29 59.59,15.29 57.53,17.35 57.53,18.45 55.28,20.7 55.28,21.45 54.14,22.59 48.16,22.59 46.78,23.97 45.77,23.97 45.03,24.72 37.89,24.72 37.25,24.08 27.17,24.08 26.96,24.29 23.28,24.29 21.36,22.37 16.58,22.37 14.26,20.04 9.61,20.04 6.66,17.09 v2(5.95,17.09)
  BOTTOM w0.14: v2(302.9,11.93) 304.24,13.27 304.24,16.29 305.14,17.19 308.38,17.19 v2(308.59,16.98)
BIA_PWM_EC: length 289.5
  TOP w0.14: v2(105.94,48.28) v3(105.94,49.04) ; v2(297.38,29.4) 298.07,28.71 299.09,28.71 299.21,28.84 300.1,28.84 300.36,29.09 300.36,29.47 300.15,29.68 RE122.1 ; DV2.3 50.94,26.12 51.06,26.23 v2(51.06,26.49)
  IN1 w0.099: v2(105.94,48.28) 105.94,47.61 95.34,37 92.67,37 92.17,36.51 87.56,36.51 84.72,33.67 81.7,33.67 79.68,31.66 77.87,31.66 77.49,31.29 74.83,31.29 74.55,31.57 71.76,31.57 71.31,31.12 70.93,31.12 67.63,27.82 52.39,27.82 v2(51.06,26.49)
  IN3 w0.089: v2(172.15,53.7) 174.75,53.7 175.19,53.27
  IN3 w0.091: v2(263.85,21.94) 263.85,21.94 261.42,21.94 258.71,24.65 258.51,24.65 253.56,29.6 252.18,29.6 251.23,30.55 228.72,30.55 228.49,30.79 228.49,31.4 228.49,31.4 228.49,32.44 216.94,43.99 216.49,43.99 215.51,44.97 215.26,44.97 214.31,45.92 214.31,46.69 213.51,47.48 209.79,47.48 208.43,48.84 208.43,49.27 207.71,50 206.45,50 205.13,48.68 203.36,48.68 202.05,49.99 194.84,49.99 194.63,49.79 190.51,49.79 190.41,49.79 178.67,49.79 175.19,53.27
  IN6 w0.099: v2(263.85,21.94) 263.85,21.94 265.33,20.46 277.78,20.46 278.97,21.65 281.14,21.65 282.31,22.82 286.3,22.82 286.78,22.34 290.3,22.34 291.97,24.01 294.01,24.01 294.9,24.9 295.4,24.9 297.31,26.81 297.31,29.32 v2(297.38,29.4)
  BOTTOM w0.127: v2(172.15,53.7) 171.04,52.59 166.25,52.59 160.35,46.69 118.45,46.69 116.63,48.52 114.97,48.52 114.2,47.75 113.36,47.75 112.59,48.52 106.19,48.52 v2(105.94,48.28)
BIA_PWM_PCH: length 201.2
  TOP w0.14: v2(180.63,88.91) 181.26,88.91 v3(181.38,89.04) ; DV2.2 49.64,23.86 v2(49.14,23.35)
  IN1 w0.076: 75.06,16.07 75.68,15.45 77.05,15.45 78.23,16.63 81.74,16.63 v2(82.21,17.1)
  IN1 w0.099: 75.06,16.07 74.87,16.26 71.58,16.26 71.13,16.7 65.42,16.7 64.94,16.22 63.99,16.22 63.64,15.87 60.52,15.87 59.23,17.15 57.67,17.15 57.16,17.66 57.16,22.85 56.16,23.86 55.01,23.86 53.76,22.62 49.87,22.62 v2(49.14,23.35)
  IN4 w0.091: v2(121.54,51.7) 121.46,51.78 121.46,62.03 123.01,63.57 123.39,63.57 125.26,65.44 125.26,68.51 127.6,70.84 127.6,78 131.61,82.01 131.61,82.26 133.13,83.78 133.13,89.04 v2(131.94,90.23)
  IN5 w0.089: 100.35,27.31 100.35,23.45 96.83,19.92 93.61,19.92 92.91,19.22 91.79,19.22 90.7,18.13 85.62,18.13 85.01,17.52 85.01,17.01 84.8,16.8 82.51,16.8 v2(82.21,17.1)
  IN5 w0.099: v2(121.54,51.7) 121.54,51.64 117.79,47.89 117.79,43.54 103.71,29.46 101.16,29.46 100.35,28.66 100.35,27.31
  IN6 w0.089: 179.9,89.2 176.52,89.2 176.49,89.23
  IN6 w0.099: v2(180.63,88.91) 180.34,89.2 179.9,89.2 ; v2(131.94,90.23) 133.15,91.44 156.76,91.44 157.39,90.8 170.26,90.8 171.08,89.98 175.74,89.98 176.49,89.23
  BOTTOM w0.089: v2(82.21,17.1) 81.87,16.76 UH2.W36
  BOTTOM w0.14: v2(180.63,88.91) 180.63,88.3 181.24,87.69 RH456.2
BID_BC: length 3.1
  TOP w0.089: v1(79.2,9.46) 79.2,8.92 RH567.1 79.07,8.29 v2(79.41,8.29) 79.58,8.29 RH566.2
  BOTTOM w0.089: v2(79.41,8.29) 79.48,8.22 UH2.AU41
BID_DIS: length 243.7
  TOP w0.089: RH565.1 RH564.2 80.04,5.99 79.11,5.99 v2(78.87,6.23) 78.5,6.6 v1(78.45,6.6)
  TOP w0.14: v2(299.56,3.43) 299.56,3.46 299.4,3.62 RE112.2
  IN5 w0.089: v2(78.87,6.23) 79.19,6.23 79.29,6.13 81.51,6.13 82.12,5.53 83.01,5.53 83.45,5.08 84.21,5.08 84.62,5.5 85.26,5.5 85.8,4.96 86.49,4.96 87.14,4.31 89.43,4.31 89.74,4 91.19,4 91.31,3.87 91.31,3.18 90.87,2.74 90.87,1.6 91.06,1.41 97.96,1.41 100.19,3.63 101.98,3.63
  IN5 w0.099: 101.98,3.63 104.73,3.63 105.41,2.95 105.41,2.29 v2(105.03,1.91) ; v2(299.56,3.43) 298.91,4.07 297.44,4.07 297.2,4.31 295.71,4.31 295.71,4.3 291.26,4.3 291.03,4.07 285.42,4.07 285.17,4.32 285.1,4.32 284.95,4.47 282.53,4.47 281.79,5.2 273.91,5.2 272.53,6.57 271.14,6.57 270.67,7.04 262.81,7.04 262.48,7.37 239.45,7.37 238.18,6.11 227.39,6.11 226.05,7.45 219.36,7.45 219.15,7.24 211.26,7.24 210.18,8.33 206.61,8.33 205.97,7.68 203.53,7.68 199.56,3.71 186.94,3.71 v2(186.07,4.59)
  IN6 w0.099: v2(105.03,1.91) 105.31,2.19 108.75,2.19 109.33,2.76 117.37,2.76 121.08,6.47 126.71,6.47 126.81,6.37 129.64,6.37 130.22,5.79 132.53,5.79 134.45,3.86 137.37,3.86 140.02,1.22 150.24,1.22 151.29,2.27 183.91,2.27 186.07,4.42 v2(186.07,4.59)
  BOTTOM w0.089: UH2.BA41 79.43,6.17 78.93,6.17 v2(78.87,6.23)
BOARD_ID: length 8.2
  TOP w0.14: v1(299.86,6.19) 299.8,6.26 299.8,7.22 RE67.2 298.78,7.37 CE51.1 299.4,8.15 v2(299.66,8.15) ; UE3.B10 v2(299.52,11.56)
  BOTTOM w0.14: v2(299.52,11.56) 299.52,10.74 300.19,10.07 300.19,8.68 v2(299.66,8.15)
BOOT_1.2V: length 7.6
  BOTTOM w0.14: 284.61,29.5 282.09,29.5 280.93,30.67 280.93,32.65 281.18,32.9 281.81,32.9 v3(282.14,32.57)
BQ24777_REGN: length 20.9
  TOP w0.254: v2(51.48,19.12) 51.48,19.14 51.51,19.18 51.51,20.68 51.84,21.01 51.84,21.71 PR318.2 52.39,23.31 52.72,23.64 54.24,23.64 54.29,23.69 55.88,23.69 56.35,23.22 57.05,23.22 57.34,22.93 PR321.1
  IN3 w0.254: v2(55.12,11.12) 55.12,11.93 54.04,13.01 54.04,13.9 52.84,15.11 52.84,16.8 51.31,18.32 51.31,18.95 v2(51.48,19.12)
  BOTTOM w0.254: PR311.1 54.9,11.34 v2(55.12,11.12)
  vias: v1(50.7,20.67)
BST1_3V: length 1.7
  TOP w0.14: v3(340.39,25.52) 341,24.91 341,24.08
BST1_5V: length 3
  TOP w0.14: v1(346.67,15.95) 346.36,16.26 345.16,16.26 344.23,17.19 PC411.1
BST1_NVVDD:
  vias: v1(165.65,112.58)
BST1_NVVDDS:
  vias: v1(182.78,112.77)
BST_0.95V: length 0.9
  TOP w0.14: 106.47,62.15 v3(105.83,62.15)
  BOTTOM w0.254: 107.16,62.96 PU800.6
  vias: v2(106.62,62.81)
BST_1V: length 6
  TOP w0.508: v2(134.89,4.47) 134.13,4.47 v3(133.91,4.68) 133.8,4.8 133.8,6.05 134.88,7.13 PR503.1
  BOTTOM w0.254: v2(134.89,4.47) 134.39,4.47 134.1,4.76 133.88,4.76 133.78,4.65 PU500.6
BST_1VSP: length 3.7
  TOP w0.14: v1(243.13,113.22) 242.76,112.85 v2(242.25,112.85)
  TOP w0.508: v2(242.25,112.85) 242.19,112.85 241.68,113.36 PR904.1
  BOTTOM w0.254: v2(242.25,112.85) 242.13,112.85 242.03,112.94 241.78,112.94 241.6,113.12 PU900.6
BST_3V: length 6
  TOP w0.14: PR411.2 343.66,24.31 347.49,28.13 v3(347.82,28.13)
BST_5V: length 1.4
  TOP w0.14: PR412.1 341.89,16.11 v1(341.64,15.87)
BST_+1.35VRUN: length 1.8
  BOTTOM w0.14: v1(196.52,114.52) 196.52,114.89 v2(196.34,115.07)
  BOTTOM w0.254: v2(196.34,115.07) 196.2,114.93 PU700.4
BT_RADIO_DIS#: length 115
  TOP w0.14: v2(272.15,13.59) v1(272.15,14.12) 272.15,14.27 RE72.2 273.28,15.41 UE4.23
  IN6 w0.099: v2(328.74,72.72) 327.53,72.72 326.8,71.98 326.8,70.22 327.37,69.65 327.37,62.28 328.35,61.3 328.35,55.96 325.94,53.54 325.94,52.27 324.17,50.5 324.17,48.95 323.37,48.15 323.37,46.71 320.07,43.4 320.06,43.4 319.83,43.17 319.83,43.16 314.54,37.88 313.33,37.88 310.32,34.87 310.32,29.19 310.86,28.65 310.86,26.62 311.1,26.38 311.1,23.76 309.76,22.42 308.62,22.42 307.77,21.56 304.21,21.56 303.41,20.76 297.18,20.76 296.73,21.21 294.24,21.21 293.51,20.47 293.51,19.9 293.51,19.9 293.51,19.4 293.51,19.4 293.51,19.29 293.2,18.98 291.3,18.98 290.91,18.6 288.9,18.6 288.9,18.6 287.69,18.6 287.54,18.45 285.02,18.45 284.1,17.52 284.1,16.86 282.47,15.24 273.8,15.24 v2(272.15,13.59)
  BOTTOM w0.14: v2(328.74,72.72) 329.4,73.38 331.11,73.38 331.98,74.24 DN2.1
BT_RADIO_DIS#_R: length 25.3
  TOP w0.14: v2(341.26,89.62) 341.87,89.62 v3(343.6,87.89)
  IN2 w0.099: v2(341.26,89.62) 341.62,89.62 341.89,89.35 341.89,88.78 341.44,88.34 339.41,88.34 339.09,88.02 334.62,88.02 333.48,86.88 333.48,83.57 331.34,81.44 v2(331.34,78.75)
  BOTTOM w0.14: JNGFF1.46 341.8,90.16 v2(341.26,89.62) ; DN2.2 331.47,78.62 v2(331.34,78.75)
CAM_CBL_DET#: length 34.7
  BOTTOM w0.089: 76.98,18.13 77.18,18.13 77.48,17.83 78.23,17.83 78.33,17.73 78.34,17.73 78.38,17.69 UH2.U43
  BOTTOM w0.127: JEDP1.29 57.55,31.73 57.99,31.29 58.72,31.29 60.52,29.49 60.52,28.09 60.58,28.03 v3(60.58,27.89) 60.67,27.8 60.67,20.43 61.02,20.07 65.79,20.07 67.46,21.75 68.34,21.75 68.61,21.49 68.61,21.21 68.99,20.82 71.44,20.82 72.06,20.2 RH511.1 73.03,19.26 74.41,19.26 75.22,18.45 76.54,18.45 76.86,18.13 76.98,18.13
CD_WAKE#: length 4.4
  BOTTOM w0.14: UR1.32 342.73,35.69 RR10.2 343.65,35.01 343.79,34.87 343.79,34.6 RR1.2 344.29,33.54 v1(343.71,32.97)
CFG0: length 49.3
  TOP w0.14: RH488.2 130.86,95.51 131.15,95.8 v2(131.15,96.15) ; RH183.1 132.45,76.74 132.51,76.81 139.04,76.81 v3(139.38,77.15) 139.73,77.49 v2(139.73,77.6) ; v2(125.05,88.27) 125.54,88.76 126.39,88.76 126.77,88.38 126.77,87.77 127.03,87.51 JXDP.9
  IN2 w0.099: v2(131.15,96.15) 131.15,96 132.6,94.55 132.6,93.21 130.48,91.09 126.22,91.09 125.78,90.65 125.78,89 v2(125.05,88.27) ; 133.4,77.36 138.34,77.36 138.52,77.19 139.31,77.19 v2(139.73,77.6)
  IN2 w0.102: v2(125.05,88.27) 125.45,87.86 125.48,87.86 128.7,84.63 128.7,82.17 129.21,81.66 129.36,81.66 131.07,79.95 131.07,79.69 133.4,77.36
  BOTTOM w0.076: UH1.BN25 139.4,77.28 v2(139.73,77.6)
CFG1: length 19.2
  TOP w0.089: v2(139.73,79.18) 139.83,79.18 v3(140.45,78.56)
  TOP w0.14: JXDP.11 130.11,88.01 v2(130.49,87.63)
  IN2 w0.099: 130.89,86.34 130.49,86.74 v2(130.49,87.63)
  IN2 w0.102: v2(139.73,79.18) 139.36,79.55 137.67,79.55 137.08,80.14 136.1,80.14 135.63,80.61 134.14,80.61 133.55,81.2 132.64,81.2 131.27,82.57 131.27,85.96 130.89,86.34
  BOTTOM w0.076: v2(139.73,79.18) 139.4,78.85 UH1.BN27
CFG2: length 26.3
  TOP w0.14: v2(139.08,77.6) 138,77.6 v3(137.61,77.21) 137.47,77.07 133.01,77.07 RH184.1 ; JXDP.15 129.87,89.01 v2(129.92,88.96)
  IN2 w0.102: v2(139.08,77.6) 136.92,79.76 135.95,79.76 135.5,80.21 133.97,80.21 133.39,80.78 132.43,80.78 130.79,82.42 130.79,85.26 129.59,86.46 129.59,88.63 v2(129.92,88.96)
  BOTTOM w0.076: UH1.BN26 139.4,77.93 v2(139.08,77.6)
CFG3: length 22.1
  TOP w0.089: v3(138.48,79.31) 138.61,79.18 v2(139.08,79.18)
  TOP w0.14: JXDP.17 130.41,89.51 131.71,88.21 131.71,86.36 131.18,85.82 v2(130.81,85.82)
  IN2 w0.102: v2(130.81,85.82) 131,85.64 131,82.5 132.52,80.98 133.48,80.98 134.05,80.41 135.57,80.41 136.02,79.95 137,79.95 137.77,79.18 v2(139.08,79.18)
  BOTTOM w0.076: v2(139.08,79.18) 139.4,79.5 UH1.BN28
  BOTTOM w0.14: RH474.2 131.06,85.57 v2(130.81,85.82)
CFG4: length 34.6
  TOP w0.089: v1(135.13,74.55) 135.13,74.39 v2(134.77,74.04) 134.62,74.19
  TOP w0.14: v2(126.54,92.07) 126.61,92.01 JXDP.27 ; RH185.1 134,74.81 134.62,74.19
  IN2 w0.102: v2(126.54,92.07) 125.97,91.5 124.92,91.5 122.61,89.19 122.61,87.13 125.07,84.67 125.07,81.06 132.59,73.54 134.28,73.54 v2(134.77,74.04)
  BOTTOM w0.076: UH1.BR20 137.81,73.57 137.33,73.57 137.19,73.43 135.38,73.43 v2(134.77,74.04)
CFG5: length 48.2
  TOP w0.089: v3(141.21,72.31) 140.64,72.88 v2(140.38,72.88)
  TOP w0.14: v2(125.67,92.17) 126,92.51 JXDP.29 ; RH186.1 132.93,71.19 v2(133.41,71.67)
  IN2 w0.099: 124.65,91.81 124.75,91.9 125.4,91.9 v2(125.67,92.17)
  IN2 w0.102: v2(140.38,72.88) 139.99,73.26 135.89,73.26 135.74,73.11 132.44,73.11 124.66,80.89 124.66,84.5 122.2,86.97 122.2,89.36 124.65,91.81
  BOTTOM w0.076: UH1.BM20 140.05,73.2 v2(140.38,72.88) 140.38,70.81 140.18,70.62 139.19,70.62 139.08,70.74 139.08,71.15 138.88,71.36 137.06,71.36 136.95,71.25 134.62,71.25
  BOTTOM w0.14: 134.62,71.25 133.84,71.25 v2(133.41,71.67)
CFG6: length 36.2
  TOP w0.14: v3(130.84,73.38) 131.36,73.9 RH187.1 132.4,73.55 133.04,73.55 v2(133.5,74.02) ; v2(126.59,92.95) 127.15,93.51 JXDP.33
  IN2 w0.102: v2(133.5,74.02) 132.77,74.76 131.67,74.76 125.28,81.15 125.28,84.75 122.81,87.22 122.81,89.1 125,91.29 126.41,91.29 127,91.88 127,92.55 v2(126.59,92.95)
  BOTTOM w0.14: UH1.BT20 137.28,73.1 134.43,73.1 v2(133.5,74.02)
CFG7: length 38.6
  TOP w0.14: v2(125.95,92.95) 127.01,94.01 JXDP.35 ; v2(136.01,74.05) 136.01,73.28 v3(135.97,73.24) 135.61,73.24 135.21,72.84 RH188.1
  IN2 w0.102: v2(136.01,74.05) 135.28,73.33 132.51,73.33 124.86,80.98 124.86,84.59 122.4,87.05 122.4,89.27 124.83,91.7 125.78,91.7 126.11,92.03 126.11,92.78 v2(125.95,92.95)
  BOTTOM w0.076: UH1.BP20 138.43,73.59 138.2,73.59 138.03,73.77 137.2,73.77 137.07,73.64 136.42,73.64 v2(136.01,74.05)
CFG8: length 23.5
  TOP w0.089: v2(135.41,75.64) 135.41,75.94 v1(135.23,76.12)
  TOP w0.14: v2(124.03,87.85) 123.68,87.51 JXDP.10
  IN2 w0.099: 124.26,87.21 124.03,87.44 v2(124.03,87.85)
  IN2 w0.102: 124.26,87.21 126.6,84.86 126.6,83.53 127.15,82.98 127.15,81.78 130.29,78.64 130.92,78.64 133.28,76.29 134.76,76.29 v2(135.41,75.64)
  BOTTOM w0.076: v2(135.41,75.64) 135.8,76.03 137.71,76.03 UH1.BR23
CFG9: length 25.3
  TOP w0.14: JXDP.12 123.44,88.01 v2(123.95,88.52) ; v2(134.14,75.64) 134.14,75.71 v1(133.81,76.04)
  IN2 w0.099: 130.4,78.36 130.92,78.36 133.2,76.08 133.69,76.08 v2(134.14,75.64)
  IN2 w0.102: 130.4,78.36 129.3,78.36 126.1,81.56 126.1,85.08 123.62,87.56 123.62,88.19 v2(123.95,88.52)
  BOTTOM w0.076: 134.62,75.15 134.77,75 137.19,75 137.33,75.14 137.81,75.14 UH1.BR22
  BOTTOM w0.14: 134.62,75.15 v2(134.14,75.64)
CFG10: length 24.2
  TOP w0.089: v3(136.78,75.03) 136.65,75.03 v2(136.04,75.64)
  TOP w0.14: v2(124.29,88.99) 124.28,89.01 JXDP.16
  IN2 w0.102: v2(124.29,88.99) 124.44,88.85 124.44,87.32 126.81,84.95 126.81,83.61 127.36,83.06 127.36,81.87 130.38,78.85 131.01,78.85 133.3,76.55 135.13,76.55 v2(136.04,75.64)
  BOTTOM w0.076: UH1.BT23 137.06,75.24 136.44,75.24 v2(136.04,75.64)
CFG11: length 28.8
  TOP w0.14: v2(125.25,89.51) JXDP.18 ; v2(133.5,75.62) 132.55,75.62 v1(132.39,75.79)
  IN2 w0.099: 125.89,81.49 131.76,75.62 v2(133.5,75.62)
  IN2 w0.102: 125.89,81.49 125.89,85 123.42,87.47 123.42,88.85 123.97,89.4 125.14,89.4 v2(125.25,89.51)
  BOTTOM w0.076: UH1.BT22 137.39,74.78 134.62,74.78
  BOTTOM w0.127: 134.35,74.78 v2(133.5,75.62)
  BOTTOM w0.14: 134.62,74.78 134.35,74.78
CFG12: length 34.4
  TOP w0.089: v3(139.42,72.11) 139.73,72.41 v2(139.73,72.88)
  TOP w0.14: v2(124.01,91.74) 123.74,92.01 123.74,92.01 JXDP.28
  IN2 w0.102: v2(139.73,72.88) 139.71,72.89 132.37,72.89 124.46,80.81 124.46,84.42 122,86.88 122,89.44 123.81,91.26 123.81,91.54 v2(124.01,91.74)
  BOTTOM w0.076: v2(139.73,72.88) 140.05,72.55 UH1.BM19
CFG13: length 35.1
  TOP w0.089: v2(136.06,71.66) 136.43,72.03 137.33,72.03 v3(137.63,71.73)
  TOP w0.14: JXDP.30 123.84,92.51 v2(124.01,92.33)
  IN2 w0.102: v2(136.06,71.66) 135.03,72.69 132.29,72.69 124.25,80.72 124.25,84.34 121.79,86.8 121.79,89.52 123.51,91.24 123.51,91.83 v2(124.01,92.33)
  BOTTOM w0.076: UH1.BR19 138.1,72.27 137.82,71.99 137.2,71.99 137.13,72.05 136.45,72.05 v2(136.06,71.66)
CFG14: length 38
  TOP w0.089: v2(135.42,71.66) 136.09,70.99 v3(136.09,70.8)
  TOP w0.14: v2(124.64,92.34) 123.48,93.51 JXDP.34
  IN2 w0.102: v2(135.42,71.66) 134.66,72.42 132.27,72.42 124.05,80.64 124.05,84.25 121.59,86.71 121.59,89.61 123.31,91.32 123.31,92.21 123.84,92.74 124.24,92.74 v2(124.64,92.34)
  BOTTOM w0.076: UH1.BP19 138.47,72.77 137.94,72.77 137.75,72.58 137.75,72.32 137.63,72.19 137.33,72.19 137.27,72.26 136.02,72.26 v2(135.42,71.66)
CFG15: length 36.1
  TOP w0.14: v2(124.66,92.97) 124.47,92.97 123.44,94.01 JXDP.36 ; v2(134.09,71.7) 134.09,71.52 v3(134.39,71.22)
  IN2 w0.099: v2(134.09,71.7) 133.63,72.16 132.43,72.16
  IN2 w0.102: 132.43,72.16 132.24,72.16 123.85,80.55 123.85,84.17 121.39,86.63 121.39,89.69 123.1,91.41 123.1,92.3 123.78,92.97 v2(124.66,92.97)
  BOTTOM w0.14: v2(134.09,71.7) 134.88,72.49 UH1.BT19
CFG16: length 26.9
  TOP w0.089: v2(138.43,76.03) 138.43,75.53 v1(138.39,75.5)
  TOP w0.14: JXDP.6 123.7,86.51 124.45,87.26 124.45,88.47 v2(124.94,88.95)
  IN2 w0.102: v2(138.43,76.03) 137.64,76.82 133.32,76.82 131.09,79.05 130.46,79.05 127.56,81.95 127.56,83.15 127.01,83.7 127.01,85.03 124.64,87.4 124.64,88.66 v2(124.94,88.95)
  BOTTOM w0.076: v2(138.43,76.03) 138.75,75.7 UH1.BP23
CFG17: length 25.8
  TOP w0.089: v2(139.08,76.03) 139.57,75.54 v3(140.11,75.54)
  TOP w0.14: v2(125.05,87.67) 125.05,87.18 123.87,86.01 JXDP.4
  IN2 w0.102: v2(125.05,87.67) 125.38,87.67 128.5,84.55 128.5,82.08 129.13,81.45 129.28,81.45 130.87,79.86 130.87,79.6 133.38,77.1 138.01,77.1 v2(139.08,76.03)
  BOTTOM w0.076: v2(139.08,76.03) 139.4,75.7 UH1.BN23
CFG18: length 32.7
  TOP w0.089: v3(139.47,73.9) 139.08,74.29 v2(139.08,74.45)
  TOP w0.14: JXDP.24 125.11,91.01 v2(125.32,90.8)
  IN2 w0.102: v2(125.32,90.8) 124.8,90.8 123.01,89.02 123.01,87.3 125.48,84.83 125.48,81.27 131.79,74.96 137.2,74.96 138.09,74.08 138.7,74.08 v2(139.08,74.45)
  BOTTOM w0.076: UH1.BN22 139.4,74.78 v2(139.08,74.45)
CFG19: length 31.6
  TOP w0.089: v2(138.43,74.45) 137.73,73.76 v3(137.73,73.53)
  TOP w0.14: JXDP.22 123.65,90.51 123.75,90.61 124.9,90.61 v2(125.31,90.2)
  IN2 w0.102: v2(125.31,90.2) 125.31,90.15 124.77,89.6 123.89,89.6 123.22,88.93 123.22,87.39 125.69,84.92 125.69,81.4 131.92,75.17 137.72,75.17 v2(138.43,74.45)
  BOTTOM w0.076: UH1.BP22 138.75,74.78 v2(138.43,74.45)
CFG_RCOMP: length 4.9
  BOTTOM w0.254: UH1.BT25 136.96,77.21 136.57,76.81 v1(133.61,76.81) RH59.1
CHAGER_SRC:
  vias: v2(49.53,8.86) v2(49.53,8.28) v2(49.53,7.69) v2(51.31,8.89) v2(51.31,8.3) v2(51.31,7.72) v3(50.48,8.33)
CHARGER_SCL: length 4.3
  TOP w0.14: v1(59.87,19.64) 59.87,19.32 59.35,18.8 PR309.2
  TOP w0.203: PU300.12 57.8,17.51 58.04,17.27 58.45,17.27 58.8,17.62 58.8,17.83 PR309.2
CHARGER_SDA: length 2.5
  TOP w0.203: PU300.11 57.77,17.11 57.98,16.9 58.76,16.9 PR306.2
CHARGER_SMBCLK: length 270.1
  TOP w0.14: v2(292.95,22.24) 292.92,22.21 292.92,21.98 292.48,21.54 290.73,21.54 RE23.1 ; v2(295.07,19.13) 295.52,19.58 UE3.B50
  TOP w0.254: PR309.1 61.02,18.37 v1(61.4,17.99) 61.54,17.85 v2(61.54,17.28)
  IN1 w0.076: v2(100.12,19) 99.19,19.93 94.61,19.93 93.86,20.68 89.93,20.68 88.19,18.94 78.49,18.94 77.46,17.9 75.66,17.9 75.18,18.38 75.06,18.38
  IN1 w0.099: v2(61.54,17.28) 61.91,17.65 63.53,17.65 64.14,18.26 66.09,18.26 66.61,17.74 69.01,17.74 69.65,18.38 70.26,18.38 70.44,18.55 70.44,18.74 70.62,18.92 70.87,18.92 71.05,18.74 71.05,18.39 71.23,18.21 71.48,18.21 71.66,18.39 71.66,18.74 71.83,18.92 72.08,18.92 72.26,18.74 72.26,18.23 72.44,18.06 72.69,18.06 72.87,18.23 72.87,18.74 73.05,18.92 73.3,18.92 73.48,18.74 73.48,18.55 73.65,18.38 75.06,18.38
  IN3 w0.091: v2(288.21,13.93) 288.38,14.09 290.01,14.09 290.78,14.87 290.78,16.9 291.61,17.73 293.57,17.73 294.98,19.13 v2(295.07,19.13)
  IN5 w0.089: v2(100.12,19) 101.01,18.11 101.98,18.11
  IN5 w0.099: v2(288.21,13.93) 284.44,13.93 284,13.49 275.7,13.49 275.14,12.93 272.21,12.93 272.02,12.75 267.04,12.75 266.13,13.65 255.48,13.65 250.09,19.04 222.74,19.04 221.78,20 221.78,23.89 219.12,26.55 187.19,26.55 186.93,26.81 182.02,26.81 178.44,23.23 178.44,19.29 175.02,15.86 165.37,15.86 165.21,15.7 129.69,15.7 129.63,15.76 106.3,15.76 104.27,17.79 102.3,17.79 101.98,18.11
  BOTTOM w0.14: v2(295.07,19.13) 295.07,19.61 292.95,21.73 v2(292.95,22.24)
CHARGER_SMBDAT: length 264.2
  TOP w0.14: UE3.A47 295.77,21.6 v2(295.36,22.01) 295.36,22.05 v1(295.01,22.4) 294.9,22.51 RE22.1
  TOP w0.254: v2(60.95,17.28) 60.75,17.48 PR306.1
  IN5 w0.089: 101.98,19.69 97.87,19.69 97.23,19.05 93.15,19.05 91.33,17.23 85.6,17.23 84.05,15.68 75.61,15.68 75.34,15.94 75.06,15.94
  IN5 w0.099: v2(284.66,14.5) 283.85,13.69 275.47,13.69 274.96,13.18 271.98,13.18 271.28,13.88 255.54,13.88 250.1,19.31 222.75,19.31 221.98,20.08 221.98,23.98 219.2,26.75 187.27,26.75 187.01,27.01 181.89,27.01 178.24,23.36 178.24,19.36 174.94,16.06 165.29,16.06 165.13,15.9 131.52,15.9 131.42,16.01 106.54,16.01 102.86,19.69 101.98,19.69 ; 75.06,15.94 73.33,15.94 73.06,15.68 69.83,15.68 69.14,16.37 66.43,16.37 65.87,16.94 62.55,16.94 61.8,17.69 61.36,17.69 v2(60.95,17.28)
  BOTTOM w0.14: v2(295.36,22.01) 294.63,22.74 292.39,22.74 289.66,20.01 286.89,20.01 286.44,19.55 286.44,18.23 287.16,17.51 287.16,17.07 284.66,14.57 v2(284.66,14.5)
CHG_BTS: length 2.9
  TOP w0.14: PR307.1 50.13,18.21 48.45,18.21 v1(48.26,18.4)
CHG_BTS_C: length 1
  TOP w0.14: 49.19,16.91 v1(48.24,16.91)
CHG_LGATE: length 18.6
  TOP w0.14: v1(52.03,19.12) 52.03,18.83 v2(51.82,18.61)
  IN5 w1.016: 50.61,18.23 48.77,18.23 47.68,17.14 47.68,3.13 48.13,2.68
  vias: v2(48.9,2.42) v2(49.48,2.42) v2(52.26,18.17)
CHG_SW: length 11.6
  IN1 w1.016: 42.55,8.26 42.55,8.96 49.4,15.82 50.61,15.82
  vias: v2(35.75,6.8) v2(36.53,7.29) v2(36.53,6.7) v2(37.11,7.29) v2(37.11,6.7) v2(37.69,7.29) v2(37.69,6.7) v2(38.28,7.29) v2(38.28,6.7) v2(38.86,7.29) v2(38.86,6.7) v2(39.29,5.39) v2(39.29,4.81) v2(39.88,5.39) v2(39.88,4.81) v2(40.46,5.39) v2(40.46,4.81) v2(41.05,5.39) v2(41.05,4.81) v2(42.23,7.25) v2(42.86,7.25) v2(51.56,15.95) v2(52.16,15.95) v3(33.21,8.2)
CHG_UGATE: length 13.9
  TOP w0.14: v2(43,18.36) 42.88,18.23 42.88,17.52 v3(43.37,17.03)
  IN1 w1.016: 43.82,12.45 48.39,17.03 50.42,17.03 ; 42.61,13.66 42.61,17.47
  vias: v2(42.23,12.52) v2(42.42,18.36) v2(42.81,12.52) v2(51.56,16.61) v2(52.16,16.61)
CLINK_CLK: length 327.8
  IN1 w0.099: v2(316.2,9.41) 315.73,9.88 315.73,11.78 314.11,13.4 314.11,16.77 326.9,29.56 326.9,30.2 329.37,32.67 329.37,38.71 328.28,39.79 328.28,44.11 332.54,48.36 332.54,55.88 336.4,59.75 336.4,63.68 332.8,67.29 332.8,74.4 332.18,75.02 332.18,81.97 338,87.8 338,89.41 v2(338.8,90.21)
  IN5 w0.099: v2(102.9,5.32) 103.42,5.84 116.03,5.84 116.33,5.53 118.17,5.53 120.47,7.83 125.93,7.83 126.53,8.43 144.62,8.43 146.91,6.15 151.31,6.15 152.04,5.41 159.46,5.41 159.71,5.16 165.39,5.16 166.05,4.5 169.69,4.5 170.87,3.33 180.08,3.33 183.84,7.08 201.51,7.08 202.92,8.49 205.64,8.49 206.32,9.17 210.55,9.17 211.65,8.07 215.58,8.07 216.85,9.34 228.47,9.34 229.63,8.19 252.11,8.19 253.03,9.11 261.88,9.11 263.04,7.95 274.41,7.95 276.2,6.16 284.4,6.16 285.42,5.14 285.49,5.14 285.76,4.87 290.69,4.87 290.93,5.1 295.37,5.1 295.38,5.11 297.53,5.11 297.77,4.87 301.06,4.87 302.5,6.3 306.7,6.3 307.18,6.78 309.37,6.78 312.35,9.76 315.85,9.76 v2(316.2,9.41)
  BOTTOM w0.089: UH2.AV2 99.17,7.45 99.55,7.45 99.63,7.37 100.23,7.37 101.43,6.17 101.85,6.17 101.98,6.04
  BOTTOM w0.14: JNGFF1.34 v2(338.8,90.21) ; v2(102.9,5.32) 102.9,5.33 102.44,5.79 102.24,5.79 101.98,6.04
CLINK_DATA: length 328.3
  IN1 w0.099: v2(316.84,9.43) 316.84,11.24 314.51,13.57 314.51,16.58 327.3,29.37 327.3,29.97 329.77,32.44 329.77,42.12 331.34,43.7 331.34,46.89 332.74,48.28 332.74,55.8 336.6,59.67 336.6,63.77 333.21,67.16 333.21,82.72 338.81,88.32 v2(338.81,89.4)
  IN5 w0.099: v2(102.31,5.32) 103.05,6.06 116.1,6.06 116.42,5.73 118.09,5.73 120.39,8.03 125.84,8.03 126.45,8.63 144.71,8.63 146.99,6.35 158.81,6.35 159.79,5.36 165.48,5.36 166.14,4.7 169.77,4.7 170.95,3.53 180,3.53 183.76,7.28 191.84,7.28 193.44,8.88 195.63,8.88 196.53,9.79 203.62,9.79 203.97,10.14 214.71,10.14 215.05,9.79 233.12,9.79 234.32,8.59 251.75,8.59 252.67,9.51 262.17,9.51 263.3,8.38 274.56,8.38 276.38,6.56 284.63,6.56 285.88,5.32 290.55,5.32 291.87,6.63 297.1,6.63 297.57,6.16 297.57,5.63 297.89,5.32 300.94,5.32 302.33,6.71 306.4,6.71 309.7,10.02 316.26,10.02 v2(316.84,9.43)
  BOTTOM w0.089: UH2.AV3 98.61,7.58 98.91,7.27 99.47,7.27 99.56,7.19 100.15,7.19 101.44,5.9 101.78,5.9
  BOTTOM w0.127: v2(102.31,5.32) 102.31,5.37 101.78,5.9
  BOTTOM w0.14: v2(338.81,89.4) 338.3,89.91 JNGFF1.32
CLINK_RST#: length 328.8
  IN1 w0.099: v2(316.14,8.8) 315.53,9.41 315.53,11.7 313.91,13.32 313.91,16.86 326.68,29.62 326.68,30.27 329.16,32.75 329.16,38.62 328.08,39.71 328.08,44.19 332.33,48.45 332.33,55.97 336.2,59.83 336.2,63.6 332.59,67.21 332.59,74.32 331.98,74.94 331.98,82.06 337.8,87.88 v2(337.8,90.1)
  IN5 w0.089: 101.98,5.01 101.69,5.3 101.51,5.3 v2(101.49,5.32)
  IN5 w0.099: v2(316.14,8.8) 315.84,8.5 311.96,8.5 309.84,6.38 308.05,6.38 306.12,4.45 303.56,4.45 303.02,4.99 301.46,4.99 301.15,4.67 297.69,4.67 297.45,4.91 295.46,4.91 295.46,4.9 291.01,4.9 290.78,4.67 285.67,4.67 285.42,4.92 285.35,4.92 284.32,5.96 276.11,5.96 274.33,7.74 262.97,7.74 261.8,8.91 253.11,8.91 252.19,7.98 235.98,7.98 234.77,6.77 228.03,6.77 226.74,8.06 218.83,8.06 218.63,7.86 211.49,7.86 210.43,8.93 206.36,8.93 205.72,8.29 203.26,8.29 200.44,5.47 182.51,5.47 180.17,3.13 170.79,3.13 169.61,4.3 165.97,4.3 165.31,4.96 159.63,4.96 159.38,5.21 151.96,5.21 151.22,5.95 146.82,5.95 144.54,8.23 126.61,8.23 126.01,7.63 121.95,7.63 118.64,4.31 110.35,4.31 109.79,4.87 107.62,4.87 107.24,5.25 105.44,5.25 105.1,4.91 102.08,4.91 101.98,5.01
  BOTTOM w0.089: v2(101.49,5.32) 101.49,5.35 100.04,6.8 99.19,6.8 99,6.99 UH2.AW2
  BOTTOM w0.14: JNGFF1.30 v2(337.8,90.1)
CLK_PCI_MEC: length 225.7
  TOP w0.14: v2(306.9,18.31) 306.9,18.27 306.38,17.75 RE62.1 305.51,17.66 v1(305.47,17.62) 305.47,17.63 UE3.A29
  IN3 w0.091: v2(107.67,4.19) 107.84,4.02 108.63,4.02 109.3,3.36 111.1,3.36 111.44,3.01 117.19,3.01 122.34,8.17 135.03,8.17 135.75,8.89 144.79,8.89 148.54,5.14 150.38,5.14 150.56,4.96 152.32,4.96 152.43,4.85 156.32,4.85 156.49,4.69 162.09,4.69 162.63,5.22 171.32,5.22 171.77,4.77 174.31,4.77 175.19,5.66 176.84,5.66 178.08,4.42 180.04,4.42 180.7,3.76 182.1,3.76 182.53,4.18 184.8,4.18 185.22,3.76 203.68,3.76 207.15,7.23 210.29,7.23 211.62,5.9 234.35,5.9 235.63,7.18 242.66,7.18 244.28,5.56 256.29,5.56 258.6,7.87 267.2,7.87 267.68,7.39 271.47,7.39 274.67,10.6 275.8,10.6 282.33,17.13 282.33,17.95 282.54,18.17 282.54,18.82 283.83,20.1 293.4,20.1 294.91,21.61 296.74,21.61 297.2,21.15 298.96,21.15 299.9,20.2 299.9,18.43 300.34,17.99 301.55,17.99 301.8,18.24 303.9,18.24 304.31,17.84 306.43,17.84 v2(306.9,18.31)
  BOTTOM w0.14: RH168.2 105.88,4.53 106.33,4.08 107.56,4.08 v2(107.67,4.19) 108.16,4.19 CH198.1
CLK_PCIE_CR: length 272.1
  IN2 w0.107: v2(97.17,24.18) 97.34,24.01 97.34,23.84 97.68,23.5 99.37,23.5 99.94,24.07 99.94,24.79 100.3,25.16 102.05,25.16 103.44,26.55 103.44,28.52 104.38,29.46 134.13,29.46 137.22,26.36 143.82,26.36 146.51,23.67 147.64,23.67 148.16,23.15 148.16,20.47 148.63,20 152.41,20 152.59,19.81 154.41,19.81 156.17,18.06 156.3,18.06 157.14,17.22 157.14,16.7 157.97,15.86 180.26,15.86 180.73,15.39 216.01,15.39 216.41,14.99 231.17,14.99 231.35,15.17 244.35,15.17 245.17,14.35 252.25,14.35 252.77,14.87 256.97,14.87 258.11,16.01 260.34,16.01 261.89,17.57 264.94,17.57 265.16,17.79 267.57,17.79 268.73,16.63 278.97,16.63 279.29,16.95 281.49,16.95 284.05,19.51 290.22,19.51 290.83,20.12 292.65,20.12 295.3,22.76 297.2,22.76 297.64,23.2 304.15,23.2 304.84,23.88 311.24,23.88 313.53,26.17 317.29,26.17 322.68,31.55 323.52,31.55 324.54,32.57 326.51,32.57 v2(326.59,32.49)
  BOTTOM w0.089: v2(97.17,24.18) 97.17,23.76 UH2.E6
  BOTTOM w0.152: UR1.5 339.78,34.1 339.73,34.04 339.73,32.37 337.03,29.67 330.53,29.67 329.81,28.95 327.33,28.95 326.99,29.3 326.99,30.6 327.15,30.77 327.15,32.47 327.03,32.59 326.69,32.59 v2(326.59,32.49)
CLK_PCIE_CR#: length 272
  IN2 w0.107: v2(326.33,33.16) 326.33,32.9 326.2,32.77 324.45,32.77 323.43,31.76 322.59,31.76 317.21,26.37 313.44,26.37 311.16,24.09 304.75,24.09 304.07,23.4 297.55,23.4 297.12,22.97 295.21,22.97 292.57,20.32 290.74,20.32 290.13,19.71 283.97,19.71 281.41,17.15 279.21,17.15 278.89,16.83 268.81,16.83 267.65,17.99 265.07,17.99 264.85,17.77 261.81,17.77 260.25,16.21 258.03,16.21 256.88,15.07 252.68,15.07 252.16,14.55 245.26,14.55 244.43,15.38 231.27,15.38 231.09,15.2 216.49,15.2 216.1,15.59 180.82,15.59 180.34,16.07 158.06,16.07 157.34,16.78 157.34,17.31 156.39,18.26 156.26,18.26 154.5,20.02 152.67,20.02 152.49,20.2 148.72,20.2 148.36,20.56 148.36,23.24 147.73,23.87 146.6,23.87 143.9,26.56 137.31,26.56 134.21,29.66 104.3,29.66 103.24,28.6 103.24,26.64 101.96,25.36 100.22,25.36 99.73,24.88 99.73,24.15 99.29,23.71 97.76,23.71 97.54,23.92 97.54,24.24 97.63,24.33 97.76,24.33 v2(97.94,24.16)
  BOTTOM w0.101: v2(97.94,24.16) 97.94,24.24 UH2.D5
  BOTTOM w0.152: v2(326.33,33.16) 326.56,32.93 327.16,32.93 327.48,32.6 327.48,30.63 327.32,30.47 327.32,29.43 327.47,29.28 329.67,29.28 330.39,30 336.89,30 339.4,32.51 339.4,34.18 339.45,34.24 339.45,34.45 339.38,34.52 UR1.6
CLK_PCIE_SSD: length 181.4
  IN2 w0.107: v2(96.29,19.43) 96.01,19.71 96.01,19.84 96.14,19.96 97.8,19.96 97.97,19.8 101.68,19.8 102.71,18.76 107.22,18.76 108.17,19.71 128.99,19.71 130.49,18.22 146.73,18.22 146.92,18.03 151.68,18.03 152.18,17.53 153.97,17.53 154.67,16.83 154.67,16.49 156.71,14.45 179.22,14.45 180,13.67 185.07,13.67 185.12,13.73 214.83,13.73 215.22,13.34 231.07,13.34 231.55,12.86 243.49,12.86 244.06,12.29 254.71,12.29 255.06,12.64 257.71,12.64 258.21,13.14 259.6,13.14 260.74,14.28 262.47,14.28 262.71,14.53 262.71,14.79 v2(262.95,15.03)
  BOTTOM w0.089: UH2.R7 96.67,19.05 v2(96.29,19.43)
  BOTTOM w0.152: v2(262.95,15.03) 262.95,10.09 261.91,9.05 261.27,9.05 261.26,9.04 JNGFF2.55
CLK_PCIE_SSD#: length 181.3
  IN2 w0.107: v2(95.53,19.43) 95.81,19.72 95.81,19.92 96.05,20.16 97.89,20.16 98.05,20 101.76,20 102.79,18.97 107.14,18.97 108.09,19.92 129.08,19.92 130.57,18.42 146.81,18.42 147,18.23 151.76,18.23 152.26,17.74 154.05,17.74 154.87,16.92 154.87,16.57 156.79,14.65 179.31,14.65 180.08,13.88 184.98,13.88 185.04,13.94 214.91,13.94 215.31,13.54 231.16,13.54 231.63,13.06 243.57,13.06 244.15,12.49 254.63,12.49 254.97,12.84 257.62,12.84 258.13,13.34 259.52,13.34 260.66,14.49 262.38,14.49 262.51,14.61 262.51,14.94 262.42,15.03 v2(262.22,15.03)
  BOTTOM w0.089: v2(95.53,19.43) 95.91,19.05 UH2.R8
  BOTTOM w0.152: v2(262.22,15.03) 262.33,15.03 262.62,14.74 262.62,10.23 261.78,9.38 261.56,9.38 261.49,9.44 261.49,9.48 261.43,9.54 JNGFF2.53
CLK_PCIE_TBT: length 88.1
  IN1 w0.107: v2(96.28,24.6) 96.28,24.42 96.1,24.24 90.58,24.24 89.03,22.69 89.03,21.72 87.4,20.09 81.3,20.09 80.73,19.52 78.53,19.52 77.56,18.55 76.2,18.55 75.14,19.61 64.69,19.61 64.28,20.01 60.96,20.01 60.52,20.46 60.52,22.3 57.27,25.55 52.24,25.55 51.68,24.99 50.36,24.99 50.07,25.28 33.85,25.28 32.58,26.55 32.58,28.87 32.23,29.22 31.5,29.22 31.27,29.45 31.27,30.97 30.53,31.71 28.75,31.71 28.74,31.72 28.72,31.72 28.23,32.21 27.75,32.21 27.63,32.33 27.63,33.15 28.31,33.83 28.31,35.15 29.26,36.1 29.26,36.61 29.05,36.83 29.05,36.99 29.15,37.09 v2(29.31,37.09)
  BOTTOM w0.089: UH2.D7 96.52,24.37 v2(96.28,24.6)
  BOTTOM w0.102: v2(29.31,37.09) UT1.V19
CLK_PCIE_TBT#: length 88.2
  IN1 w0.107: v2(96.34,23.95) 96.26,24.04 90.67,24.04 89.23,22.6 89.23,21.64 87.49,19.89 81.39,19.89 80.81,19.31 78.61,19.31 77.65,18.35 76.11,18.35 75.06,19.4 64.6,19.4 64.2,19.81 60.87,19.81 60.31,20.37 60.31,22.21 57.18,25.35 52.32,25.35 51.76,24.79 50.27,24.79 49.98,25.08 33.76,25.08 32.37,26.47 32.37,28.79 32.15,29.01 31.42,29.01 31.06,29.36 31.06,30.89 30.45,31.5 28.67,31.5 28.66,31.52 28.64,31.52 28.15,32 27.67,32 27.42,32.25 27.42,33.23 28.11,33.91 28.11,35.23 29.06,36.19 29.06,36.53 28.84,36.74 28.84,36.91 v2(28.66,37.09)
  BOTTOM w0.089: v2(96.34,23.95) 96.13,24.16 UH2.D8
  BOTTOM w0.102: v2(28.66,37.09) UT1.T19
CLK_PCIE_WLAN: length 326.3
  IN2 w0.107: v2(339.93,86.37) 340.06,86.37 340.41,86.02 340.41,85.84 340.3,85.73 339.86,85.73 339.08,86.52 336.47,86.52 335.52,85.56 335.52,84.53 332.11,81.12 332.11,78.08 333.32,76.86 333.32,66.37 334.65,65.05 334.65,62.61 337,60.26 337,51.43 335.6,50.03 335.6,40.8 337.36,39.03 337.36,34.32 336.01,32.97 331.61,32.97 330.61,31.97 326.64,31.97 325.73,31.07 322.88,31.07 318.49,26.67 318.49,26.09 316.65,24.25 313.49,24.25 311.44,22.2 304.18,22.2 303.06,21.08 294.3,21.08 293.37,20.15 293.37,19.37 293.19,19.19 291.49,19.19 290.97,18.67 288.93,18.67 288.73,18.46 285.32,18.46 282.62,15.76 268.65,15.76 267.13,17.28 265.35,17.28 265.15,17.08 263.68,17.08 262.75,16.16 261.35,16.16 259.36,14.17 256.75,14.17 256.3,13.72 251.67,13.72 251.54,13.6 244.6,13.6 243.89,14.31 239.13,14.31 238.76,14.68 232.18,14.68 231.79,14.29 216.28,14.29 215.66,14.9 180.53,14.9 180.07,15.36 157.51,15.36 156.39,16.48 156.39,17.14 154.57,18.96 147.63,18.96 145.58,21.02 145.58,23.61 143.45,25.74 109.32,25.74 107.95,24.37 107.95,23.76 107.6,23.41 107.13,23.41 106.98,23.56 105.34,23.56 104.71,22.93 102.95,22.93 102.07,22.06 100.59,22.06 100.1,22.54 97.95,22.54 97.79,22.7 97.79,22.94 97.85,23.01 v2(98.29,23.01)
  BOTTOM w0.089: v2(98.29,23.01) 97.82,23.01 97.76,22.95 UH2.G4
  BOTTOM w0.152: JNGFF1.39 340.05,84.68 340.16,84.78 340.16,86.14 v2(339.93,86.37)
CLK_PCIE_WLAN#: length 326.4
  IN2 w0.107: v2(340.61,86.39) 340.61,85.76 340.39,85.53 339.78,85.53 338.99,86.32 336.56,86.32 335.72,85.48 335.72,84.45 332.31,81.04 332.31,78.16 333.53,76.95 333.53,66.45 334.85,65.13 334.85,62.69 337.2,60.35 337.2,51.34 335.8,49.94 335.8,40.88 337.57,39.12 337.57,34.24 336.09,32.76 331.69,32.76 330.7,31.77 326.72,31.77 325.81,30.86 322.96,30.86 318.69,26.59 318.69,26 316.74,24.05 313.58,24.05 311.52,22 304.27,22 303.14,20.87 294.39,20.87 293.57,20.06 293.57,19.29 293.27,18.98 291.58,18.98 291.06,18.46 289.02,18.46 288.81,18.26 285.41,18.26 282.71,15.55 268.56,15.55 267.04,17.08 265.43,17.08 265.23,16.88 263.76,16.88 262.84,15.95 261.44,15.95 259.45,13.97 256.83,13.97 256.39,13.52 251.75,13.52 251.63,13.39 244.51,13.39 243.8,14.11 239.04,14.11 238.67,14.48 232.27,14.48 231.87,14.08 216.2,14.08 215.58,14.7 180.45,14.7 179.99,15.16 157.42,15.16 156.19,16.4 156.19,17.06 154.48,18.76 147.55,18.76 145.38,20.93 145.38,23.52 143.36,25.54 109.41,25.54 108.15,24.28 108.15,23.67 107.69,23.21 107.04,23.21 106.89,23.36 105.43,23.36 104.8,22.73 103.03,22.73 102.16,21.85 100.5,21.85 100.02,22.34 97.87,22.34 97.58,22.62 97.58,22.81 v2(97.38,23.01)
  BOTTOM w0.089: UH2.E5 97.61,23.24 v2(97.38,23.01)
  BOTTOM w0.152: JNGFF1.41 340.55,84.67 340.49,84.73 340.49,86.27 v2(340.61,86.39)
CLK_PEG_VGA: length 143.3
  IN6 w0.107: v2(96.34,18.68) 96.5,18.83 96.5,19.04 97.5,20.05 101.85,20.05 102.94,18.96 133.26,18.96 133.74,18.48 150.85,18.48 151.57,19.21 177.15,19.21 178.35,20.41 178.35,24.5 180.36,26.51 180.36,31.71 194.29,45.64 194.29,58.33 193.1,59.51 193.1,65.35 196.03,68.27 197.31,68.27 v2(197.45,68.42)
  BOTTOM w0.089: UH2.U7 96.34,18.24 v2(96.34,18.68)
  BOTTOM w0.102: v2(197.45,68.42) 197.09,68.05 UV18.AL13
CLK_PEG_VGA#: length 143.2
  IN6 w0.107: v2(96.95,18.64) 96.88,18.64 96.7,18.82 96.7,18.96 97.59,19.85 101.77,19.85 102.85,18.76 133.17,18.76 133.65,18.28 150.93,18.28 151.66,19.01 177.23,19.01 178.55,20.32 178.55,24.41 180.57,26.43 180.57,31.63 194.49,45.55 194.49,58.41 193.31,59.59 193.31,65.27 196.11,68.07 197.02,68.07 v2(197.44,67.65)
  BOTTOM w0.089: UH2.U5 96.96,18.38 96.96,18.63 v2(96.95,18.64)
  BOTTOM w0.102: UV18.AK13 v2(197.44,67.65)
CLK_REQ: length 25.6
  TOP w0.14: v2(198.24,65.92) 197.79,65.48 195.9,65.48 194.51,64.09 193.13,64.09 191.88,62.84 v1(191.88,62.11) 191.88,59.01 194.04,56.84 197.04,56.84 198.57,55.32 RV591.2 198.57,51.64 QV103.3
  BOTTOM w0.102: v2(198.24,65.92) 198.24,66.64 197.84,67.04 UV18.AK12
CLK_TP_SIO: length 150
  TOP w0.14: RE24.2 301.88,22.93 v2(301.58,22.63) 301.58,22.49 300.97,21.88 300.97,21.25 300.77,21.06 UE3.A37 ; CE77.1 186.67,5.68 188.85,3.5 198.63,3.5 201.68,6.55 201.68,8.27 201.14,8.8 199.61,8.8 v2(199.26,9.15)
  IN3 w0.091: v2(199.26,9.15) 202.09,11.98 213.74,11.98 216.29,9.43 228.66,9.43 230.47,11.24 242.21,11.24 242.75,11.78 252.32,11.78 254.37,13.83 259.44,13.83 259.6,14 266.1,14 268.81,16.71 271.45,16.71 273.52,18.78 277.55,18.78 277.88,19.11 279.6,19.11 282.22,21.73 291.07,21.73 292.78,23.45 300.76,23.45 v2(301.58,22.63)
  BOTTOM w0.14: JTP.1 193,10.12 193.14,9.98 193.41,9.98 194.31,10.87 194.31,12.2 195.25,13.14 198.13,13.14 198.66,12.61 198.66,11.94 199.63,10.96 199.63,10.51 199.87,10.27 DE4.2 199.34,9.15 v2(199.26,9.15)
