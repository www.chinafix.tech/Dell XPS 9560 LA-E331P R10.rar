# Allegro board Dell XPS 9560 LA-E331P R10.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
REM_DIODE1_P: length 453.2
  TOP w0.089: CE69.2 158.89,71.73 158.89,71.05 159.01,70.93 QE15.2 159.32,70.76 v2(158.67,70.11) QE15.1
  TOP w0.127: v2(301.32,9.18) 301.27,9.23 UE3.A13 ; v2(303.76,8.14) 303.76,7.48 CE32.2 ; v2(263.12,23.38) v3(263.12,24.08)
  IN2 w0.127: v2(263.12,23.38) 262.95,23.21 261.04,23.21 257.66,26.59 255.16,26.59 254.08,27.67 254.08,39.04 255.94,40.9 255.94,48.03 252.88,51.09 252.88,53.67 251.59,54.96 251.59,96.79 249.28,99.11 249.28,110.22 246.72,112.77 243.68,112.77 242.93,113.52 239.84,113.52 238.4,112.09 231.05,112.09 230.36,112.52 228.27,112.52 225.9,114.9 225.9,115.24 226.39,115.74 226.39,118.98 226.86,119.45 226.86,120.26 226.3,120.82 174.4,120.82 173.03,119.45 171.19,119.45 170.24,118.5 167.94,118.5 166.45,119.99 165.71,119.99 165.29,120.41 128.31,120.41 123.38,115.48 117.7,115.48 117.35,115.83 117.35,115.99 v2(117.44,116.08)
  IN3 w0.089: 177.63,55.71 173.06,60.28 173.06,62.73 172.52,63.28 171.81,63.28 171.47,62.93 168.69,62.93 167.66,63.96 167.66,64.77 167.29,65.15 167.29,66.81 166.76,67.34 161.2,67.34 160.65,67.89 159.5,67.89 158.67,68.72 v2(158.67,70.11)
  IN3 w0.127: v2(301.32,9.18) 301.32,10.27 301.56,10.52 302.51,10.52 303.76,9.26 v2(303.76,8.14) ; 177.63,55.71 182.03,51.31 194.06,51.31 194.23,51.48 201.7,51.48 202.08,51.86 204.42,51.86 205.29,51 207.94,51 208.58,50.36 212.96,50.36 214.35,48.97 214.35,48.21 215.82,46.74 218.26,46.74 232.78,32.23 252.09,32.23 252.62,31.7 253.03,31.7 258.73,25.99 258.94,25.99 261.77,23.16 262.9,23.16 v2(263.12,23.38)
  BOTTOM w0.127: QE7.3 114.37,110.97 CE45.2 115.61,111.27 116.24,111.27 116.69,111.73 116.69,113.77 117.27,114.36 117.27,115.91 v2(117.44,116.08) ; v2(303.76,8.14) 303.76,7.22 303.58,7.04 303.35,7.04 303.07,6.77 303.07,4.13 301.84,2.89 280.22,2.89 277.41,5.7 277.41,16.76 276.19,17.98 276.19,18.52 274.84,19.86 274.84,22.28 273.55,23.57 267.35,23.57 266.21,22.43 264.34,22.43 263.53,23.24 263.26,23.24 v2(263.12,23.38)
REM_DIODE2_N: length 286.6
  TOP w0.127: v2(260.97,6.77) 260.83,6.91 260.83,7.73 262.15,9.05 262.15,11.78 262.32,11.95 262.32,13.53 260.67,15.19 260.67,22.96 259.53,24.1 259.53,27.55 259.08,27.99 259.08,30.53 249.92,39.7 233.03,39.7 232.2,40.52 197.18,40.52 193.49,44.22 193.49,54.49 191.2,56.78 191.2,57.41 183.9,64.71 183.9,65.47 183.36,66.01 183.36,68.21 183.08,68.49 181.24,70.34 181.24,74.54 CE47.2 181.55,75.84 QE6.3 181.68,76.57 185.04,79.93 185.04,84.65 186.06,85.67 187.45,85.67 190.31,88.53 190.31,88.74 193.05,91.48 193.05,93.53 v2(193.31,93.79) ; UE3.B14 v2(301.52,11.47) ; v2(304.83,5.7) 304.67,5.85 CE33.1
  IN1 w0.127: v2(301.52,11.47) 301.52,10.92 301.97,10.48 304.13,10.48 306.3,8.31 306.3,7.28 305.86,6.84 304.94,6.84 304.67,6.57 304.67,5.85 v2(304.83,5.7)
  IN3 w0.127: v2(304.83,5.7) 304.78,5.75 304.78,6.37 305.26,6.85 305.84,6.85 306.17,6.52 306.17,5 305.03,3.85 303.26,3.85 302.3,2.89 293.41,2.89 293.07,3.23 293.07,4.03 292.71,4.39 282.27,4.39 281.01,5.65 260.99,5.65 260.8,5.84 260.8,6.6 v2(260.97,6.77)
  IN6 w0.127: v2(193.31,93.79) 193.05,93.53 193.05,93.3 193.17,93.17 194.27,93.17 201.23,100.13 201.23,107.66 198.89,110.01 198.89,110.68 196.79,112.78 196.79,119.07 196.98,119.26 196.98,119.77 196.65,120.1 177.76,120.1 173.67,116.01 173.67,115.64 173.81,115.51 173.99,115.51 v2(174.25,115.77)
  BOTTOM w0.127: QE5.1 173.6,118.33 QE5.2 173.75,117.18 173.75,116.87 CE46.2 173.86,116.31 173.86,115.88 173.97,115.77 v2(174.25,115.77)
REM_DIODE2_P: length 288.8
  TOP w0.127: v2(304.61,8.15) 304.61,7.45 CE33.2 ; UE3.A14 301.77,9.31 v2(301.96,9.13) ; v2(192.53,93.79) 192.79,93.53 192.79,91.58 190.05,88.85 190.05,88.63 187.35,85.92 185.95,85.92 184.79,84.76 184.79,80.04 182.32,77.57 QE6.1 180.7,77.57 180.38,77.25 QE6.2 180.63,75.72 CE47.1 180.98,74.51 180.98,70.23 183.11,68.1 183.11,65.9 183.65,65.36 183.65,64.6 190.95,57.31 190.95,56.67 193.23,54.39 193.23,44.12 197.08,40.27 232.1,40.27 232.92,39.44 249.81,39.44 258.83,30.43 258.83,27.89 259.27,27.44 259.27,24 260.41,22.86 260.41,15.08 262.07,13.43 262.07,12.05 261.9,11.88 261.9,9.16 260.57,7.83 260.57,6.97 v2(260.36,6.77)
  IN1 w0.127: v2(304.61,8.15) 304.61,7.37 304.89,7.1 305.75,7.1 306.05,7.39 306.05,8.2 304.03,10.22 302.12,10.22 301.96,10.06 v2(301.96,9.13)
  IN3 w0.127: v2(260.36,6.77) 260.54,6.59 260.54,5.73 260.88,5.39 280.9,5.39 282.16,4.13 292.61,4.13 292.81,3.93 292.81,3.13 293.3,2.64 302.41,2.64 303.37,3.6 305.13,3.6 306.43,4.89 306.43,6.63 305.95,7.11 305.26,7.11 304.61,7.76 v2(304.61,8.15)
  IN6 w0.127: v2(174.25,115.13) 174.12,115.26 173.7,115.26 173.42,115.54 173.42,116.12 177.65,120.35 196.76,120.35 197.23,119.88 197.23,119.16 197.04,118.97 197.04,112.89 199.14,110.79 199.14,110.11 201.49,107.77 201.49,100.02 194.38,92.91 193.07,92.91 192.79,93.19 192.79,93.53 v2(192.53,93.79)
  BOTTOM w0.127: v2(174.25,115.13) 173.6,115.78 173.6,116.1 CE46.1 173.49,116.86 173.49,117.14 QE5.3
REM_DIODE3_N: length 361.4
  TOP w0.127: v2(305.25,8.07) 305.25,7.7 CE35.1 ; UE3.A15 302.27,9.43 v2(302.83,8.88) ; QE11.3 27.95,52.34 CE68.2 27.63,51.12 27.63,50.94 28.08,50.49 28.89,50.49 29.5,51.09 v2(29.5,51.41)
  IN1 w0.127: v2(94.37,38.31) 94.17,38.11 92.53,38.11 91.81,37.38 87.18,37.38 84.38,34.59 84.38,34.58 84.35,34.55 81.33,34.55 80.25,33.47 76.21,33.47 75.19,32.46 70.95,32.46 67.77,29.28 41.07,29.28 38.93,31.42 38.93,37.98 35.88,41.03 35.88,43.25 35.18,43.95 35.18,44.95 34.42,45.71 34.42,45.9 33.73,46.58 33.73,47.09 33.34,47.49 33.34,48.75 30.4,51.69 29.92,51.69 29.65,51.41 v2(29.5,51.41)
  IN2 w0.127: v2(94.37,38.31) 94.54,38.15 94.98,38.15 97.91,41.08 112.49,41.08 117.14,36.43 118.02,36.43 118.45,36 v2(118.9,36)
  IN3 w0.127: v2(264.33,23.36) 264.15,23.54 263.87,23.54 262.14,25.27 261.18,25.27 253.12,33.33 233.18,33.33 225.56,40.94 224.96,40.94 223.93,41.98 223.93,42.58 221.93,44.57 221.93,48.67 220.13,50.48 215.09,50.48 214.57,51 208.87,51 208.22,51.65 205.72,51.65 204.86,52.5 201.27,52.5 201.11,52.34 194.2,52.34 193.93,52.08 190.48,52.08 190.22,52.34 190.22,52.71 v2(190.07,52.86)
  BOTTOM w0.127: v2(264.33,23.36) 264.5,23.54 264.76,23.54 265.59,24.37 273.7,24.37 275.51,22.56 275.51,20.56 277.81,18.25 277.81,17.52 278.3,17.04 278.3,7.09 281.45,3.94 300.22,3.94 302.4,6.12 302.4,8.45 v2(302.83,8.88) 303.4,9.46 305.2,9.46 305.74,8.92 305.74,7.3 305.61,7.17 305.46,7.17 305.25,7.38 v2(305.25,8.07) ; v2(190.07,52.86) 190.23,52.7 190.23,52.49 187.44,49.69 180.52,49.69 CE49.2 179.2,48.98 QE8.1 179.2,48.47 179.38,48.29 180.36,48.29 180.77,47.88 180.77,46.44 180.59,46.26 179.63,46.26 179.48,46.41 179.48,46.67 QE8.2 179.84,47.05 179.27,47.05 179.17,47.15 179.17,47.82 178.87,48.12 178.26,48.12 177.62,47.48 177.62,44.7 170.71,37.79 123.44,37.79 121.44,35.79 119.04,35.79 118.9,35.93 v2(118.9,36)
REM_DIODE3_P: length 366.4
  TOP w0.127: v2(302.55,11.44) 302.52,11.41 UE3.B16 ; v2(305.63,5.78) 305.56,5.85 CE35.2 ; v2(29.91,51) 29.75,51 29.75,50.99 29,50.24 27.98,50.24 27.38,50.84 27.38,51.11 CE68.1 27.04,52.4 26.98,52.46 QE11.2 26.53,53.41 QE11.1
  IN1 w0.127: v2(29.91,51) 29.91,51.32 30.03,51.44 30.29,51.44 33.08,48.65 33.08,47.38 33.48,46.99 33.48,46.48 34.16,45.79 34.16,45.6 34.93,44.84 34.93,43.85 35.62,43.15 35.62,40.92 38.67,37.88 38.67,31.31 40.96,29.02 67.88,29.02 71.06,32.2 75.3,32.2 76.32,33.22 80.36,33.22 81.44,34.3 84.46,34.3 84.63,34.48 84.63,34.48 87.28,37.13 91.91,37.13 92.64,37.85 94.25,37.85 v2(94.37,37.73)
  IN2 w0.127: v2(118.36,35.45) 118.36,35.73 117.91,36.18 117.03,36.18 112.38,40.83 98.02,40.83 95.09,37.89 94.54,37.89 v2(94.37,37.73)
  IN3 w0.127: v2(264.33,23.95) 264.17,23.8 263.97,23.8 262.24,25.52 261.28,25.52 253.22,33.58 233.28,33.58 225.67,41.2 225.07,41.2 224.18,42.08 224.18,42.68 222.19,44.68 222.19,48.78 220.23,50.73 215.19,50.73 214.67,51.25 208.97,51.25 208.32,51.9 205.82,51.9 204.97,52.75 201.16,52.75 201.01,52.6 194.09,52.6 193.83,52.33 190.59,52.33 190.48,52.45 190.48,52.69 v2(190.65,52.86)
  BOTTOM w0.127: v2(305.63,5.78) 305.31,6.1 305.31,6.71 305.51,6.92 305.72,6.92 305.99,7.19 305.99,9.03 305.31,9.71 303.31,9.71 302.88,10.14 302.88,11.11 v2(302.55,11.44) 302.06,10.94 302.06,9.86 302.4,9.52 302.4,8.85 302.15,8.59 302.15,6.23 300.11,4.19 281.55,4.19 278.55,7.19 278.55,17.14 278.07,17.63 278.07,18.36 275.77,20.66 275.77,22.66 273.81,24.62 265.48,24.62 264.67,23.81 264.47,23.81 v2(264.33,23.95) ; v2(190.65,52.86) 190.49,52.7 190.49,52.38 187.54,49.44 180.57,49.44 CE49.1 180.21,48.8 181.03,47.99 181.03,46.34 180.7,46.01 179.45,46.01 178.55,46.91 QE8.3 178.92,47.41 178.92,47.71 178.77,47.86 178.36,47.86 177.88,47.38 177.88,44.59 170.82,37.54 123.54,37.54 121.56,35.55 118.46,35.55 v2(118.36,35.45)
REM_DIODE4_N: length 200.6
  TOP w0.127: v2(312.74,32.43) 312.94,32.23 313.18,32.23 315.44,29.97 316.21,29.97 318.03,28.15 318.03,25.23 315.58,22.79 v5(315.58,21) 315.58,19.43 312.69,16.54 312.69,9.06 309.99,6.36 308,6.36 307.49,6.87 307.35,6.87 CE36.1 306.69,6.87 306.47,6.87 306.2,7.14 306.2,8.02 305.22,9 304.26,9 303.01,10.25 302.9,10.25 302.77,10.12 UE3.A16
  IN2 w0.127: v2(278.99,24.68) 279.16,24.85 279.16,25.09 279.44,25.38 282.97,25.38 284.21,24.14 288.25,24.14 288.92,24.81 290.07,24.81 292.4,27.14 293.2,27.14 296.28,30.22 299.48,30.22 299.68,30.43 303.04,30.43 304.58,31.96 308.77,31.96 309.08,32.27 312.57,32.27 v2(312.74,32.43)
  IN3 w0.127: v2(243.21,101.16) 243.02,100.97 243.02,100.21 245.82,97.41 249.37,97.41 251.65,95.12 251.65,63.76 251.14,63.25 251.14,57.22 251.08,57.16 251.08,54.4 249.25,52.57 249.25,40.32 261.62,27.95 263.71,27.95 265.49,26.17 276.2,26.17 277.96,24.42 278.74,24.42 278.99,24.67 v2(278.99,24.68)
  BOTTOM w0.127: QE12.1 281.43,27.16 QE12.2 281.59,26.02 281.59,25.71 CE50.1 281.56,25.08 281.56,24.54 280.93,23.91 279.44,23.91 279.17,24.19 279.17,24.5 v2(278.99,24.68) ; QE9.3 241.76,106.84 242.27,106.33 CE72.1 241.81,105.85 241.81,102.88 243.04,101.65 243.04,101.33 v2(243.21,101.16)
REM_DIODE4_P: length 197.6
  TOP w0.127: v2(312.74,31.85) 312.87,31.97 313.08,31.97 315.34,29.71 316.1,29.71 317.77,28.04 317.77,25.34 315.33,22.89 315.33,19.54 312.43,16.64 312.43,9.16 309.88,6.62 308.11,6.62 307.6,7.12 307.35,7.12 CE36.2 306.69,7.12 306.58,7.12 306.45,7.25 306.45,8.13 305.32,9.25 304.37,9.25 303.02,10.6 UE3.B17
  IN2 w0.127: v2(279.57,24.69) 279.41,24.86 279.41,24.99 279.55,25.12 282.86,25.12 284.1,23.88 288.35,23.88 289.03,24.56 290.17,24.56 292.5,26.89 293.31,26.89 296.39,29.97 299.58,29.97 299.78,30.17 303.15,30.17 304.69,31.71 308.88,31.71 309.18,32.01 312.57,32.01 v2(312.74,31.85)
  IN3 w0.127: v2(279.57,24.69) 279.57,24.67 279.07,24.16 277.85,24.16 276.1,25.92 265.39,25.92 263.61,27.7 261.51,27.7 249,40.21 249,52.68 250.83,54.51 250.83,57.26 250.89,57.33 250.89,63.36 251.4,63.87 251.4,95.01 249.26,97.15 245.72,97.15 242.76,100.11 242.76,101.08 242.68,101.16 v2(242.62,101.16)
  BOTTOM w0.127: QE9.2 241.11,108.32 QE9.1 241.11,107.36 241.35,107.12 CE72.2 241.56,106.1 241.56,102.77 242.79,101.54 242.79,101.33 v2(242.62,101.16) ; v2(279.57,24.69) 279.42,24.54 279.42,24.29 279.55,24.17 280.83,24.17 281.31,24.65 281.31,25.08 CE50.2 281.33,25.76 281.33,25.97 QE12.3
RESET_OUT#: length 403.1
  TOP w0.127: v2(101.51,4.56) 101.09,4.97 101.09,5.6 101.44,5.94 103.52,5.94 105.02,7.44 105.02,7.64 105.45,8.07 105.45,8.94 105.44,8.96 105.44,10.02 106.48,11.06 111.59,11.06 113.14,12.61 113.14,15.93 112.52,16.55 112.52,16.74 112.05,17.22 109.34,17.22 108.79,17.77 105.71,17.77 105.54,17.93 105.46,17.93 102.79,20.61 102.24,20.61 101.45,21.39 101.15,21.39 101.04,21.5 101.04,21.5 99.77,22.77 99.7,22.85 99.7,24.81 98.93,25.58 98.93,27.36 101.94,30.37 105.9,30.37 115.67,40.15 v3(115.67,42.77) 115.67,46.35 v2(115.25,46.77)
  TOP w0.14: v2(302.52,24.91) 301.88,25.55 RE33.2 ; UE3.B39 301.02,19.69 300.87,19.54 300.87,19.15 v2(300.35,18.63)
  IN2 w0.089: v2(101.51,4.56) 101.98,4.56
  IN2 w0.099: v2(315.07,7.29) 314.61,6.83 313.74,6.83 311.11,4.2 310.49,4.2 309.85,3.56 306.82,3.56 306.08,2.82 303.29,2.82 302.72,3.39 301.17,3.39 300.6,2.82 269.38,2.82 267.54,4.66 263.12,4.66 262.02,3.55 251.75,3.55 250.78,4.53 247.2,4.53 244.19,1.52 239.57,1.52 239.4,1.69 239.4,1.69 239.04,2.04 239.04,2.05 237.85,3.24 226.46,3.24 225.79,3.92 213.98,3.92 211.72,1.66 206.38,1.66 205.47,2.57 169.97,2.57 168.9,3.64 168.4,3.64 167.53,2.77 151.65,2.77 149.08,5.34 147.47,5.34 144.9,7.92 136.42,7.92 135.48,6.98 126.49,6.98 126.22,6.71 121.09,6.71 116.1,1.72 109.43,1.72 108.61,2.54 106.96,2.54 104.94,4.56 101.98,4.56
  IN3 w0.091: v2(302.52,24.91) 302.99,24.44 307.04,24.44 308.27,25.66 309.96,25.66 310.1,25.52 310.78,25.52 311.86,24.44 314.56,24.44 315.04,23.95 315.04,22.7 314.94,22.6 314.94,12.83 315.67,12.1 315.67,11.38 315.65,11.35 315.65,7.87 v2(315.07,7.29)
  IN4 w0.091: v2(125.31,92.99) 124.92,93.38 124.49,93.38 124.26,93.15 124.26,93.13 123.88,92.74 123.85,92.74 123.6,92.49 123.6,92.46 123.22,92.08 123.19,92.08 123.19,87 124.78,85.42 124.78,71.32 121.83,68.36 121.83,67.08 119.82,65.07 119.69,65.07 117.73,63.11 117.73,54.94 117.62,54.83 117.62,52.68 117.16,52.22 117.16,48.68 v2(115.25,46.77) ; v2(300.35,18.63) 300.79,19.07 300.79,20.36 302.03,21.6 302.03,24.43 v2(302.52,24.91)
  BOTTOM w0.089: UH2.AY1 100.09,6.47 101.09,5.47 101.09,4.97 v2(101.51,4.56)
  BOTTOM w0.14: RH490.1 127.27,93.38 125.71,93.38 v2(125.31,92.99) ; RH91.2 105.14,3.91 105.04,3.91 104.29,4.66 101.62,4.66 v2(101.51,4.56)
RING2: length 20.7
  IN1 w1.27: 13.73,57.51 13.86,57.39 13.86,53.31 15.08,52.09 15.08,47.22 12.58,44.72 11.65,44.72 11.09,45.28 8.76,45.28
  BOTTOM w0.127: v1(13.23,56.03) 12.73,56.03 12.35,56.41 12.35,57.26 v2(12.57,57.49)
  vias: v2(8.64,44.24) v2(8.64,43.66) v2(12,57.69)
RING2_L:
  vias: v3(8.68,58.43)
ROM_CS: length 1.2
  TOP w0.14: v2(216.67,61.66) 216.98,61.35 T205.1
  BOTTOM w0.102: v2(216.67,61.66) 216.24,62.09 UV18.H6
ROM_SCLK: length 21.5
  TOP w0.14: v2(230,50.62) RV644.2 230.01,51.3 RV641.1
  IN5 w0.099: v2(230,50.62) 229.44,51.19 227.22,51.19 226.2,52.21 221.1,52.21 217.04,56.28 217.04,58.49 217.1,58.55 217.1,59.63 v2(216.66,60.07)
  BOTTOM w0.102: UV18.H4 216.24,60.49 v2(216.66,60.07)
ROM_SI: length 15.8
  TOP w0.14: v2(216.69,60.91) 217.91,59.69 217.91,59.12 218.16,58.87 219.23,58.87 v1(223.45,54.66) 224.92,53.19 224.92,51.82 RV642.2 RV639.1
  BOTTOM w0.102: UV18.H5 216.3,61.3 v2(216.69,60.91)
ROM_SO: length 20.6
  TOP w0.14: v2(215.85,63.43) 216.23,63.05 216.23,62.4 216.49,62.15 218.17,62.15 218.19,62.16 219.37,62.16 v1(219.99,61.54) 221.25,60.28 221.25,58.32 221.55,58.03 222.3,58.03 225.93,54.4 225.93,51.82 RV643.2 RV640.1
  BOTTOM w0.102: UV18.H7 215.85,63.39 v2(215.85,63.43)
RREF: length 2.4
  BOTTOM w0.203: UR1.9 337.6,35.69 337.48,35.58 337.48,35.23
  BOTTOM w0.305: 337.48,35.23 337.48,34.28 337.5,34.26 RR6.2
RTCRST_ON: length 5.8
  TOP w0.14: UE4.2 276.58,10.52 275.53,9.47 274.96,9.47 v1(274.51,9.91) 273.76,9.91 RE143.2 QR104.2
RTD3_CIO_PWR_EN: length 133.4
  TOP w0.089: v3(80.28,18.51) 80.26,18.53 v2(79.68,18.53)
  IN5 w0.099: v2(36.65,32.2) 36.65,35.64 36.96,35.95 36.96,37.75 32.32,42.39 32.32,43.82 31.37,44.78 31.37,50.3 29.13,52.54 29.13,56.56 28.09,57.6 28.09,66.7 26.02,68.77 26.02,73.25 25.38,73.89 25.38,79.2 26.75,80.57 26.75,82.41 28.58,84.25 28.58,93.6 28.13,94.05 28.13,98.88 27.43,99.58 27.43,101.44 v2(26.7,102.18)
  IN6 w0.099: v2(79.68,18.53) 78.77,19.44 75.22,19.44 72.03,22.63 65.93,22.63 61.44,27.12 58.01,27.12 56.73,28.4 50.67,28.4 48.99,30.09 45.32,30.09 43.2,32.2 v2(36.65,32.2)
  BOTTOM w0.089: UH2.R39 80.41,19 79.99,18.58 79.73,18.58 v2(79.68,18.53)
  BOTTOM w0.14: v2(26.7,102.18) 25.02,102.18 24.48,101.64 23.85,101.64 23.5,101.29 23.5,100.47 23.72,100.24 RT39.2 23.88,100.08 24.37,99.59 QT20.4
RTD3_CIO_PWR_EN_AR: length 57.9
  TOP w0.14: v2(23.85,96.22) 24.45,96.22 v1(24.65,96.43)
  IN5 w0.099: v2(23.85,96.22) 24.43,96.22 25.14,95.51 25.14,91.98 24.52,91.36 24.52,84.09 22.79,82.36 22.79,68.97 23.96,67.81 23.96,65.71 24.22,65.44 24.22,65.13 25.29,64.06 25.29,61.45 25.87,60.87 25.87,58.6 26.59,57.88 26.59,52.61 25.31,51.33 25.31,50.26 24.08,49.03 24.08,47.84 24.67,47.25 v2(24.67,46.43)
  BOTTOM w0.089: v2(24.67,46.43) 24.67,46.34 24.27,45.94 UT1.F1
  BOTTOM w0.14: QT20.3 24.37,96.2 RT436.2 23.89,96.19 v2(23.85,96.22)
RTD3_USB_PWR_EN: length 12.7
  TOP w0.14: v1(21.5,34.38) 21.09,33.96 v2(21.08,33.96) 20.72,33.6 RT40.2
  IN3 w0.089: v4(22.85,44.25) 22.63,44.03 22.63,42.2 21.75,41.31 21.75,34.63 21.42,34.3
  IN3 w0.091: v2(21.08,33.96) 21.42,34.3
  BOTTOM w0.089: v4(22.85,44.25) 22.85,44.27 23.13,44.56 UT1.D4
RUN_ON: length 25.8
  TOP w0.14: RE37.2 302.88,26.5 303.15,26.23 303.68,26.23 v2(304.24,26.79) 304.53,26.79 v1(304.8,27.06) ; v2(299.51,12.25) 299.02,11.77 UE3.B9
  BOTTOM w0.14: v2(304.24,26.79) 304.82,26.22 306.12,26.22 306.97,25.36 306.97,19.22 306.46,18.72 306.46,18.17 306.2,17.91 304.84,17.91 303.09,16.16 300.92,16.16 300.14,15.39 300.14,12.89 v2(299.51,12.25)
RUN_ON#: length 4
  TOP w0.14: 311.02,13.47 RE56.2 311.02,12.33 v1(311.72,11.63) ; 311.02,13.47 311.43,13.47 311.67,13.71 QE4.6 ; 311.02,13.47 QE4.5
RUN_ON_EC: length 200.5
  TOP w0.127: v2(240.64,2.32) 240.64,2.63 241.19,3.17 UZ7.3
  TOP w0.14: RZ76.1 239.95,1.63 v2(240.64,2.32) ; UZ20.1 180.17,6.44 v2(180.15,6.42) ; RE35.1 303.28,24.77 302.77,25.28 RE37.1 303.73,25.59 304.51,26.36 305.06,26.36 v2(305.33,26.64) 307.09,26.64 307.62,26.11 309.62,26.11 310.22,25.51 311.47,25.51 312.94,24.04 v1(312.94,22.4) 314.29,21.05 314.29,19.4 311.76,16.87 v2(311.54,16.87) 311.02,16.35 QE4.2 ; UZ1.3 315.86,34.21 316.23,34.58 316.23,35.06 316.04,35.25 315.38,35.25 v2(315.14,35.01) UZ1.5
  IN6 w0.099: v2(180.15,6.42) 180.51,6.78 202.16,6.78 203.16,7.78 205.54,7.78 206.16,8.4 210.44,8.4 214.22,4.62 227.09,4.62 227.63,4.07 239.46,4.07 240.51,3.03 240.51,2.45 v2(240.64,2.32) 240.87,2.55 240.87,2.84 241.33,3.29 243.1,3.29 243.8,3.99 244.93,3.99 245.73,4.79 258,4.79 258.77,4.03 262.08,4.03 263.62,5.57 266.93,5.57 268.4,4.1 270.41,4.1 270.96,4.65 272.39,4.65 274.02,3.02 295.04,3.02 295.96,3.95 301.82,3.95 301.86,3.91 304.28,3.91 304.63,4.26 306.45,4.26 308.06,5.88 309.98,5.88 v2(310.62,5.24)
  BOTTOM w0.14: v2(310.62,5.24) 311.58,6.21 311.58,11.17 311.14,11.61 311.14,16.47 v2(311.54,16.87) ; v2(305.33,26.64) 305.33,29.42 304.57,30.18 304.57,31.31 305.83,32.57 307.75,32.57 310.64,35.47 312.89,35.47 313.28,35.07 RZ43.2 315.08,35.07 v2(315.14,35.01)
RUN_ON_P: length 324
  TOP w0.14: UZ11.4 178.7,6.98 177.82,6.98 177.33,6.5 RZ58.2 176.96,8.05 175.96,9.06 175.96,14.3 178.33,16.67 178.33,19.62 178.03,19.92 178.03,24.86 v2(178.19,25.03) ; v2(293.54,30.95) 293.29,30.7 293.06,30.7 292.75,30.39 PR610.2 ; RZ90.1 132.39,64.62 132.26,64.49 v2(130.27,64.49) 130.11,64.33 125.33,64.33 123.36,62.36 118.97,62.36 115.91,65.43 v3(115.57,65.43)
  TOP w0.254: v3(115.57,65.43) v2(110.57,65.43) RZ50.1
  IN2 w0.099: v2(183.33,63) 183.77,63 185,64.23 186.92,64.23 187.83,63.32 190.21,63.32 v2(190.65,63.76) ; v2(250.7,21.22) 251.7,21.22 252.2,20.72 253.06,20.72 254.49,22.14 257.29,22.14 258.43,23.29 259.44,23.29 260.58,22.16 263.2,22.16 263.6,22.56 264.19,22.56 264.41,22.33 267.24,22.33 268.41,23.5 274.88,23.5 278.69,27.31 281.81,27.31 282.35,26.78 286.48,26.78 287.16,26.1 289.25,26.1 292.97,29.82 292.97,30.38 v2(293.54,30.95)
  IN5 w0.099: v2(178.19,25.03) 178.42,25.03 181.43,28.03 184.56,28.03 186.17,29.64 223.79,29.64 227.43,25.99 248.22,25.99 249.85,24.36 249.85,22.07 v2(250.7,21.22)
  IN6 w0.089: 181.1,63 180.06,63 177.47,65.59 177.47,67.75 176.41,68.81 175.66,68.81 174.87,69.6 174.36,69.6 174.15,69.8 164.02,69.8 163.79,69.57 161.05,69.57 159.98,70.65 156.08,70.65 155.17,69.74 151.69,69.74 150.14,71.29 144.41,71.29 143.43,70.32 141.97,70.32 141.14,69.48 138.18,69.48
  IN6 w0.099: v2(178.19,25.03) 179.88,26.71 179.88,32.2 193.6,45.92 193.6,58.33 191.26,60.66 191.26,63.15 v2(190.65,63.76) 189.15,65.27 184.9,65.27 184.51,65.66 184.51,66.77 184.67,66.94 184.67,69.82 182.54,71.95 182.54,80.44 181.89,81.09 181.89,84.81 v2(182.08,84.99) ; v2(183.33,63) 181.1,63 ; 138.18,69.48 135.26,69.48 v2(130.27,64.49)
  BOTTOM w0.14: UZ9.4 182.03,84.49 181.93,84.59 181.93,84.85 v2(182.08,84.99)
  BOTTOM w0.254: RZ50.1 v2(110.57,65.43)
RUNPWROK: length 227.8
  TOP w0.127: UH14.2 v2(112.99,7.12)
  TOP w0.14: v2(302.21,14.87) 302.65,15.31 303.23,15.31 303.29,15.38 UE3.B26 ; v1(308.28,13.06) 307.9,13.45 v2(307.9,13.88) 308.12,14.09 308.52,14.09 RE52.2 310.07,14.82 310.37,15.12 QE4.3
  IN3 w0.091: v2(302.21,14.87) 302.6,14.47 303.37,14.47 303.95,13.89 307.89,13.89 v2(307.9,13.88) 308.11,13.67 308.11,10.08 309.35,8.84 v2(309.35,8.05)
  IN6 w0.099: v2(112.99,7.12) 113.21,6.9 115.71,6.9 117.18,8.37 118.61,8.37 118.61,8.37 134.48,8.37 134.73,8.61 144.87,8.61 147.38,6.1 151.63,6.1 152.34,5.39 161.93,5.39 163.37,6.83 164.66,6.83 166.08,5.41 171.71,5.41 173.52,7.22 177.98,7.22 178.95,8.18 199.2,8.18 199.96,8.94 201.41,8.94 202.88,10.41 210.5,10.41 214.25,6.66 227.03,6.66 228.21,5.48 244.42,5.48 245.82,6.87 252.63,6.87 253.14,6.36 261.9,6.36 262.58,7.04 272.39,7.04 274.12,5.31 282.76,5.31 284.32,6.87 299.39,6.87 300.09,6.17 301.18,6.17 302.08,7.07 306.21,7.07 306.52,7.37 306.9,7.37 308,8.48 308.93,8.48 v2(309.35,8.05)
S5_1.2V: length 4.4
  TOP w0.14: v3(290.67,28.58) 290.67,28.76 291.06,29.16 v2(291.15,29.16)
  TOP w0.254: PC613.1 291.83,28.47 v2(291.15,29.16)
  BOTTOM w0.203: PU600.8 290.67,29.64 v2(291.15,29.16) 291.83,28.47 PC613.1
SATA_PRX_DTX_N1B: length 165.5
  IN6 w0.119: v2(80.79,23.47) 80.92,23.47 81.68,24.23 87.64,24.23 87.87,24 87.88,24 88.04,23.83 88.1,23.78 88.41,23.46 88.41,21.88 88.96,21.34 92.11,21.34 92.72,20.72 92.72,20.04 92.94,19.81 92.94,19.05 92.78,18.89 92.78,18.31 93.84,17.25 101.59,17.25 102.25,16.59 102.25,16.29 102.76,15.79 104.76,15.79 105.1,16.13 129.41,16.13 130.4,15.14 161.01,15.14 162,14.16 174.71,14.16 175.63,15.08 184.99,15.08 186.05,16.14 229.6,16.14 232.12,13.62 234.99,13.62 235.11,13.74 235.11,13.92 v2(234.99,14.04)
  BOTTOM w0.089: UH2.D39 80.79,24.09 80.79,24.09 80.85,24.02 80.85,23.53 v2(80.79,23.47)
  BOTTOM w0.17: CS20.1 235.03,13.62 235.03,14 v2(234.99,14.04)
SATA_PRX_DTX_N1B_RC: length 2.2
  BOTTOM w0.17: JHDD.8 234.86,11.43 235.01,11.58 235.01,12.32 CS20.2
SATA_PRX_DTX_P1B: length 165.4
  IN6 w0.119: v2(81.43,23.43) 81.43,23.61 81.79,23.97 87.54,23.97 87.69,23.81 87.86,23.64 87.91,23.59 88.15,23.35 88.15,21.78 88.85,21.08 92,21.08 92.46,20.61 92.46,19.93 92.69,19.71 92.69,19.16 92.52,19 92.52,18.2 93.73,16.99 101.48,16.99 101.99,16.48 101.99,16.19 102.65,15.53 104.86,15.53 105.21,15.87 129.3,15.87 130.29,14.88 160.9,14.88 161.89,13.9 174.81,13.9 175.74,14.82 185.09,14.82 186.15,15.88 229.49,15.88 232.01,13.36 235.1,13.36 235.37,13.63 235.37,13.84 v2(235.57,14.04)
  BOTTOM w0.089: v2(81.43,23.43) 81.2,23.66 81.2,23.87 81.3,23.97 UH2.E37
  BOTTOM w0.17: CS19.1 235.64,13.42 235.46,13.6 235.46,13.93 v2(235.57,14.04)
SATA_PRX_DTX_P1B_RC: length 2.2
  BOTTOM w0.17: JHDD.9 235.36,11.32 235.45,11.4 235.45,12.24 CS19.2
SATA_PRX_SSDTX_N0A: length 187
  IN6 w0.119: v2(258.56,12.35) 258.75,12.16 258.75,12.01 258.43,11.69 251.01,11.69 249.76,12.93 231.78,12.93 229.26,15.45 186.38,15.45 185.32,14.39 175.91,14.39 174.99,13.47 161.71,13.47 160.73,14.46 130.01,14.46 129.08,15.4 105.34,15.4 105,15.06 102.34,15.06 101.37,16.03 99.28,16.03 98.53,16.79 93.03,16.79 91.57,18.24 91.57,19.87 91.1,20.34 87.05,20.34 86.79,20.09 84.93,20.09 84.64,20.37 84.64,22.08 84.42,22.31 84.05,22.31 83.96,22.4 v2(83.96,22.66)
  BOTTOM w0.101: UH2.G31 84.41,23.08 v2(83.96,22.66)
  BOTTOM w0.17: JNGFF2.43 259.5,12.04 259.35,11.9 258.94,11.9 258.56,12.28 v2(258.56,12.35)
SATA_PRX_SSDTX_P0A: length 187
  IN6 w0.119: v2(259.14,12.35) 259.01,12.22 259.01,11.9 258.54,11.43 250.9,11.43 249.66,12.68 231.67,12.68 229.15,15.2 186.49,15.2 185.43,14.14 176.02,14.14 175.1,13.21 161.61,13.21 160.62,14.2 129.91,14.2 128.97,15.14 105.45,15.14 105.11,14.8 102.23,14.8 101.26,15.77 99.17,15.77 98.42,16.53 92.92,16.53 91.31,18.14 91.31,19.76 90.99,20.08 87.15,20.08 86.9,19.83 84.82,19.83 84.38,20.26 84.38,21.97 84.31,22.05 84.09,22.05 v2(83.98,21.94)
  BOTTOM w0.101: UH2.H31 84.39,22.32 v2(83.98,21.94)
  BOTTOM w0.17: JNGFF2.41 259.75,12.54 259.39,12.91 259.12,12.91 258.99,12.79 258.99,12.51 v2(259.14,12.35)
SATA_PTX_DRX_N1B: length 166.9
  IN6 w0.119: v2(233.68,14.04) 233.68,16.66 232.58,17.76 186.51,17.76 184.51,15.76 175.34,15.76 174.42,14.84 162.28,14.84 161.29,15.82 130.68,15.82 129.47,17.03 129.14,17.03 128.59,17.58 102.23,17.58 102.07,17.74 94.23,17.74 93.8,18.18 93.8,22.98 92.6,24.17 88.97,24.17 87.38,25.76 81.68,25.76 80.64,24.71 v2(80.49,24.71)
  BOTTOM w0.089: v2(80.49,24.71) 80.54,24.71 81.13,25.29 UH2.B38
  BOTTOM w0.17: CS18.1 233.58,13.65 233.58,13.94 v2(233.68,14.04)
SATA_PTX_DRX_N1B_RC: length 2.2
  BOTTOM w0.17: CS18.2 233.62,12.32 233.62,11.67 233.86,11.43 JHDD.6
SATA_PTX_DRX_P1B: length 166.9
  IN6 w0.119: v2(81.2,24.37) 81.05,24.22 80.95,24.22 80.82,24.34 80.82,24.53 81.79,25.5 87.28,25.5 88.86,23.91 92.5,23.91 93.54,22.87 93.54,18.07 94.12,17.48 101.96,17.48 102.12,17.32 128.48,17.32 129.03,16.77 129.36,16.77 130.57,15.57 161.19,15.57 162.17,14.58 174.53,14.58 175.45,15.5 184.62,15.5 186.61,17.5 232.47,17.5 233.35,16.62 233.42,16.55 233.42,14.37 233.1,14.05 v2(233.1,14.04)
  BOTTOM w0.089: UH2.C38 80.9,24.59 80.9,24.39 80.99,24.3 81.14,24.3 v2(81.2,24.37)
  BOTTOM w0.17: CS17.1 232.93,13.42 233.15,13.64 233.15,13.99 v2(233.1,14.04)
SATA_PTX_DRX_P1B_RC: length 2.2
  BOTTOM w0.17: CS17.2 233.19,12.24 233.19,11.49 233.36,11.32 JHDD.5
SATA_PTX_SSDRX_N0A: length 190.9
  IN6 w0.119: v2(84.8,27.54) 84.6,27.54 84.52,27.46 84.52,27.28 85.05,26.76 87.4,26.76 88.79,25.36 92.54,25.36 94.34,23.56 94.34,18.53 94.66,18.21 100.68,18.21 101.07,18.61 102.17,18.61 102.51,18.27 132.68,18.27 133.29,17.66 162.22,17.66 164.31,15.57 174.18,15.57 175.06,16.44 183.95,16.44 186.02,18.52 234.46,18.52 235.94,17.04 235.94,16.24 237.25,14.93 238.65,14.93 239.96,13.62 250.05,13.62 250.76,12.9 255.55,12.9 255.86,12.6 255.86,12.45 v2(256.12,12.19)
  BOTTOM w0.089: v2(84.8,27.54) 84.8,27.26 84.99,27.07 84.99,26.29 84.65,25.94 84.65,25.26 84.46,25.07 UH2.C31
  BOTTOM w0.17: v2(256.12,12.19) 255.89,12.19 255.76,12.06 255.76,11.01 256.05,10.73 256.46,10.73 256.57,10.83 256.57,11.15 256.69,11.27 257.01,11.27 CD53.1
SATA_PTX_SSDRX_N0A_C: length 2.6
  BOTTOM w0.17: CD53.2 258.19,11.01 259.37,11.01 259.41,11.04 JNGFF2.47
SATA_PTX_SSDRX_P0A: length 191
  IN6 w0.119: v2(84.21,27.71) 84.27,27.66 84.27,27.17 84.94,26.5 87.29,26.5 88.69,25.1 92.43,25.1 94.08,23.45 94.08,18.43 94.55,17.95 100.79,17.95 101.18,18.35 102.06,18.35 102.4,18.01 132.58,18.01 133.18,17.4 162.11,17.4 164.21,15.31 174.29,15.31 175.17,16.18 184.06,16.18 186.13,18.26 234.35,18.26 235.68,16.93 235.68,16.14 237.14,14.67 238.54,14.67 239.85,13.36 249.94,13.36 250.65,12.65 255.45,12.65 255.6,12.5 255.6,12.32 255.47,12.19 v2(255.33,12.19)
  BOTTOM w0.089: UH2.B31 84.36,25.5 84.44,25.59 84.44,26.02 84.8,26.37 84.8,26.97 84.58,27.19 84.29,27.19 84.15,27.33 84.15,27.64 v2(84.21,27.71)
  BOTTOM w0.17: CD51.1 255.87,10.3 255.33,10.83 v2(255.33,12.19)
SATA_PTX_SSDRX_P0A_C: length 2.6
  BOTTOM w0.17: CD51.2 258.3,10.58 259.37,10.58 259.41,10.54 JNGFF2.49
SD_CD#: length 21.4
  TOP w0.14: v3(327.92,42.91) 328.79,42.91 329.38,43.5 JCR.8 332.85,43.5 333.73,42.62 333.73,41.53 334.96,40.29 338.24,40.29 339.14,39.39 341.77,39.39 343.22,37.94 v2(343.22,36.28)
  BOTTOM w0.14: v2(343.22,36.28) 342.69,36.28 342.48,36.49 UR1.30
SD_CLK: length 21.6
  TOP w0.14: JCR.6 329.37,46.3 328.89,45.81 v2(328.89,43.73)
  BOTTOM w0.14: v2(328.89,43.73) 328.89,42.13 328.8,42.05 326.74,42.05 326.58,41.89 326.58,41.55 326.71,41.42 327.09,41.42 327.23,41.28 327.23,40.38 327.34,40.27 327.66,40.27 327.79,40.39 327.79,40.65 327.79,40.65 327.79,41.28 327.93,41.42 328.46,41.42 328.6,41.28 328.6,40.71 328.74,40.57 329.02,40.57 329.16,40.71 329.16,41.28 329.3,41.42 v1(329.85,41.42) 331.41,41.42 332.06,40.78 332.87,40.78 333.83,41.74 CR8.1 RR4.2
SD_CLK_R: length 3.6
  IN6 w0.099: v2(336.77,40.81) 336.77,40.5 v2(337.65,39.62)
  BOTTOM w0.14: v2(337.65,39.62) 338.45,39.62 338.58,39.49 UR1.17 ; v2(336.77,40.81) 336.75,40.83 RR4.1
SD_CMD: length 22
  TOP w0.14: v2(336.61,48.9) 334.69,48.9 334.55,49.04 334.55,49.67 334.42,49.79 334.12,49.79 333.99,49.67 333.99,49.04 333.85,48.9 333.57,48.9 333.43,49.04 333.43,49.74 333.29,49.88 333.01,49.88 332.87,49.74 332.87,49.04 332.73,48.9 331.98,48.9 331.73,49.16 331.73,52.78 331.25,53.25 JCR.3
  BOTTOM w0.14: v2(336.61,48.9) 336.61,46.36 336.17,45.92 336.17,43.13 336.47,42.82 v1(337.27,42.82) RR5.2
SD_CMD_R: length 3
  IN6 w0.099: v2(338.74,41.3) 339.2,40.83 v2(339.2,39.98)
  BOTTOM w0.14: v2(339.2,39.98) 339.38,39.8 UR1.19 ; v2(338.74,41.3) 338.71,41.32 RR5.1
SD_D2: length 22
  TOP w0.14: v2(337.52,50.92) 333.46,50.92 332.77,51.61 332.77,54.53 331.25,56.05 JCR.1
  BOTTOM w0.14: RR8.2 339.73,43.58 339.73,43.82 339.35,44.2 337.88,44.2 337.76,44.33 337.76,44.78 337.88,44.9 338.27,44.9 338.39,45.03 338.39,48.59 v3(338.08,48.9) 338.08,50.36 v2(337.52,50.92)
SD_D2_R: length 2.9
  IN6 w0.099: v2(340.46,41.28) 340.29,41.11 v2(340.29,40.25)
  BOTTOM w0.14: UR1.21 340.18,39.63 340.29,39.74 v2(340.29,40.25) ; v2(340.46,41.28) 340.49,41.31 RR8.1
SD_D3: length 22.2
  TOP w0.14: JCR.2 331.76,54.65 332.25,54.16 332.25,51.39 333.24,50.4 335.07,50.4 335.21,50.26 335.21,49.56 335.35,49.42 335.63,49.42 335.77,49.56 335.77,50.26 335.91,50.4 336.19,50.4 336.33,50.26 336.33,49.56 336.47,49.42 337.3,49.42 v2(337.31,49.41)
  BOTTOM w0.14: v2(337.31,49.41) 337.5,49.22 v3(337.5,46.87) 337.5,46.36 336.74,45.6 336.74,43.89 337.06,43.57 339.03,43.57 339.15,43.44 339.15,43.27 RR7.2
SD_D3_R: length 2.8
  IN6 w0.099: v2(339.6,41.3) 339.79,41.11 v2(339.79,39.95)
  BOTTOM w0.14: v2(339.79,39.95) 339.78,39.94 UR1.20 ; RR7.1 v2(339.6,41.3)
SD_LN0_M: length 23.9
  TOP w0.102: v2(346.09,39.44) 345.95,39.58 345.95,46.69 345.7,46.94 345.7,51.7 346.39,52.4 349.96,52.4 350.07,52.29 350.07,51.88 350.17,51.77 JCR.14
  BOTTOM w0.102: v2(346.09,39.44) 345.96,39.57 345.96,39.82 345.64,40.14 345.19,40.14 343.62,38.57 v5(343.36,38.57) 343.05,38.57 342.9,38.43 342.58,38.43 342.52,38.49 UR1.25
SD_LN0_P: length 23.9
  TOP w0.102: JCR.13 350.17,53.27 350.07,53.17 350.07,52.91 349.82,52.66 346.28,52.66 345.43,51.81 345.43,46.83 345.68,46.58 345.68,39.62 v2(345.5,39.44)
  BOTTOM w0.102: UR1.26 342.44,38.09 342.51,38.16 343.02,38.16 343.16,38.3 343.73,38.3 345.3,39.87 345.53,39.87 345.7,39.71 345.7,39.63 v2(345.5,39.44)
SD_LN1_M: length 17
  TOP w0.102: JCR.17 350.17,45.77 350.07,45.67 350.07,45.26 349.78,44.97 349.52,44.97 347.27,42.71 347.27,40.05 347.11,39.9 v2(347.11,39.89)
  BOTTOM w0.102: UR1.23 340.98,39.56 340.91,39.63 340.91,39.94 342.07,41.09 346.77,41.09 347.35,40.52 347.35,40.12 v2(347.11,39.89)
SD_LN1_P: length 17
  TOP w0.102: JCR.18 350.26,44.27 349.85,44.68 349.62,44.68 347.54,42.6 347.54,40.05 v2(347.7,39.89)
  BOTTOM w0.102: UR1.22 340.58,39.57 340.65,39.64 340.65,40.05 341.96,41.36 v5(345.25,41.36) 346.89,41.36 347.61,40.63 347.61,39.97 v2(347.7,39.89)
SD_RCLK_M: length 20.3
  TOP w0.102: JCR.10 329.27,40.7 329.01,40.96 329.01,41.69 328.91,41.79 326.52,41.79 326.39,41.66 326.39,40.06 326.49,39.96 328.3,39.96 328.56,39.71 328.56,38.93 328.3,38.67 327.25,38.67 327.15,38.57 327.15,37.69 v2(327.28,37.56)
  BOTTOM w0.102: v2(327.28,37.56) 327.09,37.75 327.09,38.12 328.4,39.43 v5(329.67,39.43) 333.63,39.43 RR2.2
SD_RCLK_M_R: length 3.7
  IN6 w0.089: v2(336.84,38.3) 336.65,38.49 336.49,38.49 335.74,39.24 335.61,39.24 v2(335.57,39.2)
  BOTTOM w0.102: v2(336.84,38.3) 336.85,38.31 337.11,38.31 337.33,38.09 UR1.15 ; RR2.1 335.22,39.37 335.4,39.37 v2(335.57,39.2)
SD_RCLK_P: length 20.4
  TOP w0.102: v2(326.65,37.56) 326.89,37.8 326.89,38.68 327.14,38.94 328.19,38.94 328.3,39.04 328.3,39.59 328.19,39.7 326.38,39.7 326.12,39.95 326.12,41.78 326.41,42.06 329.02,42.06 329.06,42.1 JCR.9
  BOTTOM w0.102: RR3.2 333.74,39.7 328.29,39.7 326.82,38.23 326.82,37.74 v2(326.65,37.56)
SD_RCLK_P_R: length 3.8
  IN6 w0.089: v2(336.84,38.88) 336.74,38.78 336.56,38.78 335.57,39.77 v2(335.57,39.79)
  BOTTOM w0.102: RR3.1 335.22,39.64 335.43,39.64 v2(335.57,39.79) ; v2(336.84,38.88) 337,38.73 337.16,38.73 337.4,38.49 337.46,38.49 337.46,38.49 337.47,38.49 UR1.16
SD_REG2: length 0.6
  BOTTOM w0.14: 342.19,39.67 v1(342.19,40.26)
SIO_EXT_SCI#: length 276.6
  TOP w0.089: RH383.2 77,9.91 v1(77.1,9.81) 77.92,9.81 78.04,9.94 79.78,9.94 79.84,9.99 81.14,9.99 81.32,9.81 81.32,9.24 81.53,9.03 83.38,9.03 84.05,8.35 85.1,8.35 85.52,7.93 86.02,7.93 v2(86.2,7.76)
  TOP w0.14: v2(303.02,21.73) 302.77,21.48 UE3.A33
  IN2 w0.089: 101.98,10.58 99.98,10.58 99.41,10.01 97.67,10.01 97.15,10.52 95.22,10.52 94.59,9.89 92.26,9.89 91.69,9.32 90.53,9.32 90.28,9.06 89.19,9.06 88.48,8.36 86.8,8.36 v2(86.2,7.76)
  IN2 w0.099: 101.98,10.58 103.3,10.58 104.44,11.71 113.54,11.71 114.6,12.77 148.97,12.77 149.26,12.49 153.1,12.49 154.52,11.06 154.52,10.38 154.74,10.17 163.28,10.17 164.19,11.08 177.67,11.08 178.51,10.24 183.59,10.24 183.77,10.06 187.65,10.06 188.6,9.11 196.59,9.11 197.26,9.78 200.03,9.78 200.17,9.92 201.6,9.92 202.52,10.84 211.36,10.84 214.64,7.57 226.16,7.57 227.59,6.13 238.39,6.13 240.59,8.33 252.35,8.33 253.14,7.54 255.78,7.54 256.77,8.53 262.49,8.53 262.7,8.32 273.03,8.32 275,6.35 281.9,6.35 282.65,7.1 287.69,7.1 287.85,6.94 292.22,6.94 292.77,6.4 295.69,6.4 296.11,6.82 299.44,6.82 300.08,6.18 300.99,6.18 301.64,6.82 309.64,6.82 314.52,11.71 v2(314.88,11.71)
  IN3 w0.091: v2(314.88,11.71) 314.58,12.01 314.58,12.37 314.36,12.59 314.36,19.67 311.66,22.38 308.33,22.38 307.77,21.83 303.12,21.83 v2(303.02,21.73)
  BOTTOM w0.089: UH2.AV29 86.07,7.62 v2(86.2,7.76)
SIO_EXT_SMI#: length 250.6
  TOP w0.089: RH110.1 76.2,12.4 77.46,12.4 77.82,12.77 v1(78.6,12.77) 79.13,12.25 79.48,12.25 79.87,12.65 v2(79.95,12.65)
  TOP w0.14: v2(297.65,8.68) 297.78,8.82 297.78,9.52 297.77,9.53 UE3.A6 ; RE140.1 284.91,8.9 284.91,9.77 v2(284.9,9.77)
  IN5 w0.089: v2(79.95,12.65) 80.37,13.06 83.98,13.06 84.05,13 90.47,13 92.12,14.65 96.08,14.65 96.58,14.15 98.94,14.15 99.63,13.46 100.59,13.46 101.04,13.92 101.98,13.92
  IN5 w0.099: v2(297.65,8.68) 297.11,8.68 294.46,11.34 293.27,11.34 292.27,10.34 289.35,10.34 287.81,8.79 285.29,8.79 284.9,9.18 v2(284.9,9.77) 283.55,11.13 270.96,11.13 270.65,10.82 269.04,10.82 268.63,10.4 265.96,10.4 264.49,11.87 262.21,11.87 261.66,11.32 252.19,11.32 251.28,12.24 235.81,12.24 235.61,12.03 230.38,12.03 230.17,12.24 229.46,12.95 223.81,12.95 218.82,17.94 218.82,24.34 218.03,25.13 186.62,25.13 186.34,25.41 182.7,25.41 180.12,22.82 180.12,18.96 175.19,14.03 160.95,14.03 160.69,13.78 149.23,13.78 149.06,13.95 145.93,13.95 145.75,13.78 129.35,13.78 129.21,13.64 125.04,13.64 124.87,13.46 122.74,13.46 121.86,12.58 117.02,12.58 116.13,13.46 114.85,13.46 114.65,13.66 106.58,13.66 106.32,13.92 101.98,13.92
  BOTTOM w0.089: UH2.AF41 v2(79.95,12.65)
SIO_EXT_WAKE#: length 250.6
  TOP w0.14: v2(282.73,17.59) 282.73,17.81 v1(283.01,18.09) ; UE3.B5 297.02,11.71 v2(297.52,12.21)
  IN6 w0.089: 75.06,11.73 75.44,12.11 77.57,12.11 78.84,13.38 91.3,13.38 92.05,14.13 95.84,14.13 96.74,13.23 99.27,13.23 99.37,13.32 101.06,13.32 101.31,13.08 101.98,13.08
  IN6 w0.099: v2(73.48,10.61) 73.94,10.61 75.06,11.73 ; v2(282.73,17.59) 281.85,16.71 278.85,16.71 277.58,15.44 273.46,15.44 272.05,14.03 268.53,14.03 266.46,11.95 263.5,11.95 261.55,10.01 250.59,10.01 249.41,11.19 237.2,11.19 236.75,10.74 234.97,10.74 234.59,11.12 230.85,11.12 228.28,13.7 186.76,13.7 185.98,12.92 176.52,12.92 175.6,12 161.1,12 160.74,12.36 152.21,12.36 152.16,12.41 149.22,12.41 149.09,12.28 146.36,12.28 145.91,12.73 129.51,12.73 128.71,13.53 125.37,13.53 124.27,12.44 116.72,12.44 116.12,13.04 112.9,13.04 112.09,12.23 108.79,12.23 107.94,13.08 101.98,13.08
  BOTTOM w0.089: UH2.AN44 78.04,9.7 75.25,9.7
  BOTTOM w0.127: RH523.2 72.85,10.68 73.42,10.68 v2(73.48,10.61) 73.65,10.45 74.5,10.45 75.25,9.7
  BOTTOM w0.14: v2(297.52,12.21) 297.49,12.21 296.75,12.95 294.45,12.95 291.3,9.8 291.3,9.34 290.63,8.67 287.16,8.67 285.88,9.95 285.88,10.78 284.29,12.37 284.29,13.52 282.73,15.08 v2(282.73,17.59)
SIO_PWRBTN#: length 363.4
  TOP w0.14: v2(295.17,16.25) 295.04,16.38 UE3.B58 ; v2(82.68,34.98) 82.35,34.65 82.27,34.65 80.39,32.77 75.6,32.77 74.63,31.8 v3(74.63,27.19) 74.63,24.82 74.98,24.47 74.98,22.53 74.38,21.93 v2(73.97,21.93)
  IN2 w0.089: 97.75,9.62 97.65,9.52 96.8,9.52 96.25,8.96 94.46,8.96 v2(94.07,8.58)
  IN2 w0.099: v2(292.1,5.9) 291.57,5.36 285.71,5.36 284.77,6.3 282.99,6.3 282.24,5.55 272.5,5.55 270.52,7.52 262.37,7.52 262.17,7.72 257.1,7.72 256.11,6.73 252.8,6.73 252,7.53 240.96,7.53 238.73,5.29 227.25,5.29 225.79,6.75 214.21,6.75 210.95,10.01 203.08,10.01 202.07,9 200.38,9 199.61,8.23 186.92,8.23 185.92,9.24 184.71,9.24 184.06,8.59 178.5,8.59 178.16,8.93 175.07,8.93 174.23,9.77 170.29,9.77 168.92,8.4 157.02,8.4 155.75,9.67 154.66,9.67 154.12,10.22 154.12,10.83 152.96,12 148.98,12 148.61,12.37 114.77,12.37 113.71,11.31 106.51,11.31 105.37,10.18 100.1,10.18 99.55,9.62 97.75,9.62
  IN3 w0.089: 75.06,17.92 76.24,16.73 77.51,16.73 77.88,16.37 77.88,16.06 79.76,14.18 84.63,14.18 85.12,13.69 85.12,13.14 85.42,12.84 85.42,12.09 86.94,10.58 88.25,10.58 89.04,9.79 92.48,9.79 92.74,10.04 93.73,10.04 94.15,9.62 94.15,8.65 v2(94.07,8.58)
  IN3 w0.091: v2(82.68,34.98) 83.06,34.6 83.62,34.6 85.19,36.18 85.6,36.18 86.08,36.66 86.56,36.66 87.07,37.17 94.74,37.17 95.84,38.26 97.97,38.26 101.17,41.46 101.17,42.43 112.28,53.54 112.46,53.54 116.9,57.99 116.9,63.37 119.07,65.54 119.73,65.54 122.79,68.61 122.79,71.39 124.6,73.19 124.6,84.8 128.56,88.77 128.56,92.3 131.05,94.79 133.2,94.79 v2(133.86,95.45) ; v2(292.1,5.9) 292.99,6.78 292.99,10.37 294.52,11.9 294.52,15.59 v2(295.17,16.25) ; v2(73.97,21.93) 74.88,21.02 74.88,18.09 75.06,17.92
  BOTTOM w0.089: UH2.AT13 93.96,8.46 v2(94.07,8.58)
  BOTTOM w0.14: RH6.2 v2(133.86,95.45)
SIO_RCIN#: length 245.2
  TOP w0.089: v2(91.92,8.73) 92.52,9.33 v1(92.52,10.3) 92.67,10.44 92.67,11.71 92.84,11.88 RH518.1
  TOP w0.14: UE3.A27 305.02,16.63 v2(305.17,16.48)
  IN2 w0.089: v2(91.92,8.73) 92.44,8.21 94.24,8.21 94.75,8.73 98.92,8.73 100.16,9.97 101.98,9.97
  IN2 w0.099: v2(306.92,5.93) 306.24,6.61 301.7,6.61 300.41,5.32 295.94,5.32 295.78,5.16 285.63,5.16 284.69,6.1 283.07,6.1 282.32,5.35 272.41,5.35 270.44,7.32 262.28,7.32 262.09,7.52 257.18,7.52 256.19,6.53 252.72,6.53 251.92,7.33 241.05,7.33 238.81,5.09 227.17,5.09 225.79,6.47 214.2,6.47 211.46,9.2 209.81,9.2 209.75,9.25 205.91,9.25 205.18,8.52 202.26,8.52 201.99,8.78 200.45,8.78 199.69,8.03 178.78,8.03 178.07,8.73 173.82,8.73 173.29,8.2 156.94,8.2 155.97,9.17 153.69,9.17 152.11,10.74 152.11,11.04 151.51,11.64 148.99,11.64 148.46,12.17 114.85,12.17 113.79,11.11 106.59,11.11 105.46,9.97 101.98,9.97
  BOTTOM w0.089: v2(91.92,8.73) 91.47,8.28 UH2.AT17
  BOTTOM w0.14: v2(305.17,16.48) 304.83,16.48 304.48,16.14 304.48,13.95 304.83,13.61 306.92,13.61 307.72,12.82 307.72,11.71 306.64,10.63 306.64,6.21 v2(306.92,5.93)
SIO_SLP_A#: length 265.3
  TOP w0.14: UE3.B28 303.45,16.38 303.24,16.16 302.63,16.16 v2(302.18,15.71)
  IN2 w0.089: 101.98,3.82 100.61,3.82 98.3,1.5 93.29,1.5 92.73,2.06 92.73,2.08 92.55,2.26 92.55,2.31 v2(92.36,2.49)
  IN2 w0.099: v2(168.81,3.16) 168.22,2.57 151.55,2.57 148.99,5.14 147.39,5.14 144.81,7.72 139.28,7.72 138.35,6.78 126.58,6.78 126.3,6.51 121.17,6.51 116.19,1.52 109.31,1.52 108.5,2.33 106.88,2.33 105.4,3.82 101.98,3.82
  IN3 w0.091: v2(302.18,15.71) 302.33,15.71 302.75,15.29 303.15,15.29 304.09,14.35 308.1,14.35 308.3,14.15 308.3,10.16 309.76,8.71 309.76,6.74 309.04,6.02 v2(309.04,5.46)
  IN6 w0.099: v2(168.81,3.16) 169.04,2.93 179.96,2.93 182.02,4.99 204.93,4.99 207.17,7.24 209.66,7.24 213.56,3.33 226.73,3.33 227.2,2.86 237.28,2.86 239.02,1.13 244.42,1.13 246.91,3.62 253.67,3.62 254.02,3.27 257.7,3.27 258.1,2.87 262.56,2.87 264.09,4.4 266.41,4.4 268.19,2.62 307.09,2.62 309.04,4.57 v2(309.04,5.46)
  BOTTOM w0.089: v2(92.36,2.49) 92.23,2.62 92.23,3.72 92.44,3.93 92.44,4.38 92.44,4.65 92.58,4.79 UH2.BC15
  BOTTOM w0.14: v2(168.81,3.16) 168.81,3.65 169.39,4.23 170.39,4.23 170.94,3.68 175.54,3.68 175.79,3.93 175.79,4.63 175.74,4.68 175.74,6.33 176.12,6.71 JAPS.6
SIO_SLP_S0#: length 121
  TOP w0.127: v1(164.53,2.54) 164.73,2.33 173.69,2.33 RZ61.1
  TOP w0.14: RE125.1 157.38,2.6 RE144.1 159.5,2.6 159.7,2.4 162.29,2.4 163.35,3.46 v2(163.39,3.46) 164.31,2.54 v1(164.53,2.54) ; RZ61.1 174.82,2.9 177.57,2.9 RZ59.1
  IN6 w0.089: v2(86.92,3.05) 87.46,3.59 88.06,3.59 88.69,4.22 92.19,4.22 92.75,4.79 95.61,4.79 95.72,4.68 96.34,4.68 97.36,4.68 97.62,4.93 97.99,4.93 99.77,6.71 101.67,6.71 101.69,6.73 101.98,6.73 ; v2(86.92,3.05) 86.92,3.06 v2(86.92,3.05)
  IN6 w0.099: 101.98,6.73 104.5,6.73 105.07,7.3 105.7,7.3 106.62,6.39 115.48,6.39 117.26,8.17 118.69,8.17 118.7,8.17 135.48,8.17 135.72,8.41 144.78,8.41 147.3,5.9 151.55,5.9 152.26,5.19 162.47,5.19 v2(163.7,6.42)
  BOTTOM w0.089: UH2.BC26 86.62,4.8 86.62,4.42 86.65,4.38 86.65,4.06 86.83,3.88 86.83,3.14 v2(86.92,3.05) ; v2(86.92,3.05) 86.92,3.06 v2(86.92,3.05)
  BOTTOM w0.14: JAPS.15 171.62,8.16 171.32,8.46 DZ1.2 169.05,6.56 168.66,6.17 165.43,6.17 164.97,5.71 164.41,5.71 v2(163.7,6.42) 163.39,6.11 v2(163.39,3.46)
SIO_SLP_S3#: length 543.9
  TOP w0.14: v2(117.41,9.82) 117.83,10.24 120.18,10.24 123.08,13.13 123.08,13.78 122.05,14.8 117.5,14.8 116.26,16.05 116.26,17.04 114.27,19.03 109.5,19.03 108.36,20.17 108.36,21.57 108.23,21.7 108.23,25.28 107.97,25.54 107.97,29.37 120.27,41.67 v3(120.27,45.91) 120.27,50.17 120.64,50.54 v2(121.01,50.54) ; UZ20.2 180.15,5.79 179.71,6.23 179.71,6.79 178.06,8.44 178.06,9.55 v2(178,9.61) ; v2(166.46,3.5) 167.28,4.33 UZ21.2 ; RZ81.1 120.24,56.25 v2(120.4,56.09) ; RE35.2 v2(302.44,22.46) 301.9,21.93 301.9,21.31 301.77,21.17 UE3.A35
  IN2 w0.099: v2(121.01,50.54) 120.44,51.12 120.44,52.63 120.88,53.07 121.88,53.07 122.54,53.73 122.54,55.65 122.1,56.09 v2(120.4,56.09)
  IN3 w0.091: v2(302.44,22.46) 304.13,22.46 304.38,22.21 307.61,22.21 308.17,22.77 311.82,22.77 314.75,19.83 314.75,12.75 315.48,12.02 315.48,11.46 315.45,11.43 315.45,9.37 v2(315.03,8.95)
  IN5 w0.099: v2(26.7,101.55) 25.94,101.55 22.33,97.93 22.33,89.03 22.77,88.59 22.77,85.83 22.19,85.25 22.19,66.63 23.62,65.19 23.62,64.88 24.68,63.82 24.68,61.22 25.27,60.62 25.27,56.9 24.89,56.52 24.89,55.16 23.1,53.37 23.1,44.54 23.24,44.4 23.24,44.08 22.67,43.51 22.67,41.67 21.85,40.84 21.85,31.76 20.57,30.48 20.57,29.33 15.66,24.43 15.66,23.46 16.02,23.11 17.48,23.11 19.88,20.71 21.66,20.71 v2(22.1,21.15)
  IN6 w0.089: 101.98,9.95 99.83,9.95 98.58,8.7 95,8.7 94.32,8.02 94.03,8.02 93.31,7.3 v2(93.1,7.3) 93.1,7.34 92.8,7.64 92.8,7.86 92.51,8.15 91.43,8.15 90.89,7.61 90.58,7.61 90.26,7.93 90.26,8.39 89.96,8.7 89.23,8.7 88.42,7.88 88.42,7.43 87.45,6.46 87.07,6.46 86.93,6.6 86.07,6.6 85.08,7.59 83.72,7.59 83.35,7.96 82.15,7.96 82.13,7.98 80.52,7.98 79.87,8.64 79.84,8.64 79.54,8.94 79.21,8.94 78.9,8.64 78.57,8.64 78.56,8.64 78.54,8.64 78.46,8.72 77.75,8.72 77.58,8.56 76.56,8.56 76.18,8.18 75.06,8.18
  IN6 w0.099: v2(22.1,21.15) 24.44,23.49 26.63,23.49 26.84,23.28 41.31,23.28 42.4,22.19 46.64,22.19 47.05,21.79 51.51,21.79 51.72,21.58 52.29,21.58 55.47,18.4 55.47,17.79 56.63,16.63 56.63,13.73 57.24,13.12 63.85,13.12 64.56,12.41 69.73,12.41 70.31,11.82 71.53,11.82 71.93,11.42 71.93,10.17 72.79,9.32 72.79,8.76 73.37,8.18 75.06,8.18 ; 101.98,9.95 101.99,9.95 102.15,9.79 106.02,9.79 106.32,9.49 107.04,9.49 107.32,9.77 117.36,9.77 v2(117.41,9.82) 125.26,9.82 126.35,10.92 127.92,10.92 128.51,10.32 144.91,10.32 145.38,9.84 146.47,9.84 148.6,7.72 151.63,7.72 152.1,8.19 154.6,8.19 155.28,7.51 158.98,7.51 159.37,7.89 162.44,7.89 162.61,8.06 171.01,8.06 172.72,9.77 175.01,9.77 175.73,9.05 177.44,9.05 v2(178,9.61) 179.02,9.61 179.5,9.13 183.97,9.13 184.5,9.66 186.62,9.66 187.11,10.15 201.48,10.15 202.68,11.35 210.7,11.35 214.08,7.98 227.04,7.98 228.35,6.68 236.03,6.68 237.24,7.88 253.04,7.88 253.45,7.47 256.08,7.47 256.81,8.2 262.64,8.2 262.99,7.84 274.08,7.84 275.26,6.66 282.53,6.66 283.75,7.88 291.91,7.88 293.32,9.29 294.17,9.29 294.49,9.61 302.69,9.61 303.02,9.28 312.32,9.28 312.85,8.75 314.83,8.75 v2(315.03,8.95)
  BOTTOM w0.089: UH2.AW15 92.79,6.78 93.1,7.09 v2(93.1,7.3)
  BOTTOM w0.14: v2(178,9.61) 178.05,9.56 178.05,7.51 JAPS.2 178.12,6.24 177.55,5.66 177.55,3.82 176.34,2.61 167.35,2.61 v2(166.46,3.5) ; QT11.3 28.4,100.96 27.81,101.55 v2(26.7,101.55)
SIO_SLP_S3#_AR: length 64.3
  TOP w0.14: v2(26.27,98.31) 26.27,98.84 v1(26.26,98.84)
  IN5 w0.099: v4(23.46,44.85) 23.46,53.44 25.09,55.08 25.09,56.44 25.47,56.82 25.47,60.71 24.88,61.3 24.88,63.9 23.82,64.96 23.82,65.28 23.52,65.58 23.52,67.67 22.39,68.8 22.39,85.17 22.97,85.75 22.97,88.67 22.53,89.11 22.53,97.85 22.99,98.31 v2(26.27,98.31)
  BOTTOM w0.089: v4(23.46,44.85) 23.35,44.96 UT1.D2
  BOTTOM w0.14: v2(26.27,98.31) 27.01,97.56 27.01,96.99 26.86,96.84 RT433.2 26.92,96.5 27.38,96.05 27.59,96.05 27.75,96.21 QT11.1
SIO_SLP_S4#: length 360.8
  TOP w0.14: UZ22.2 121.74,64.52 v2(121.74,64.53) ; v2(297.44,3.4) 297.56,3.53 RE38.2 ; v2(121.67,50.81) 121.67,42.39 108.45,29.17 108.45,25.74 109.32,24.87 109.32,20.19 110.01,19.51 113.87,19.51 114.47,19.51 116.74,17.24 116.74,16.25 117.6,15.39 v1(120.08,15.39) 122.14,15.39 123.56,13.98 123.56,12.88 118.37,7.68 118.37,7.31 117.95,6.89 v2(117.95,6.36) ; v2(302.31,18.71) 302.31,19.52 302.52,19.72 UE3.B36
  IN2 w0.089: v2(93.68,2.06) 94.07,1.68 98.22,1.68 100.64,4.1 101.03,4.1 101.15,4.22 101.15,4.83 101.25,4.92 101.93,4.92 101.98,4.87
  IN2 w0.099: v2(169.48,3.72) 169.2,4 162.69,4 161.66,2.97 151.76,2.97 149.19,5.54 147.56,5.54 144.98,8.12 136.33,8.12 135.4,7.18 126.1,7.18 126.03,7.11 118.7,7.11 v2(117.95,6.36) 113.51,1.92 110.16,1.92 108.39,3.69 107.6,3.69 107.21,4.09 106.07,4.09 105.28,4.87 101.98,4.87 ; v2(121.67,50.81) 121.95,51.09 121.95,52.85 122.74,53.64 122.74,55.73 121.86,56.62 121.86,64.41 v2(121.74,64.53) ; v2(314.48,7.29) 314.33,7.14 313.75,7.14 311.01,4.4 310.39,4.4 309.78,3.79 306.76,3.79 305.99,3.02 303.37,3.02 302.8,3.59 302.64,3.59 302.62,3.62 301.11,3.62 300.52,3.02 297.81,3.02 v2(297.44,3.4)
  IN3 w0.091: v2(314.48,7.29) 314.57,7.38 314.57,7.75 313.78,8.54 313.78,19.16 312.01,20.94 303.79,20.94 302.31,19.47 v2(302.31,18.71)
  IN6 w0.099: v2(169.48,3.72) 170.07,3.13 179.88,3.13 181.94,5.19 204.31,5.19 206.56,7.44 209.74,7.44 213.64,3.53 226.81,3.53 227.29,3.06 237.37,3.06 239.1,1.33 244.34,1.33 246.83,3.82 253.76,3.82 254.1,3.47 257.78,3.47 258.19,3.07 262.47,3.07 264.01,4.6 266.5,4.6 268.28,2.82 296.86,2.82 v2(297.44,3.4)
  BOTTOM w0.089: v2(93.68,2.06) 93.4,1.77 92.88,1.77 92.74,1.91 92.74,2.05 92.73,2.06 92.73,2.36 92.74,2.37 92.74,2.5 92.74,2.5 92.74,2.64 92.41,2.96 92.41,3.65 92.65,3.89 92.65,4.34 92.68,4.37 UH2.BD15
  BOTTOM w0.14: v2(169.48,3.72) 169.77,3.44 175.64,3.44 176.15,3.95 176.15,4.45 176.62,4.93 JAPS.5
SIO_SLP_S5#: length 250.4
  TOP w0.14: v2(305.5,11.72) 305.09,12.13 UE3.A18 ; v2(167.54,6.64) 167.74,6.84 v3(167.74,8.07)
  IN2 w0.089: v2(94.17,6.56) 94.47,6.56 94.73,6.82 94.73,7.93 94.98,8.19 95.84,8.19 96.52,7.5 97.33,7.5 97.52,7.69 98.9,7.69 99.79,8.58 101.98,8.58
  IN2 w0.099: v2(308.36,5.47) 307.63,5.47 307.25,5.09 304.8,5.09 304.56,5.33 303.48,5.33 303.24,5.57 301.52,5.57 300.66,4.72 296.19,4.72 296.03,4.55 285.75,4.55 285.71,4.51 272.12,4.51 270.92,5.7 250.67,5.7 250.58,5.8 246.05,5.8 245.28,5.03 240.35,5.03 239.57,4.25 226.88,4.25 225.47,5.66 213.87,5.66 211.22,8.31 206.55,8.31 205.44,7.21 168.1,7.21 v2(167.54,6.64) 167.1,7.08 163.25,7.08 162.41,6.24 159.95,6.24 159.42,6.76 152.63,6.76 151.99,7.4 151.99,8.19 151.99,8.19 151.99,8.36 149.69,10.66 147.11,10.66 146.6,11.17 116.35,11.17 114.57,9.39 106.96,9.39 106.72,9.15 102.64,9.15 102.07,8.58 101.98,8.58
  IN3 w0.091: v2(305.5,11.72) 306.02,11.72 308.95,8.79 308.95,7.44 308.29,6.79 308.29,5.43 308.36,5.37 v2(308.36,5.47)
  BOTTOM w0.089: v2(94.17,6.56) 93.9,6.56 93.61,6.26 UH2.BA13
  BOTTOM w0.14: v2(167.54,6.64) 167.75,6.86 DZ1.3 168.69,9.39 RZ89.1 171.08,10.36 174.77,10.36 177.12,8 JAPS.4
SIO_SLP_SUS#: length 268.9
  TOP w0.14: RE111.2 291.33,24.24 290.6,23.52 289.27,23.52 285.31,19.56 v2(285.31,18.87)
  IN2 w0.089: 101.98,8.78 99.74,8.78 98.83,7.86 97.44,7.86 97.26,7.68 96.59,7.68 95.91,8.37 95.76,8.37 94.91,8.37 94.55,8.01 94.55,7.08 94.4,6.93 93.94,6.93 93.79,6.78 93.79,6.65 v2(93.08,5.94) 93.08,6.04 92.72,6.4 91.68,6.4 91.4,6.68 91.4,7.11 90.98,7.53 90.11,7.53 89.94,7.36 89.42,7.36 89.13,7.08 89.13,5.85 88.07,4.79 85.66,4.79 85.21,4.34 84.15,4.34 83.8,3.99 78.24,3.99 77.97,3.71 75.28,3.71 75.06,3.49
  IN2 w0.099: 101.98,8.78 102.55,9.35 105.68,9.35 106.64,10.31 109.34,10.31 110.06,9.59 114.49,9.59 116.31,11.41 146.15,11.41 146.65,11.41 147.19,10.86 149.77,10.86 153.04,7.59 156.44,7.59 157.06,6.97 159.5,6.97 160.03,6.44 162.33,6.44 163.31,7.43 205.08,7.43 206.16,8.52 211.3,8.52 213.95,5.86 225.55,5.86 226.96,4.45 239.46,4.45 240.35,5.33 245.29,5.33 246.57,6.61 251.78,6.61 252.47,5.93 252.65,5.93 252.65,5.93 270.98,5.93 272.2,4.71 283.57,4.71 v2(284.15,5.29) ; 75.06,3.49 74.97,3.4 74.39,3.4 72.79,5 69.65,5 68.77,5.87 63.92,5.87 63.67,6.12 62.12,6.12 61.86,5.86 61.86,5.26 62.13,4.99 62.13,4.17 61.52,3.56 59.02,3.56 v2(58.95,3.49)
  IN3 w0.091: v2(285.31,18.87) 285.88,18.3 285.88,15 286.17,14.71 286.17,9.45 284.99,8.26 284.99,6.13 v2(284.15,5.29)
  BOTTOM w0.089: v2(93.08,5.94) 93.31,5.94 93.55,5.7 UH2.BB13
  BOTTOM w0.14: RZ1133.1 58.69,3.23 v2(58.95,3.49)
SIO_SLP_WLAN#: length 232
  TOP w0.089: v2(93.08,8.6) v1(93.51,9.03)
  TOP w0.14: UE3.B45 298.02,19.66 298.08,19.59 298.08,18.83 v2(297.6,18.34)
  IN2 w0.099: v2(295.83,5.75) 295.44,5.36 293.24,5.36 292.26,6.34 288.88,6.34 288.28,5.75 285.6,5.75 284.85,6.5 282.9,6.5 282.15,5.75 272.58,5.75 270.61,7.72 262.45,7.72 262.25,7.92 257.01,7.92 256.03,6.93 252.88,6.93 252.09,7.73 240.84,7.73 238.6,5.5 227.36,5.5 225.9,6.96 214.4,6.96 211.13,10.22 202.97,10.22 201.99,9.24 200.34,9.24 199.54,8.44 188.42,8.44 187.42,9.44 184.62,9.44 183.98,8.79 178.58,8.79 178.24,9.13 177.9,9.13 177.02,10.02 170.17,10.02 168.99,8.84 165.55,8.84 164.96,9.42 160.49,9.42 160.03,9.88 154.74,9.88 154.32,10.3 154.32,10.98 153.08,12.22 149.14,12.22 148.79,12.57 114.69,12.57 113.62,11.51 106.43,11.51 105.29,10.38 100.04,10.38 99.47,9.81 97.56,9.81 97.55,9.8 96.58,9.8 96.57,9.8 95.27,9.8 94.87,9.41 94.34,9.41 93.9,8.98 93.46,8.98 v2(93.08,8.6)
  IN3 w0.091: v2(297.6,18.34) 296.55,17.29 296.55,13.27 296.93,12.89 296.93,11.1 296.13,10.29 296.13,6.63 295.83,6.33 v2(295.83,5.75)
  BOTTOM w0.089: UH2.AV13 93.61,7.95 93.08,8.48 v2(93.08,8.6)
