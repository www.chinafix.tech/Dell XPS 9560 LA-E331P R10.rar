# Allegro board Dell XPS 9560 LA-E331P R10.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+VCCIO: length 265.7
  TOP w0.508: v2(310.08,25.1) 310.12,25.07 311.31,25.07 312.13,24.25 312.13,20.37 RE69.1 ; RH30.2 176.92,87.52 v2(176.36,87.52) ; v2(135.73,94.01) 135.34,94.4 v3(135.34,94.5) 135.34,96.57 134.65,97.27 131.8,97.27 130.86,98.21 RH483.1
  IN1 w0.381: v2(172.38,78.61) 172.63,78.61 173.01,78.99 173.01,79.98 172.3,80.69 170.8,80.69 170.48,81.01 170.48,83.56 171.08,84.16 171.29,84.16 171.93,84.79 172.34,84.79 173.39,85.85 173.39,86.66 174.81,88.08 175.88,88.08 176.36,87.6 v2(176.36,87.52)
  IN1 w0.508: v2(292.36,22.1) 292.36,21.92 292.8,21.47 294.07,21.47 294.26,21.28 296.29,21.28 296.99,20.58 300.42,20.58 300.95,21.11 304.73,21.11 307.61,23.99 307.61,24.99 308.67,26.06 309.44,26.06 310.08,25.41 v2(310.08,25.1)
  IN3 w0.508: v2(159.42,67.25) 159.52,67.25 160.25,66.52 160.68,66.52 162.28,64.92 162.28,63.93 162.91,63.29 164.61,63.29 165.14,62.77 165.14,58.01 167.37,55.78 170.1,53.04 172.49,53.04 v2(172.67,53.22) 174.55,53.22 178.39,49.38 194.8,49.38 195,49.59 201.88,49.59 203.92,47.54 208.98,47.54 209.44,47.08 213.34,47.08 213.91,46.52 213.91,45.75 215.09,44.57 215.35,44.57 216.32,43.59 216.77,43.59 219.2,41.16 219.21,41.16 228.09,32.27 228.09,30.62 228.56,30.15 228.89,30.15 228.89,30.15 239.21,30.15 v2(241.17,28.19)
  IN4 w0.508: v2(142.71,72.49) 141.69,73.5 141.69,80.07 141.01,80.76 138.67,80.76 138.27,81.16 138.27,85.53 135.73,88.06 v2(135.73,94.01)
  IN6 w0.508: v2(292.36,22.1) 290.64,22.1 290.47,21.93 286.61,21.93 286.13,22.41 282.48,22.41 281.31,21.25 279.14,21.25 278.19,20.3 277.95,20.06 268.37,20.06 265.69,17.37 259.17,17.37 256.67,14.87 255.06,14.87 254.48,15.44 248.48,15.44 248.01,14.97 245.2,14.97 245.05,15.12 240.86,15.12 239.72,16.26 239.4,16.26 239.05,16.62 239.05,16.93 238.98,17 238.98,18.16 240.87,20.05 240.87,27.89 v2(241.17,28.19)
  BOTTOM w0.152: 172.52,73.98 UH1.J21 UH1.H21 173.17,73.98 ; UH1.H20 173.17,73.19 ; 173.32,78.69 173.48,78.85 UH1.H27 UH1.J27 172.52,78.7 ; UH1.J16 172.52,70.04 ; UH1.G21 173.9,74.01 ; UH1.J19 172.52,72.4 ; 173.75,69.83 173.48,69.57 UH1.H15 ; UH1.J20 173.14,73.81 ; UH1.G19 173.9,72.43 ; 173.14,78.54 UH1.J26 UH1.H26 173.31,78.4 173.31,78.52 ; UH1.H16 173.17,70.04 ; UH1.J15 173.14,69.88 ; UH1.G17 173.9,70.86 ; UH1.J17 173.14,71.45 ; UH1.H19 173.17,72.4 ; UH1.H17 173.17,70.83
  BOTTOM w0.203: UH1.AG12 159.07,66.9 v2(159.42,67.25)
  BOTTOM w0.381: RH24.1 173.2,54.29 173.2,53.76 v2(172.67,53.22)
  vias: v2(117.78,67.93) v2(117.78,67.29) v2(117.79,66.62) v2(117.82,65.85) v2(118.42,67.93) v2(118.42,67.29) v2(118.43,66.62) v2(118.49,65.92) v2(119.05,67.93) v2(119.06,67.32) v2(119.06,66.62) v2(173.86,73.14) v2(173.85,72.34) v2(173.86,70.71)
+VCCSA: length 8.4
  TOP w0.508: v2(171.04,75.43) 171.45,75.43 PC1385.1 ; PC1390.1 171.45,74.1 v2(171.04,74.1) ; CH134.1 170.99,87.38 171.23,87.14 171.23,85.76 ; PC1386.1 171.26,79.82 v2(170.85,79.82) ; v2(170.88,76.87) 171.54,76.87 PC1382.1
  BOTTOM w0.508: RH201.2 178.14,89.37 178.68,88.83 v2(178.8,88.83) ; PC1384.1 PC1395.1 178.82,91 v2(178.75,90.94)
  vias: v2(115.34,90.33) v2(115.7,89.54) v2(115.98,90.33) v2(116.31,89.77) v2(116.61,90.36) v2(116.87,89.59) v2(117.27,90.08) v2(117.74,88.95) v2(117.73,87.32) v2(117.81,90.38) v2(117.78,89.63) v2(118.4,90.15) v2(118.4,89.53) v2(118.43,88.85) v2(118.37,87.32) v2(119.04,90.1) v2(119.04,89.47) v2(119.04,88.83) v2(119.06,87.33) v2(119.67,90.1) v2(119.67,89.47) v2(119.67,88.83) v2(119.76,88.25) v2(119.76,87.32) v2(120.27,90.14) v2(120.27,89.51) v2(120.27,88.87) v2(120.35,88.22) v2(120.33,87.64) v2(167.13,90.37) v2(167.72,90.39) v2(168.3,90.38) v2(168.91,90.37) v2(169.53,90.37) v2(170.12,90.37) v2(171.15,84.73) v2(171.15,83.43) v2(171.15,82.13) v2(171.51,92.78) v2(171.83,92.27) v2(171.93,85.38) v2(171.93,82.78) v2(171.93,82.13) v2(171.97,84.09) v2(172.15,92.78) v2(172.28,91.83) v2(172.59,92.34) v2(172.72,82.78) v2(173.04,91.89) v2(174.82,91.92) v3(114.23,88.75)
+VCCST: length 355.3
  TOP w0.127: v3(113.51,115.35) 113.51,114.47 PC1137.1
  TOP w0.254: UE3.B51 295.02,20.14 294.77,20.39 294.58,20.39 v2(294.13,19.95)
  TOP w0.381: v2(115.83,113.67) 116.16,114 PR1145.1
  TOP w0.508: CE34.1 290.88,22.39 290.88,22.54 290.85,22.58 290.85,22.67 290.62,22.9 v2(290.04,22.9) ; RH152.1 RH151.1 v2(133.49,103.01) ; RH164.1 179.75,64 v2(180.11,63.65) ; v2(108.85,8.58) RH97.1 RH98.1 ; PC1137.1 114.76,114.05 PR1131.1 115.05,114 115.38,113.67 v2(115.83,113.67)
  IN3 w0.508: v2(180.11,63.65) 180.16,63.65 181.1,64.59 182.8,64.59 190.15,57.25 190.15,55.19 191.1,54.24 194.25,54.24 197.11,57.1 199.4,57.1 200.89,55.61 203.43,55.61 203.52,55.52 208.17,55.52 208.92,54.77 208.98,54.77 211.54,52.21 216,52.21 216.21,52.41 216.71,52.41 216.92,52.21 218.16,52.21 218.36,52.41 219.72,52.41 223.13,49.01 227.88,49.01 231.41,45.47 231.41,44.74 240.71,35.44 247.4,35.44 248.43,34.41 253.56,34.41 261.1,26.87 263.27,26.87 265.56,24.58 266.32,24.58 v2(267.05,23.86) ; v2(115.83,113.67) 119.04,110.46 123.69,110.46 124.97,109.18 124.97,105.96 127,103.93 127,102.99 127.61,102.38 131.46,102.38 132.08,103.01 v2(133.49,103.01) 134.44,103.01 134.94,102.51 134.94,99.32 132.14,96.53 v2(132.14,96.17)
  IN4 w0.508: v2(132.14,96.17) 132.14,95.23 133.73,93.64 133.73,85.31 134.21,84.83 134.21,81.97 131.14,78.89 v2(131.14,77.53) 129.65,76.05 129.65,70.33 128.27,68.96 128.27,65.7 123.56,60.99 123.56,58.44 124.24,57.76 124.24,47.8 110.68,34.23 110.68,26.29 110.79,26.18 110.79,19.92 108.95,18.08 v2(108.95,16.67) ; v2(267.05,23.86) 274.74,23.86 275.59,23 277.24,23 278.89,21.34 280.73,21.34 281.43,22.04 289.56,22.04 289.65,22.13 289.69,22.13 290.04,22.49 290.04,22.89 v2(290.04,22.9)
  IN5 w0.508: v2(290.04,22.9) 290.58,22.36 290.58,21.34 291.59,20.33 293.75,20.33 v2(294.13,19.95)
  IN6 w0.508: v2(132.14,96.17) 132.75,96.78 133.62,96.78 134.23,96.17 141.72,96.17 145.05,92.85 159.81,92.85 160.78,93.82 169.54,93.82 170.66,92.7 170.66,91.6 171.68,90.58 176.23,90.58 176.53,90.28 180.3,90.28 181.24,89.34 181.24,86.35 180.89,86 v2(180.89,79.03)
  BOTTOM w0.203: v2(173.88,80.98) 173.88,80.99 UH1.H30 ; UH1.H28 UH1.J28 172.77,79.8 v2(172.38,79.42)
  BOTTOM w0.508: RH156.1 RH570.1 130.67,78 v2(131.14,77.53) ; RH100.1 v2(108.85,8.58) 110.36,10.09 110.36,13.28 109.88,13.76 109.88,15.5 108.95,16.43 v2(108.95,16.67)
  vias: v2(180.47,78.6)
+VCCSTG: length 196.4
  TOP w0.127: v2(182.93,81.47) v3(183.36,81.03)
  TOP w0.508: v2(173.47,82.12) 173.69,82.12 174.02,82.44 CH106.1 174.91,82.95 CH105.1
  IN1 w0.508: v2(173.89,80.2) 173.88,80.21 173.67,80.21 173.11,80.77 173.11,81.37 173.47,81.73 v2(173.47,82.12)
  IN3 w0.508: v2(131.79,98.36) 131.79,98.31 131.98,98.12 132.55,98.12 v2(132.82,98.38) ; v2(204.05,49.88) 202.72,49.88 202.21,50.39 194.67,50.39 194.47,50.19 190.07,50.19 189.37,50.19 181.63,50.19 181.2,50.61 179.53,50.61 175.7,54.44 171.82,54.44 v2(171.6,54.23)
  IN5 w0.508: v2(204.05,49.88) 204.09,49.88 204.32,50.11 204.32,51.02 202.82,52.52 198.44,52.52 195.95,55.01 195.95,57.53 192.45,61.03 192.45,66.83 188.09,71.19 184.41,71.19 182.93,72.67 v2(182.93,81.47)
  IN6 w0.508: v2(131.79,98.36) 131.48,98.05 130.72,98.05 130.24,98.54 129.15,98.54 127.5,96.88 123.89,96.88 123.22,96.21 123.22,87.7 127.05,83.87 v2(127.46,83.87)
  BOTTOM w0.203: UH1.G30 173.47,82.08 v2(173.47,82.12)
  BOTTOM w0.254: UH1.H29 173.53,80.55 173.89,80.2 v2(173.89,80.2)
  BOTTOM w0.508: v2(131.79,98.36) 131.7,98.27 RH494.1 ; v2(127.46,83.87) 127.33,83.74 127.33,80.98 129.51,78.8 RH165.1 129.78,73.3 132.76,70.32 135.31,70.32 136.15,69.48 136.15,68.08 135.76,67.7 134.88,67.7 134.24,67.06 134.24,66.43 132.77,64.96 132.77,52.97 136.81,48.93 161.14,48.93 165.66,53.45 170.83,53.45 v2(171.6,54.23) ; v2(132.82,98.38) 133.3,98.38 133.67,98.01 RH496.1 RH495.1
  vias: v2(182.3,81.44)
AGND: length 64.5
  TOP w0.127: v2(2.34,43) 2.93,43 v3(3.28,42.66)
  TOP w0.356: CA14.2 2.49,40.37 CA12.2 2.5,39.74 CA17.2 ; CA26.2 3.95,37.6 v2(4.15,37.8)
  TOP w0.508: CA44.2 5.26,43.68 v2(4.88,43.3) ; v2(14.74,44.5) 14.74,44.9 13.97,45.67 CA43.2 ; v2(3.02,35.19) 2.73,35.47 CA27.2 ; CA41.1 5.7,59.31 6.15,58.86 v2(6.15,58.67) ; v2(11.35,40.75) 11.53,40.57 RA74.1 ; CA42.1 14.81,53.95 v2(14.9,53.86) ; RA95.2 3.11,57.72 v2(2.92,57.53) ; v2(2.34,43) CA13.2 CA14.2
  GND1 w0.203: JHP1.5 12.28,46.7 ; JHP1.5 12.28,47.37 ; JHP1.5 11.35,46.7 ; JHP1.5 10.42,47.37 ; JHP1.7 9.18,46.7 ; JHP1.7 9.18,47.37 ; JHP1.7 8.2,46.7 ; JHP1.7 7.22,46.7 ; JHP1.7 7.22,47.37
  GND2 w0.203: 7.22,46.7 JHP1.7 ; JHP1.7 9.18,47.37 ; JHP1.7 8.2,46.7 ; JHP1.7 9.18,46.7 ; JHP1.7 7.22,47.37 ; JHP1.5 12.28,47.37 ; JHP1.5 12.28,46.7 ; JHP1.5 10.42,47.37 ; JHP1.5 11.35,46.7
  GND3 w0.203: 8.2,46.7 JHP1.7 ; JHP1.7 9.18,46.7 ; JHP1.7 7.22,46.7 ; JHP1.7 7.22,47.37 ; JHP1.7 9.18,47.37 ; JHP1.5 12.28,46.7 ; JHP1.5 11.35,46.7 ; JHP1.5 12.28,47.37 ; JHP1.5 10.42,47.37
  BOTTOM w0.203: UA1.42 11.24,42.34 11.6,42.71 11.91,42.71 12.41,43.2 CA24.2 ; UA1.20 4.22,37.72 v2(4.15,37.8) ; v2(6.17,42.69) 6.35,42.52 6.35,42.34 6.44,42.24 UA1.30
  BOTTOM w0.305: CA28.2 2.22,37.58 2.22,36.32 2.6,35.94 CA29.2
  BOTTOM w0.356: CA24.2 12.19,43.72 12.19,44.12
  BOTTOM w0.508: v2(2.92,57.53) 4.33,57.53 4.73,57.92 6.44,57.92 7.25,58.73 RA73.2 ; v2(14.38,43.12) 14.74,43.48 v2(14.74,44.5) 14.74,44.66 14.16,45.23 CA30.2 CA25.2 12.86,45.23 12.19,44.57 12.19,44.12 CA31.2 ; CA20.2 3.35,43.71 3.68,43.38 CA21.2 4.8,43.38 v2(4.88,43.3) ; CA29.2 2.8,35.41 v2(3.02,35.19) 2.41,34.58 RA94.2
DV12S: length 16.8
  IN6 w0.508: v2(332.26,38.17) 332.87,37.56 332.87,34.81 333.62,34.06 334.63,34.06 v2(335.15,33.54)
  BOTTOM w0.203: 336.98,35.32 336.98,35.55 337.52,36.09 UR1.10 ; 336.26,37.8 336.98,37.8 337.09,37.69 UR1.14
  BOTTOM w0.508: 336.26,37.8 335.93,37.47 334.39,37.47 333.93,37.93 CR2.1 ; 336.98,35.32 336.61,34.96 336.61,33.08 CR5.1 335.45,32.91 v1(335.42,32.94) 335.15,33.21 v2(335.15,33.54)
DV33_18: length 1.1
  BOTTOM w0.178: 338.66,40.12 338.66,39.87 338.98,39.55 UR1.18
  vias: v1(338.55,40.49)
GND: length 4310.1
  TOP w0.102: v2(335.15,108.53) v3(335.92,108.53) ; CV1000.2 247.91,61.29 ; v2(342.71,85.1) v3(342.71,84.46)
  TOP w0.127: v3(113.83,13.38) v2(113.83,14.07) ; v2(28.46,78.6) v3(27.79,78.6) ; v2(319.68,29.6) v3(319.68,30.27) ; v2(328.55,85.15) v3(328.55,85.92)
  TOP w0.203: v2(53.43,19.05) 53.56,18.92 53.56,18.41 53.45,18.31 PU300.22 ; v2(311.34,34.51) 311.44,34.61 UZ1.11 ; UA4.11 v2(9.49,8.26) ; UZ7.11 v2(241.59,4.5) ; 215.84,50.75 215.27,50.17 215.27,49.54 v2(215.33,49.48) 215.75,49.05 215.75,47.16 216.11,46.81 219.33,46.81 v2(219.33,46.81) 219.69,46.81 220.61,47.74 220.61,48.32 220.11,48.82 220.11,50.66 219.84,50.94 219.84,51.44 219.65,51.63 219.65,52.47 219.15,52.97 219.15,53.24 218.59,53.8 217.18,53.8 v2(216.54,53.16) 215.84,52.46 215.84,50.75
  TOP w0.254: UZ24.5 210.59,48.11 v2(210.57,48.08) ; DT14.2 v2(10.12,67.48) ; DT22.2 v2(6.48,72.94) ; RZ86.2 172.42,4.04 v2(172.57,4.2) ; UZ16.5 131.62,68.2 132.07,68.64 CZ57.2 ; DT18.2 11.46,64.31 v2(11.72,64.56) ; CT163.2 27.85,40.19 v2(27.36,39.69) 27.72,39.33 RT1.2 ; CV992.2 248.92,81.79 v2(248.92,81.83) ; 105.92,28.45 106.66,28.45 106.93,28.18 v2(106.93,27.82) 106.85,27.74 v2(106.85,26.22) 106.85,24.31 106.68,24.14 106.55,24.14 106.55,24.14 106.55,24.14 v2(106.55,24.14) v2(104.78,24.14) 103.44,24.14 v2(103.32,24.27) ; 105.92,28.45 v2(104.53,28.45) 104.34,28.65 102.93,28.65 v2(102.74,28.46) 102.23,27.95 101.6,27.95 101.23,27.58 v2(101.23,27.34) 100.8,26.91 v2(100.8,26.37) 100.8,26.05 101.47,25.37 101.47,24.96 102.1,24.34 102.1,24.34 102.17,24.27 v2(103.32,24.27) ; 105.92,28.45 105.98,28.39 YH2.4 ; YH2.2 104.04,25.44 CH48.2 103.2,24.38 v2(103.32,24.27) ; CH196.2 87.98,6.89 87.71,7.16 87.71,7.72 87.44,7.99 v2(87.29,7.99) ; v2(155.51,8.33) 155.93,8.74 UE1.9 ; JXDP.37 126.8,94.51 126.34,94.05 v2(126.34,94.05) ; DT13.2 11.47,67.74 v2(11.7,67.51) ; DT23.2 v2(11.18,74.02) ; DT25.2 7.71,60.52 v2(7.72,60.53) ; UE1.16 152.43,10.17 152.72,10.46 v2(152.72,10.78) ; DT19.2 10.7,62.79 v2(10.65,62.74) ; UZ21.3 167.28,3.68 v2(167.11,3.51) ; UN3.5 v2(334.96,102.42) ; RZ32.1 194.95,7.6 194.64,7.91 193.23,7.91 193.11,7.78 UE6.5 ; v2(150.81,5.5) 151.25,5.93 UE1.23 ; DT24.2 11.32,72.06 v2(11.67,71.7) ; DT15.2 11.1,67 v2(10.71,67.38) ; DT16.2 v2(11.18,65.11) ; v2(11.79,69.39) 11.64,69.24 DT12.2 ; v2(155.93,3.78) UE1.32 ; UI1.14 v2(22.99,90.96) ; DT17.2 v2(10.31,64.65)
  TOP w0.279: v2(126.33,100.12) 126.47,99.98 126.55,99.98 126.63,99.89 127.06,99.89 127.18,100.01 JXDP.59 ; JXDP.31 129.31,93.01 129.63,92.69 129.63,91.74 v2(129.67,91.7)
  TOP w0.305: v2(6.67,17.79) 6.4,18.06 JAUDIO.7 ; JXDP.13 127.11,88.51 126.39,89.23 v2(126.39,89.35) 127.04,90.01 128.19,90.01 JXDP.19 ; JXDP.26 121.37,91.51 120.96,91.1 v2(120.98,91.1) ; v2(122.92,84.52) 123.6,84.52 123.94,84.86 123.94,85.29 123.72,85.51 JXDP.2 ; JXDP.7 129.83,87.01 v2(130,87.18) ; v2(129.67,97.2) 129.63,97.2 129.32,97.51 JXDP.49 ; UE3.B54 294.69,18.38 294.94,18.13 v2(295.16,18.13) ; v2(120.91,87.21) 121.1,87.01 JXDP.8 ; v2(129.67,91.7) 129.47,91.51 JXDP.25 ; v2(31.39,32.06) 30.88,32.06 30.75,31.94 PQ206.3 ; v2(3.81,18.8) 4,18.99 JAUDIO.1 ; JXDP.32 121.21,93.01 120.97,92.78 v2(120.97,92.57) ; JXDP.50 124.08,97.51 v2(124.09,97.52) ; UE3.B60 v2(295.19,15.38) ; JXDP.20 124.6,90.01 v2(124.69,90.1) ; v2(219.22,75.12) 219.22,75.07 218.6,74.44 RV602.1 ; UE3.B11 300.02,11.16 300.05,11.18 300.05,11.95 v2(300.29,12.19) ; UE3.B66 v2(295.12,12.38) ; UF1.15 239.26,48.44 239.5,48.21 v2(239.61,48.21) 239.61,48.73 239.4,48.94 UF1.16 ; PU204.3 v2(9.08,1.45) ; UF1.10 236.89,46.21 v2(236.86,46.17) ; v2(304.31,10.91) 303.84,11.38 UE3.B18 ; CT72.2 28.92,35 v2(28.69,34.77) 28.34,34.77 28.16,34.95 CT71.2 ; JXDP.14 v2(120.97,88.51) ; UF1.5 v2(236.39,50.84) ; v2(120.96,94.65) 121.1,94.51 JXDP.38
  TOP w0.356: UI4.3 27.45,82.65 RI8.1 ; RH423.2 60.44,3.37 CZ19.2 ; RT43.1 RT40.1 RT38.1 ; CT82.2 CT81.2 v2(26.63,34.77) ; RA57.2 CA19.2 3.19,29.21 3.3,29.09 v2(3.48,29.09) ; CA130.2 3.77,35.02 v2(3.75,35.04) ; CT99.2 26.04,37.73 v2(26.06,37.74) ; v2(20.58,55.95) 21.36,56.74 CT161.2 ; v2(24.56,34.81) 24.56,35.26 RT164.1 ; RH77.2 61.6,10.77 61.2,10.37 61.2,9.94 61.34,9.8 UH7.3 ; RT12.2 25.97,35.29 CT80.2 v2(26,34.77) ; v2(26.06,39.69) 25.88,39.52 CT100.2 ; v2(9.3,9.97) 9.11,9.78 CA124.2 CA125.2 ; v2(28.01,37.09) 27.97,37.13 CT93.2 ; CV883.1 204.15,80.21 v2(204.16,80.2) ; CA1.2 v2(14.16,34.22)
  TOP w0.381: CV1040.2 238.3,83.2 238.3,83.16 v2(237.77,82.64) ; v2(33.29,42.02) 33.81,42.53 CT50.2 ; v2(4.57,31.62) 4.65,31.53 CA38.2 ; CT63.2 29.17,43.7 v4(29.31,43.56) ; v2(241.12,66.58) 240.87,66.83 CV1019.2 ; v2(210.57,48.08) 210.3,47.81 CZ98.2 ; QV13.3 21.53,77.34 21.9,77.71 21.9,78.7 20.96,79.64 v2(20.89,79.64) ; RH188.2 133.08,73.02 133.54,73.48 133.73,73.48 133.76,73.5 133.77,73.5 134.14,73.87 v2(134.14,74.04) ; QZ15.4 163.78,116.47 164.05,116.2 CV919.2 ; PC1031.2 215.02,71.43 214.63,71.83 v2(214.37,71.83) ; CV898.2 203,77.72 203.33,78.05 203.33,78.52 CV890.2 ; v2(13.27,21.3) 13.33,21.3 13.34,21.31 16.08,21.31 PR240.2 ; v2(20.28,62.02) 20.07,61.81 RT431.1 ; UC1.3 124.38,54.51 123.16,55.73 v2(123.16,56.1) ; v2(244.41,2.8) 244.45,2.76 244.45,2.09 244.43,2.07 RZ74.2 ; CT65.2 26.16,40.24 v2(26.06,40.34) ; UZ18.3 126.27,67.56 v2(126.27,67.56) ; v2(300.84,6.6) 300.9,6.54 CE24.2 ; v2(244.12,83.43) 243.76,83.08 RV615.2 ; UZ11.3 179.32,4.72 v2(178.81,5.22) ; RH565.2 82.35,6.31 82.35,5.54 v2(82.74,5.15) ; CH204.2 85.5,5.63 v2(85,5.14) 85.18,4.96 85.28,4.96 85.41,4.83 CH70.2 ; v2(199.06,75.17) 199.06,75.08 199.65,74.49 200.72,74.49 200.86,74.35 CV859.2 ; v2(8.76,21.32) 8.97,21.32 9.41,21.76 PR263.2 ; CV865.2 199.44,77.29 v2(199.11,77.62) ; CV1018.2 244.88,64.94 v2(245.68,64.14) ; v2(12.38,5.6) CA127.2 12.38,4.33 12.14,4.09 PR270.2 ; v2(23.46,42.94) 23.46,42.55 CT143.2 ; UZ20.3 180.14,5.14 v2(179.87,5.41) ; UZ23.3 v2(105.22,52.06) ; v2(17.18,81.29) DV5.3 13.98,81.29 v2(13.83,81.13) ; PQ101.3 37.43,31.87 37.18,31.62 v2(36.9,31.62) ; 117.21,97.11 117.21,97.71 117.77,98.27 117.77,99.32 PC1107.2 ; UV28.3 177.18,112.35 177.01,112.52 v2(177.01,112.8) ; CT94.2 29.4,38.26 CT66.2 30.06,37.85 v2(29.96,37.74) ; QZ16.4 156.84,118.54 156.67,118.7 156.11,118.7 v2(155.91,118.5) ; QZ14.4 v2(220.53,119.04) ; v2(60.39,4.14) 60.57,3.96 RH423.2 ; PC1508.2 212.89,70.19 v2(213.39,69.69) ; v2(19.24,34.24) RT43.1 ; v2(221.97,118.31) 222.54,117.74 QZ14.1 ; CH173.2 CH80.2 89.16,8.85 89.16,10.5 89.58,10.92 v2(89.71,10.92) ; RT3.1 25.15,48.3 v2(25.33,48.49) ; UZ12.3 174.43,4.71 174.66,4.95 RZ71.2 ; CZ43.2 37.85,24.9 36.64,26.11 v2(36.51,26.11) ; JUSB2.7 335.16,72.3 DI9.3 ; CV889.2 206.72,80.29 v2(206.67,80.24) ; v2(216.79,75.97) 216.81,76 216.81,76.02 216.86,76.06 216.86,76.62 CV900.2 ; RT437.2 29.59,55.57 v2(30.1,55.06) ; CT68.2 CT67.2 31.41,37.56 v4(31.23,37.74) ; v2(31.68,28.6) 33.25,28.6 34.05,29.4 PQ231.3 ; v2(13.41,85.16) 13.6,85.35 DV4.3 v2(17.11,85.35) ; v2(22.76,60.41) 22.67,60.5 CT145.2 ; CA126.2 v2(9.34,3.84) ; 252.62,55.62 v2(252.86,55.86)
  TOP w0.406: UV19.3 227.92,44.31 v2(227.59,44.64) ; DI7.3 20.37,101.99 v2(20.38,102) ; v2(249.67,47.15) 249.65,47.15 249.62,47.13 249.5,47.13 249.1,46.72 QV3.1 ; v2(255.14,45.54) 255.35,45.33 QZ7.4 ; UZ19.3 121.54,57.54 122.05,57.03 v2(122.3,57.03) ; QZ17.1 250.82,43.24 v2(251.17,42.9) 251.17,42.4 251.63,41.94 QZ17.4 ; QZ6.4 252.62,55.62 ; UV20.3 198.14,44.22 v2(198.63,44.71)
  TOP w0.432: v2(225.53,44.62) 225.35,44.8 QV104.4 ; QZ6.1 251.32,52.65 251.46,52.51 v2(251.46,52.23) ; v2(224.05,44.51) QV104.1
  TOP w0.457: v2(212.3,66.76) 212.47,66.94 PC1503.2 ; PC1516.2 205.18,74.1 205.35,73.93 v2(205.35,73.79) ; v2(311.57,15.22) 311.67,15.33 QE4.1 ; UE4.6 279.18,9.58 CE55.2 ; PC1027.2 207.33,76.72 206.82,77.22 PC1009.2 ; PC1515.2 209.91,72.3 v2(210.38,71.83) 210.5,71.7 PC1512.2 ; v2(8.45,25.28) 8.88,24.85 PR264.1 ; 215.58,68.59 216.57,68.59 CV885.2 ; PC1507.2 213.49,76.02 213.67,75.84 v2(214.18,75.84) ; PC1011.2 207.52,69.76 v2(208.34,68.93) ; v2(206.54,66.74) 206.54,66.65 206.25,66.37 PC1010.2 ; v2(326.01,49.79) 326.01,49.34 RI13.1 325.36,49.49 UI5.3 ; CV1044.2 245.94,63.97 245.85,64.07 245.76,64.07 245.68,64.14 v2(245.68,64.14) ; v2(236.92,80.23) 236.9,80.21 236.9,79.64 CV995.2 ; CH51.1 96.14,6.3 v2(96.14,6.96)
  TOP w0.508: PC1269.2 164.42,70.14 PC1248.2 ; PC1269.2 164.01,70.56 v2(163.62,70.56) ; PC1269.2 164.45,70.37 PC1243.2 ; v2(347.47,82.81) 347.28,83 CH44.2 ; CV884.1 214.96,66.8 215.73,66.03 CV888.2 216.69,66.03 v2(216.74,65.97) ; CV887.2 206.2,78.88 205.84,79.23 v2(205.84,79.33) ; v2(194.12,9.74) 193.7,9.33 CE65.2 ; RT429.2 24.04,59.24 v2(24.84,59.24) ; CH202.2 104.29,11.5 v2(104.59,11.21) ; RH544.2 110.7,5.28 v2(110.76,5.22) ; CD5.2 150.22,28.65 v2(150.53,28.34) ; v2(150.48,19.37) 150.19,19.09 CD18.2 RD30.2 ; v2(311.38,21.55) 311.3,21.47 CE22.2 ; CV979.2 234.41,108.89 v2(234.41,109.18) ; RZ41.2 280.28,19.95 280.28,19.26 v2(280.48,19.06) ; v2(145.32,72.37) 144.93,72.37 PC1304.2 ; v2(205.95,107.58) 206.05,107.48 CV936.2 ; CV947.2 v2(225.81,113.29) ; CN2.2 334.6,106.69 v2(335.22,106.69) ; v2(247.27,79.45) 247.89,78.83 CV998.2 ; v2(227.07,110.38) 226.3,111.15 CV982.2 ; v2(29.74,25.39) 29.67,25.46 PC299.2 29.08,24.72 PR271.2 ; RH529.2 109.22,6.73 v2(109.69,7.2) ; v2(216.74,67.62) 216.79,67.68 CV885.2 ; PR403.1 349.34,21.98 v2(349.57,21.75) 349.57,21.13 PC400.2 ; v2(178.81,86.75) 179.57,86.75 179.63,86.81 CZ97.2 ; CD24.2 219.25,20.38 218.64,20.98 v2(218.15,20.98) ; v2(226.45,52.94) RV643.1 RV653.1 ; PC225.2 13.92,3.88 v2(14.05,4.01) ; v2(207.52,77.8) 207.35,77.63 PC1009.2 ; 139.87,27.76 140.38,27.25 CD72.2 ; 139.87,27.76 139.87,28.43 v2(139.87,28.43) ; 139.87,27.76 139.87,27.75 139.37,27.25 CD8.2 ; PC1363.2 155.13,70.74 v2(154.78,70.74) ; CH123.2 162.45,62.93 v2(162.06,63.32) ; CD82.2 218.48,27.59 v2(219.16,27.59) 219.83,27.59 CD81.2 ; v2(234.05,16.86) 234.05,16.86 233.88,16.7 RH210.2 ; CD23.2 216.68,27.25 v2(216.17,27.75) ; PC1374.2 147.83,70.8 v2(147.55,70.8) ; v2(299.02,5.78) 298.71,6.09 CE51.2 ; QV96.3 243.13,94.24 v2(242.44,94.93) ; CH112.2 CH113.2 173.1,87.51 v2(172.82,87.79) ; CE55.2 280.06,9.28 v2(280.19,9.16) ; v2(238.52,66.51) 238.33,66.7 238.33,67.17 CV1043.2 ; CV850.2 218.48,78.46 v2(218.4,78.39) ; CE31.2 v2(305.56,10.98) ; CE77.2 v2(184.85,6.37) ; CV902.2 215.01,79.45 v2(215.08,79.38) ; CV976.2 204.52,111.45 CV932.2 203.4,111.4 203.37,111.36 v2(203.16,111.36) ; v2(247.32,66.51) 246.92,66.51 246.51,66.1 CV1048.2 ; JRTC.2 v2(331,105.67) ; CA128.2 v2(6.58,8.77) ; v2(26.67,22.87) 27.05,23.25 PC201.2 27.04,23.57 PC205.2 PC206.2 ; v2(222.42,82.58) 223.37,82.58 223.65,82.3 CV872.2 ; v2(153.02,67.87) 153.03,67.89 PC1332.2 ; CV938.2 236.54,110.5 v2(236.01,109.98) ; v2(204.41,76.72) 204.15,76.46 PC1514.2 ; v2(41.99,27.41) 41.99,27.41 41.99,27.42 42.87,28.3 UZ8.2 ; PC1101.2 117.67,112.11 118,112.44 PC1102.2 v2(118.62,113.12) ; CE23.2 304.2,24.56 v2(304.2,24.95) ; v2(160.48,6.85) 160.62,6.98 160.62,7.62 160.29,7.95 RE13.2 ; CH46.2 100.38,1.81 v2(100.42,1.85) ; PC1518.2 v2(175.01,115.01) 174.82,114.82 CV917.2 ; v2(111.68,8.36) 111.89,8.16 UH14.3 ; CV880.1 201.55,85.54 v2(202.06,86.05) ; RE70.1 285.87,8.87 v2(285.36,9.37) ; PR1516.1 v2(175.99,119.77) ; PC1339.2 145.41,68.81 v2(145.7,68.52) ; UV21.3 220.79,45.54 220.73,45.47 v2(220.41,45.47) ; CN9.2 v2(335.15,108.53) ; v2(208.33,98.77) 208.68,99.12 CV929.2 ; PC1305.2 144.93,74.6 v2(145.39,74.6) ; v2(191.77,81.67) 191.94,81.5 CV878.2 ; v2(124.27,104.34) 124.21,104.28 PR1129.2 PC1114.2 PC1115.2 ; RD39.2 v2(251.33,24.22) ; v2(125.76,108.81) PC1110.2 125.74,108.01 PC1116.2 ; PC1032.2 206.25,64.97 205.68,64.4 CV851.2 204.8,64.56 204.8,64.96 v2(204.34,65.41) ; v2(248.1,27.9) 247.99,27.79 CD34.2 247.99,25.9 CD35.2 ; v2(307.29,12.54) CE19.2 CE18.2 ; CV1007.2 247.96,59.46 v2(248.12,59.3) ; v2(142.3,20.98) 142.55,20.98 142.95,20.59 CD6.2 ; RT5.2 32.53,35.58 32.63,35.48 CT164.2 ; CE70.2 290.32,6.3 v2(289.91,5.88) ; v2(61.15,26.5) 60.51,25.87 RV114.2 ; v2(227.01,108.76) 226.83,108.76 226.56,109.03 226.4,109.03 CV981.2 ; v2(223.2,63.28) 223.53,62.95 CV897.1 ; PC1012.2 205.56,77.58 v2(206.37,76.77) ; CT164.2 32.27,34.87 v2(31.97,35.18) ; CT164.2 33.19,34.31 CT165.2 ; CD85.2 226.4,28.65 v2(226.72,28.32) ; PC1239.2 v2(158.86,78.64) ; CE13.2 152.72,11.68 v2(152.72,10.78) ; PD100.2 v2(14.03,76.84) ; CH189.2 98.57,9.52 v2(98.3,9.25) 98.87,8.68 RH401.1 ; PU203.2 29.23,21.29 29.43,21.5 30.05,21.5 30.42,21.87 31.09,21.87 ; RV654.1 v2(229.12,52.99) ; RV654.1 RV644.1 ; RV654.1 RV652.1 228.23,52.72 v2(228.47,52.97) ; CE76.2 159.58,9.91 159.83,9.67 v2(159.83,9.01) 159.22,9.01 CE75.2 ; JCR.19 349.6,42.75 v2(349.6,42.75) ; v2(229.61,106.78) 229.69,106.86 CV952.2 ; v2(204.27,106.97) 204.53,106.7 CV926.2 ; v2(248.12,87.43) 248.17,87.38 CV993.2 ; v2(175.65,116.09) 175.78,115.96 PC1501.2 ; v2(231.31,110.68) 231.44,110.55 CV942.2 ; CE12.2 148.65,5.43 CE14.2 148.91,4.58 v2(149.35,4.14) ; v2(78.71,11.51) 78.28,11.08 CH191.2 ; CH183.2 85.59,17.86 v2(85.81,17.64) ; v2(244.49,44.95) 244.03,44.95 CV1500.2 ; PC1036.2 215.11,68.12 215.58,68.59 ; v2(155.24,77.86) 155.52,77.86 155.84,77.54 PC1375.2 155.94,78.65 PC1330.2 PC1338.2 ; v2(16.38,111.86) 16.35,111.9 H18.1 ; CH102.2 174.47,69.92 v2(174.51,69.96) ; v2(216.61,106.54) 217.93,105.22 CV961.2 ; RA74.2 12.47,39.18 v2(12.97,38.68) ; v2(205.35,73.79) 205.42,73.71 PC1023.2 ; RZ40.2 37.98,29.09 v2(37.72,29.09) ; v2(240.12,89.84) 240.12,89.99 239.78,90.33 CV994.2 239.79,90.55 CV988.2 ; v2(218.41,65.15) 218.64,64.92 CV894.2 ; v2(222.51,110.16) RV625.2 224.57,110.16 CV927.2 ; JCR.15 350.32,50.25 v2(349.89,50.68) ; CV853.2 228.09,46.97 227.62,47.44 v2(227.36,47.44) ; v2(347.32,115.25) 347.89,115.82 CE16.2 CE15.2 ; H26.1 v2(344.93,81.61) ; CV1024.2 246.38,85.61 246.64,85.35 v2(246.71,85.35) ; PC1038.2 216.63,73.58 v2(216.74,73.47) ; v2(77.98,2.74) 77.51,2.27 RH455.1 ; v2(172.26,77.89) 172.65,77.49 CH104.2 ; CN7.2 v2(335.28,105.86) ; CH119.2 155.89,68.39 v2(155.77,68.51) ; RE27.2 300.98,28.08 v2(301.01,28.11) 301.04,28.11 301.88,27.26 RE33.1 RE32.1 ; v2(178.79,83.93) 177.5,83.93 CH117.2 ; v2(285.75,6.46) 285.75,6.46 285.75,6.24 286.94,5.04 CE71.2 ; v2(84.62,17.29) 84.66,17.33 RH528.2 ; RV1128.2 v2(179.15,112.65) ; PC1348.2 150.24,76.02 PC1306.2 148.9,76.44 v2(148.5,76.44) ; PC1233.2 167.97,69.73 PC1223.2 167.46,68.74 v2(167.65,68.55) ; v2(215.86,19.95) 215.87,19.94 CD22.2 215.87,18.62 CD83.2 ; CV1051.2 214.82,77.61 213.98,76.77 CV1050.2 213.98,76.03 v2(214.18,75.84) ; CE37.2 284.97,13.24 v2(284.97,13.07) ; v2(175.08,85.38) 174.67,84.97 CH116.2 ; PC1532.2 v2(179.33,118.12) ; v2(18.92,92.02) 19.11,92.02 19.62,91.51 UV16.2 ; v2(152.1,67.87) 151.96,68.02 CH118.2 ; PC1376.2 PC1377.2 150.54,77.92 v2(150.16,77.92) 150.16,78.23 149.7,78.69 PC1322.2 PC1321.2 ; v2(309.22,16.99) 309.22,17.51 CE48.2 ; v2(289.12,20.71) 289.12,21.03 290.2,22.11 CE34.2 ; v2(246.13,66.68) 246.13,66.78 245.82,67.08 CV1042.2 ; CV864.1 218.44,87.38 218.95,86.88 220.06,86.88 v2(220.23,86.7) ; CV945.2 v2(221.87,113.29) ; RH580.2 95.59,15.36 v2(95.59,16.12) ; DL1.1 343.19,114.94 v2(343.07,114.82) ; v2(209.16,79.48) 209.29,79.36 CV903.2 208.37,78.66 CV921.2 ; RZ88.2 109.87,52.09 v2(110.36,52.59) ; v2(213.06,78.73) 213.23,78.56 213.85,78.56 CV923.2 ; v2(239.03,51.92) 238.92,51.92 238.81,52.03 CF2.2 ; CV975.2 208.6,111.32 v2(209.04,110.88) 209.59,110.88 CV965.2 ; v2(236.92,66.51) 236.34,67.09 CV1046.2 ; v2(216.74,70.97) 216.69,70.93 CV922.2 ; YV1.2 220.09,47.99 v2(220.13,48.03) ; PC1327.2 PC1334.2 147.62,78.46 v2(147.62,77.92) 148,77.92 PC1314.2 ; CZ46.2 v2(244.86,6.77) ; CZ8.2 306.16,31.81 305.86,31.5 v2(305.86,31.29) ; v2(206.33,68.8) 206.25,68.72 PC1039.2 ; PC1232.2 161.43,68.86 161.08,68.51 v2(160.33,68.51) ; CH200.2 93.59,6.85 94.07,7.34 v2(94.16,7.34) ; v2(224.04,104.47) 223.63,104.06 QV95.3 ; RV581.2 RV1073.2 221.68,48.6 v2(221.49,48.41) ; CV1030.2 240.96,95.58 v2(240.36,96.17) ; v2(340.87,99.89) 340.87,99.96 340.63,100.2 RN33.1 ; QZ18.3 218.39,115.9 v2(218.39,113.1) ; v2(195.45,119.68) 195.84,119.3 PC1534.2 ; v2(210.86,79.37) 211.02,79.22 CV901.2 ; v2(25.46,30.81) 25.46,31.25 25.21,31.51 PQ211.3 ; v2(170.56,27.74) 170.9,27.39 CD16.2 170.9,26.13 171.02,26.02 CD17.2 ; RV601.1 215.58,84.69 216.03,84.25 216.03,84.15 216.45,83.73 216.45,83.39 217.14,82.7 v2(217.51,82.7) ; RI27.2 325.78,54.6 v2(325.31,55.06) 324.82,54.57 CI22.2 ; v2(90.81,7.05) 91.09,7.32 CH186.2 ; CD36.2 267.42,20.65 266.68,19.91 v2(266.68,19.92) ; CE2.2 190.39,6.41 v2(190.44,6.36) 191.14,6.36 191.22,6.44 UE6.9 ; CV1032.2 243.51,90.56 v2(243.32,90.56) ; v2(214.75,97.98) 214.9,97.83 CV971.2 ; v2(220.54,110.82) 220.78,110.58 CV925.2 ; v2(199.16,67.6) 198.95,67.39 CV891.2 ; CH111.2 170.58,81.51 v2(171.17,81.51) 171.17,81.3 171.81,80.66 CH108.2 ; v2(332.17,103.77) 332.3,103.89 CN1.2 ; RV619.2 239.28,103.63 v2(238.51,104.4) ; v2(240.86,62.49) 240.92,62.54 RV616.2 ; CN6.2 v2(336.04,105.67) ; CH187.2 v2(100.14,4.5) ; v2(293.79,25) 293.79,24.43 CE39.2 ; CV950.2 232.68,108.03 232.03,107.38 v2(231.63,107.38) ; v2(245.32,86.51) 245.05,86.78 CV1039.2 ; RH581.2 98.07,11.74 v2(98.32,11.49) ; RT183.2 24.79,61.3 CT158.2 26.08,61.3 26.34,61.57 v2(26.39,61.57) ; CE78.2 185.93,8.24 185.75,8.42 v2(185.75,8.82) ; v2(146.56,28.43) 146.56,28.41 146.62,28.47 CD1.2 ; v2(212.41,111.51) 212.18,111.28 CV962.2 ; PR902.2 240.08,111.46 239.71,111.83 CV937.2 238.95,112.59 v2(238.63,112.91) ; CV499.2 245.89,48.61 v2(246.34,49.07) ; v2(196.66,85.1) 197.68,86.11 CV879.2 ; v2(248.12,62.5) 248.02,62.41 248.02,61.91 247.91,61.79 247.91,61.29 ; CV179.2 15.25,87.83 15.14,87.94 CV178.2 14.18,87.39 v2(13.4,87.39) ; PC1137.2 112.45,114.05 v2(112.22,114.28) ; v2(145.07,20.04) 145.07,19 145.4,18.67 CD70.2 ; v2(169.05,78.38) PC1231.2 PC1240.2 169.05,81.23 v2(168.76,81.51) ; DA9.2 14.99,45.54 15.21,45.32 v2(15.21,45.29) ; PC1342.2 149.22,68.26 CH124.2 149.61,67.87 v2(150.27,67.87) ; PC1007.2 210.07,76.53 v2(210.32,76.78) ; v2(245.25,83.68) 245.23,83.7 CV1035.2 ; CA39.2 5.28,31.62 v2(4.57,31.62) ; CV919.2 163.25,115.53 v2(163.13,115.64) ; v2(28.28,82.58) 28.16,82.46 RI8.1 ; 333.25,31.5 v2(332.42,31.5) ; CD20.2 212.93,20.05 212.25,20.74 v2(212.08,20.74) ; v2(182.5,86.31) 181.98,86.83 CZ96.2 ; v2(237.61,101.18) 237.7,101.09 CV953.2 ; RH186.2 132.02,69.88 v2(132.07,69.83) CZ57.2 ; v2(249.94,60.21) CV1009.2 250.64,59.64 CV1004.2 ; PC1006.2 208.22,72.78 v2(208.34,72.91) ; CD74.2 139.57,19.23 v2(139.9,19.56) ; SW1.4 v2(331.41,118.15) ; PQ205.3 27.33,33.23 v2(27.09,33.47) ; CV1033.2 237.92,86.43 v2(237.72,86.63) ; CZ18.2 RZ46.1 56.95,7.82 55.88,7.82 CZ11.2 55.88,8.08 56.32,8.51 v2(56.54,8.51) ; v2(162.16,66.61) 162.05,66.72 CH125.2 ; v2(120.03,1.81) 119.77,2.07 SW4.5 ; PC1271.2 161.91,71.51 PC1276.2 161.53,71.89 v2(161.15,71.89) ; RT2.2 30.32,43.06 29.96,43.42 v4(29.96,43.57) ; v2(204.37,71.83) 204.43,71.76 PC1034.2 204.98,71.19 PC1014.2 ; CI1.2 v2(23.86,86.66) ; v2(306.02,18.35) 306.02,18.68 CE52.2 ; CV1002.2 247.27,67.51 v2(247.38,67.62) ; v2(208.93,110.19) 209.19,109.93 209.19,109.03 CV930.2 ; CD19.2 211.31,18.79 211.31,21.57 211.84,22.11 v2(212.08,22.11) ; v2(50.29,13.47) 49.54,14.22 PC319.2 ; RV617.2 226.88,107.4 v2(227.09,107.19) 227.09,107.2 227.53,107.2 CV980.2 ; PQ232.3 v2(31,6.29) ; v2(3.43,33.92) 4.01,33.33 CA77.2 ; v2(216.08,109.98) 215.72,110.33 CV969.2 ; RV655.1 v2(224.42,53.09) ; CV1021.2 236.14,92.13 v2(237.15,92.13) ; JAUDIO.31 2.24,20.15 3.11,19.28 v2(3.11,18.86) ; PC1359.2 150.09,74.94 PC1310.2 ; v2(163.52,78) PC1230.2 PC1229.2 ; CV857.1 v2(216.46,51.8) ; PD101.1 11.81,12.98 11.2,13.59 JAUDIO.20 ; v2(20.28,62.02) 20.6,62.02 20.92,61.71 CT146.2 ; v2(178.79,88.17) 178.4,87.79 CH114.2 ; v2(161.21,70.62) 161.59,70.62 PC1261.2 ; v2(105.21,11.21) 105.36,11.36 105.64,11.36 106.85,12.57 CH201.2 ; CE43.2 CE42.2 v2(289.64,12) ; CH133.2 172.38,86.79 v2(171.88,86.79) ; RH498.1 131.71,104.8 v2(131.28,104.36) ; PC1131.2 115.43,99.28 115.43,97.99 114.85,97.41 114.27,97.41 113.79,97.89 113.34,97.89 112.9,98.32 v2(112.9,98.92) 113.44,98.92 PR1138.1 ; v2(250.77,19.79) 251.41,19.15 CD90.2 ; CV869.2 195.13,87.89 v2(194.89,88.13) ; CV895.2 212.19,61.71 212.19,61.7 v2(211.96,61.92) ; CV943.2 233.42,110.37 v2(232.9,109.86) ; v2(248.62,90.93) 248.66,90.89 CV1031.2 ; CT160.2 26.26,63.73 25.83,64.16 CT159.2 25.19,64.16 24.22,65.13 24.22,65.68 v2(24.56,66.02) ; CE40.2 303.63,4.93 v2(303.88,4.93) ; v2(173.86,66.81) 174.19,67.14 CZ49.2 ; CN22.2 336.12,103.46 v2(336.61,103.96) ; YV1.4 216.07,49.69 v2(215.77,49.98) ; PC1132.2 116.59,97.6 v2(116.1,97.11) ; CV886.2 203,80.67 CV883.1 ; CZ4.2 v2(307.98,33.66) ; CH106.2 176.33,82.44 v2(176.45,82.56) 176.45,83.08 CH105.2 ; v2(33.88,3.95) 34.48,3.35 PC329.2 ; v2(297.99,22.7) 297.99,22.73 298.02,22.75 CE44.2 RE61.2 298.17,24.39 298.35,24.22 CE27.2 ; v2(24.83,26.36) 24.83,26.14 25.54,25.43 PQ225.3 ; SW4.4 111.62,2.92 112.1,3.4 v2(112.1,3.76) ; v2(14.63,35.5) 14.94,35.8 CA2.2 ; CR14.2 328.76,48.58 v2(328.93,48.41) ; PR1110.2 119.7,112.3 v2(120.16,112.76) 120.59,112.33 PR1109.2 ; UE2.1 347.44,119.97 v2(347.44,120.66) ; PC1340.2 147.38,68.64 v2(147.5,68.53) ; v2(201.68,83.44) 201.68,83.44 201.68,83.45 201.59,83.54 CV882.2 ; CV1038.2 CV997.2 v2(238,92.12) ; UV17.4 66.58,23.8 v2(66.66,23.72) ; CH120.2 170.36,65.19 v2(170.39,65.22) ; CV944.2 v2(223.2,113.29) ; v2(21.59,30.62) 21.51,30.54 PR217.2 ; CE38.2 v2(288.2,14.94) ; v2(123.83,111.64) 124.22,111.25 PR1116.2 ; v2(112.17,99.55) PR1137.2 PC1129.2 ; PC1362.2 PC1350.2 154.33,72.53 v2(153.97,72.53) ; CV893.2 216.79,62.7 v2(216.66,62.57) ; QF1.4 235.9,42.1 v2(235.41,41.61) ; CH103.2 172.72,72.34 v2(172.31,71.93) ; v2(238.33,108.37) 238.33,108.58 237.95,108.96 CV984.2 ; v2(24.13,10.61) 24.13,10.8 23.64,11.3 PQ229.3 ; JRTC.4 v2(333.85,97.34) ; CV875.2 202.96,76.15 v2(203.41,75.7) ; v2(250.38,92.91) 250.08,92.6 CV1037.2 248.11,92.97 CV1020.2 ; CH107.2 173.91,79.18 CH110.2 174.33,78.41 v2(174.52,78.6) ; PC1502.2 205.05,66.15 v2(204.43,66.77) ; UZ22.3 122.37,65.17 RZ87.2 121.26,67.22 v2(120.84,67.64) ; v2(2.46,59.25) RA95.1 4.03,59.25 DA5.2 ; CI21.2 RI26.2 v2(27.43,88.22) ; CV892.2 213.79,63.79 214.17,63.41 v2(214.17,63.37) ; v2(245.71,89.06) 245.7,89.07 RV632.2 ; CV1023.2 249.68,79 v2(249.68,79.38) ; PC1341.2 PC1335.2 145.2,78.58 v2(145.2,78.04) 144.92,78.04 PC1379.2 ; PC1382.2 170.47,76.23 v2(170.88,76.23) ; SW2.2 v2(348.63,112.78) ; v2(26.58,27.14) 26.35,27.37 25.86,27.37 25.59,27.63 25.59,28.71 25.18,29.12 PQ208.3 ; PC1221.2 168.55,69.11 v2(168.55,68.54) PC1247.2 ; PR1108.2 121.55,112.3 v2(122.01,112.76) 122.44,112.33 PR1107.2 ; CD41.2 CD40.2 267.51,3.39 v2(267.03,2.9) ; v2(187.52,11.92) 187.52,12.39 187.3,12.61 DE5.1 ; v2(62.36,10.61) 62.22,10.61 62.02,10.82 RH77.2 ; PC1138.1 109.55,108.26 108.97,108.85 v2(108.97,109.23) ; v2(208.25,44.62) 208.03,44.84 RV550.2 ; RH95.1 104.36,10.17 105.02,9.51 105.02,8.78 105.03,8.77 v2(105.03,8.34) ; v2(179.85,3.95) 179.63,3.73 RZ85.2 ; RE74.1 RE75.1 283.83,15.76 284.65,16.58 284.65,17.13 285.08,17.56 v2(285.3,17.56) ; CV939.2 240.34,99.04 CV955.2 238.44,99.84 v2(238.44,100.4) 238.75,100.4 238.94,100.59 CV941.2 ; PC1352.2 PC1360.2 154.23,75.19 v2(153.85,75.19) ; v2(249.94,63.26) 250.32,62.87 CV1005.2 CV1006.2 ; PR105.2 37.58,34.9 38.11,35.43 41.45,35.43 42.09,36.07 v2(42.09,36.83) ; v2(231.4,106.38) 231.36,106.41 230.93,106.41 230.63,106.12 CV949.2 ; v2(102.74,28.46) 103.13,28.08 CH47.2 ; RE44.2 289.21,16.44 289.38,16.44 v2(289.57,16.25) ; v2(66.54,31.71) 65.86,32.38 CV156.2 ; JAUDIO.33 1.9,13.57 v2(2.25,13.21) ; v2(120.94,52.29) 120.46,52.77 CH197.2 ; v2(249.75,64.97) 249.54,64.77 CV1015.2 ; JCR.4 329.4,51.85 329.19,51.63 v2(329.12,51.63) ; CD76.2 v2(136.63,19.45) ; v2(154.39,79.19) 153.88,79.7 PC1329.2 PC1331.2 ; v2(159.5,63.24) 158.89,63.24 CD7.2 ; CD26.2 v2(210.65,27.99) ; CV996.2 250.65,88.77 250.14,88.26 v2(249.78,88.26) ; v2(220.72,20.41) 221.21,20.41 222.24,19.37 CD87.2 ; CH180.2 75.72,27.19 v2(75.12,26.59) ; QF1.1 234.33,43.71 v2(234.7,44.08) ; v2(93.29,16.12) 93.68,16.5 CH82.2 ; v2(117.22,97.11) 117.21,97.11 117.36,97.27 PC1126.2 ; CV1049.2 200.66,66.3 v2(200.89,66.08) ; CH109.2 176.15,80.84 176.79,80.84 177.1,80.53 v2(177.1,80.22) ; PC1055.2 173.32,115.2 173.87,114.64 v2(173.88,114.64) ; PC613.2 293.21,28.91 293.86,28.91 294.26,29.31 v2(294.26,29.6) ; v2(289.56,13.53) 290.06,14.03 CE21.2 CE20.2 ; v2(145.13,70.8) 145.41,70.8 PC1378.2 ; PC1364.1 114.69,95.03 v2(114.63,95.09) ; v2(169.57,86.04) 169.87,86.04 170.38,86.55 170.38,86.89 170.08,87.19 CH134.2 ; v2(152.37,70.8) 152.65,70.8 PC1372.2 ; v2(222.74,28.26) 222.96,28.47 CD80.2 ; CH174.2 v2(131.14,93.73) ; RE31.1 v2(310.44,17.01) ; v2(175.45,21.1) 175.45,19.57 CD13.2 174.6,18.72 CD12.2 ; v2(315.41,40.97) 316.21,40.97 QI10.3 ; CV1022.2 240.12,79.41 v2(240.12,80.23) ; PQ233.3 20.91,11.25 20.53,10.87 v2(20.53,10.72) ; RZ71.2 175.86,4.95 v2(176.16,5.25) ; CH176.2 85.46,7.49 85.18,7.21 v2(84.87,7.21) ; v2(248.1,83.51) 247.92,83.33 CV991.2 ; RT199.2 28.59,59.38 28.59,59.38 29.04,58.94 v2(29.18,58.94) ; CV863.2 222.12,86.62 CV873.1 222.44,85.92 v2(222.82,85.54) ; CE53.2 v2(273.72,7.06) ; v2(104.96,2.83) 105.47,2.83 CH53.2 ; v2(167.27,78.38) PC1224.2 PC1225.2 ; v2(249.12,66.62) 250.19,66.62 250.57,67 CV1003.2 ; QV102.3 243.98,91.43 244.12,91.3 v2(244.12,91.29) ; v2(238.13,96.92) 237.44,97.6 CV985.2 ; RV642.1 v2(225.43,52.94) ; RE30.2 298.45,3.83 v2(298.04,3.43) ; v2(29.27,15.19) 27.13,15.19 26.62,15.69 PD102.1 25.81,15.69 25.02,16.49 PC218.2 ; CZ12.2 v2(316.74,37.22) ; v2(194.25,60.91) 194.25,61.24 CV866.2 ; RH209.2 123.81,17.05 124.16,16.71 v2(124.27,16.71) ; CE28.2 289.82,18.09 289.2,18.09 288.35,18.93 v2(288.35,19.02) ; CE54.2 280.08,8.39 v2(280.19,8.5) ; v2(199.65,110.24) 199.22,109.82 PQ700.3 ; v2(170.86,79.19) 170.48,79.19 PC1386.2 ; CI12.2 18.23,106.63 v2(17.81,107.04) ; v2(109.41,66.11) 109.03,65.73 PC800.2 ; v2(246.08,16.86) 246.09,16.86 246.09,17.63 246.89,18.44 RD38.2 ; QR104.3 272.6,8.65 RE143.1 272.34,9.91 v2(271.97,9.91) ; CV907.2 v2(210.31,52.21) ; v2(91.23,12.22) 91.44,12.01 CH203.2 ; v2(241.71,86.65) 242.34,86.65 CV1036.2 ; PC1310.2 148.84,74.53 v2(148.43,74.53) ; PC1310.2 149.82,73.55 PC1361.2 ; CV972.2 215.77,106.88 216.21,107.31 CV978.2 216.63,107.31 v2(217.64,108.32) 216.85,109.1 CV960.2 ; CF1.2 240.75,44.15 v2(240.75,43.63) ; PC1300.2 PC1303.2 148.71,72.37 v2(148.31,72.37) ; PR404.2 v2(349.56,19.82) ; v2(208.35,105.18) 208.55,104.98 RV620.2 ; v2(145.45,76.44) 145,76.44 PC1311.2 ; v2(172.98,118.75) 173,118.73 PC1041.2 ; RV636.2 247.97,95.39 CV989.2 v2(247.96,96.15) ; v2(244.12,59.3) 244.44,59.3 CV1041.2 ; CV956.2 CV954.2 238.66,107.27 v2(238.36,107.57) ; PC419.2 338.96,20.29 v2(338.96,20.77) 339.17,20.98 PC418.2 ; v2(111.1,110.73) PC1100.1 PC1103.1 ; v2(201.66,60.06) 200.97,60.75 CV854.2 ; RV107.2 55.47,26.91 v2(55.47,26.48) ; PR406.2 v2(349.56,18.04) ; CD84.2 227.93,19.85 v2(227.44,19.85) 227.44,19.15 227.49,19.1 RD40.2 CD29.2 ; RZ80.2 129.82,67.95 v2(129.82,67.96) ; v2(208.56,106.38) 209.17,106.99 CV935.2 ; PC1033.2 210,68.4 210.3,68.71 v2(210.43,68.71) ; RV566.2 211.68,43.9 v2(211.65,43.94) ; PR812.2 107.13,65.67 v2(107.51,66.05) ; CV1026.2 v2(236.03,97.25) ; PQ223.3 15.04,3.14 v2(15.43,2.74) ; CZ6.2 v2(307.91,35.06) ; PC1351.2 154.49,73.53 PC1353.2 154.16,73.86 v2(153.78,73.86) ; RZ50.2 v2(110.55,64.51) ; CD32.2 250.82,18.87 CD90.2 ; PC1029.2 208.93,74.23 v2(208.34,74.81) 207.96,74.43 PC1025.2 ; CD21.2 212.86,27.62 v2(213.06,27.82) ; PC1109.2 110.99,105.86 110.71,105.59 110.71,105.58 v2(110.43,105.29) ; v2(159.34,81.49) 159.78,81.06 PC1246.2 ; CH188.2 94.77,14.22 v2(94.77,13.76) ; CD25.2 214.5,27.25 v2(213.99,27.76) ; RH211.2 120.74,19.24 120.08,19.9 v2(120.08,20.47) ; v2(331.79,44.97) 331.72,44.9 JCR.7 ; v2(220.04,62.61) 220.04,63.25 220.03,63.25 CV896.1 ; v2(200.34,96.41) 199.61,97.14 CV856.2 198.03,97.14 197.99,97.1 CV855.2 ; CH121.2 151,64.51 v2(151.19,64.7) ; CV948.2 231.96,105.17 v2(231.17,105.17) ; v2(193.26,83.35) 193.26,83.29 193.85,82.7 CV924.2 ; CV958.2 218.66,109.42 v2(219.05,109.03) ; v2(29.72,2.68) 29.45,2.94 PQ222.3 ; CH190.2 78.6,13.93 v2(78.74,13.79) ; v2(152.27,79.21) 151.84,79.64 PC1325.2 PC1324.2 ; PC335.2 v2(349.06,26.81) ; DE2.1 v2(347,110.94) ; v2(165.36,78) PC1226.2 PC1241.2 ; v2(174.29,112.02) 173.96,111.68 173.96,111.41 173.61,111.06 PR1016.1 ; v2(214.75,101.18) 214.88,101.3 CV973.2 ; v2(200.03,62.58) 200.81,62.58 CV852.2 ; v2(169.86,119.4) 169.86,118.74 PC1017.2 ; CZ9.2 v2(314.14,39.32) ; PC1121.2 v2(124.08,108.02) ; RV579.2 222.36,52.34 222.38,52.36 RV656.1 222.44,52.43 222.38,52.49 v2(222.38,53.35) ; PR405.1 v2(347.98,24.41) ; v2(78.73,9.26) 78.28,9.26 77.9,8.89 RH567.2 ; CR15.2 v2(327.48,51.83) ; CD78.2 v2(142.86,27.61) CD79.2 ; v2(51.03,10.8) 50.61,11.22 PC334.2 ; CH135.2 169.89,84.09 169.53,83.73 v2(169.53,83.43) ; v2(310.08,13.47) 310.37,13.76 QE4.4 ; v2(230.43,97.99) 230.59,98.15 CV983.2 ; CV951.2 238.3,113.55 v2(238.63,113.55) ; PC1209.2 v2(150.94,102.24) ; JTAG1.2 v2(298.44,26.06) ; RV580.1 227.47,42.5 v2(227.09,42.12) ; PR501.2 PC500.2 v2(131.57,1.53) ; CV1028.2 CV1029.2 CV1027.2 v2(239.74,95.75) ; PR508.2 v2(136.46,2.14) ; PC1104.1 v2(110.36,107.13) ; v2(255.33,19.78) 254.86,19.78 CD88.2 CD89.2 CD90.2 ; CD75.2 138.15,19.46 v2(138.16,19.47) ; CH52.2 91.94,5.22 v2(91.83,5.11) ; v2(133.14,16.9) 133.28,17.04 133.28,17.76 CD69.2 ; v2(227.21,99.65) 226.86,99.65 226.85,99.64 226.3,99.1 CV986.2 226.3,98.1 CV940.2 ; v2(194.24,6.36) 194.24,6.57 194.75,7.08 RZ32.1 ; v2(266.01,19.91) 266.01,18.91 266.37,18.55 CD39.2 CD38.2 ; H35.1 16.47,94.6 v2(16.51,94.56) ; v2(175.95,61.99) 175.81,61.99 175.39,62.4 CH128.2 ; CT155.2 21.67,56.55 CT161.2 ; PC1220.2 168.2,71.19 v2(168.58,71.19) 168.58,70.76 168.87,70.47 PC1222.2 ; v2(50.1,19.19) 49.77,18.86 PC320.2 ; RV109.2 52.34,26.69 v2(52.59,26.44) ; CE41.2 RE58.2 v2(307.21,8.47) ; CV1034.2 CV1013.2 250.64,84.07 250.51,84.2 v2(250.45,84.2) ; CZ45.2 237.55,6.76 v2(237.57,6.75) ; v2(95.37,9.39) 95.73,9.03 RH88.1 ; PC1385.2 170.67,74.81 v2(171.05,74.81) ; CD73.2 135.09,27.27 v2(134.28,28.08) ; v2(134.81,19.44) 135.18,19.07 CD77.2 ; v2(211.4,106.24) 211.4,106.23 CV931.2 ; CV974.2 214.87,99.46 v2(214.75,99.58) ; JCR.12 v2(349.81,54.8) ; v2(237.62,105.1) 237.69,105.18 CV957.2 ; v2(171.34,16.87) 171.34,17.39 RD28.2 ; CD71.2 148.65,19.6 v2(147.6,20.66) ; v2(20.87,91) 21.39,90.48 RI6.2 RI7.2 ; v2(223.16,79.19) 223.16,79.94 CV870.2 ; v2(132.86,74.04) 132.86,74.43 132.96,74.52 RH185.2 132.93,74.79 132.08,74.79 RH187.2 ; CV918.2 177.98,113.04 177.25,113.04 v2(177.01,112.8) ; PC1349.2 154.54,76.21 PC1354.2 154.16,76.59 v2(153.78,76.59) ; v2(198.95,72.7) 198.96,72.72 CV860.2 ; v2(211.33,73.79) 211.46,73.92 PC1513.2 ; CV1010.2 v2(243.97,61.41) ; PC503.2 v2(134.62,5.96) ; CH45.2 v2(100.46,2.74) ; v2(96.6,37.3) 96.6,37.58 96.98,37.96 98.1,37.96 CE66.2 ; CV928.2 219.05,105.41 v2(219.05,105.42) ; RV631.2 v2(242.7,69.06) ; v2(167.66,65.34) 167.8,65.2 CH126.2 ; v2(176.16,19.62) 176.15,19.6 CD14.2 CD15.2 ; v2(248.88,83.4) 248.88,83.79 CV1025.2 ; PC903.2 v2(243.08,114.18) ; CE11.2 v2(159.16,4.17) ; v2(133.64,78.01) 133.45,78.2 RH184.2 132.47,78.2 RH183.2 ; PC1323.2 v2(156.73,69.97) ; RV651.1 v2(223.45,53.09) ; v2(149.55,9.55) 149.56,9.56 149.56,9.88 149.57,9.9 149.57,10.11 149.85,10.38 CE8.2 ; CE25.2 RE57.2 v2(308.15,15.33) ; CV906.2 v2(213.95,53.64) ; v2(149.96,70.8) 150.24,70.8 PC1373.2 150.67,70 151.13,69.54 PC1333.2 ; v2(203.34,79.33) 203.47,79.2 CV890.2 ; v2(136.76,27.82) 136.56,27.62 CD2.2 ; v2(223.33,86.03) 223.52,86.22 CV899.2 ; CD86.2 225.34,18.68 226.26,19.6 v2(226.26,21.03) ; v2(65.04,31.72) 65.51,31.25 CV157.2 ; CN8.2 v2(335.22,107.64) ; CE67.2 v2(322.84,36.71) ; CH122.2 158.33,67.38 v2(158.5,67.21) ; PC1326.2 v2(154.89,68.53) ; v2(162.15,68.51) 162.35,68.72 PC1245.2 ; v2(203.67,107.67) 203.7,107.69 CV977.2 ; PC1244.2 PC1242.2 v2(161.62,78.04) ; CV946.2 v2(224.54,113.29) ; v2(176.76,9.46) 176.76,14.1 177.86,15.2 PR1804.2 ; CH127.2 170.23,67.04 170.39,66.87 v2(170.39,66.58) ; PR410.2 v2(349.56,17.09) ; CV970.2 213.48,111.02 213.15,110.7 v2(213.15,109.98) ; QV101.3 v2(219.4,106.09) ; v2(158.54,81.45) 157.87,80.78 PC1320.2 PC1328.2 v2(157.87,78.62) ; PQ220.3 v2(28.58,2.57) ; v2(232.3,16.86) 232.3,16.85 231.96,16.51 RH212.2 ; CV817.2 208.46,52.41 v2(208.85,52.02) ; CE17.2 v2(291.21,11.25) ; RE85.1 v2(152.45,3.65) ; CV858.1 v2(219.15,51.8) ; JRTC.3 v2(326.9,101.55) ; PC1390.2 170.67,73.48 v2(171.05,73.48) 171.05,73.14 170.74,72.82 PR810.1 ; SW2.1 v2(348.63,109.11)
  GND1 w0.203: 248.05,71.11 H5.1 ; H5.1 248.05,75.89 ; H5.1 246.31,71.76 ; H5.1 246.31,75.24 ; H5.1 250.44,73.5 ; H5.1 245.66,73.5 ; H5.1 249.79,71.76 ; H5.1 249.79,75.24 ; JUSBC1.B12 6.94,68.22 ; JUSBC1.B12 6.55,68.13 ; JUSBC1.B12 6.16,69 ; JUSBC1.B12 7.03,68.61 ; 15.7,5.89 H37.1 ; H37.1 15.7,9.95 ; H37.1 14.21,9.41 ; H37.1 14.21,6.43 ; H37.1 13.67,7.92 ; H37.1 17.19,6.43 ; H37.1 17.19,9.41 ; H37.1 17.73,7.92 ; JHDMI1.21 5.53,92.93 ; JHDMI1.21 2.87,92.93 ; JHDMI1.21 2.87,93.91 ; JHDMI1.21 5.53,93.91 ; JHDMI1.21 4.2,93.91 ; JHDMI1.17 12.22,87.88 ; JHDMI1.17 12.33,87.43 ; JHDMI1.17 11.21,87.43 ; JHDMI1.17 11.32,87.88 ; JHDMI1.17 11.32,86.98 ; JHDMI1.17 12.22,86.98 ; H16.1 188.18,89.77 ; H16.1 187.53,88.03 ; H16.1 185.79,87.38 ; H16.1 183.4,89.77 ; H16.1 184.05,91.51 ; H16.1 185.79,92.16 ; H16.1 184.05,88.03 ; H16.1 187.53,91.51 ; JCR.23 350.22,35.17 ; JCR.23 350.22,35.9 ; JCR.23 348.85,35.9 ; JCR.23 350.22,34.45 ; JCR.23 347.48,34.45 ; JCR.23 348.85,34.45 ; JCR.23 347.48,35.9 ; JCR.23 347.48,35.17 ; H46.1 129.49,61.76 ; H46.1 127.75,57.63 ; H46.1 129.49,58.28 ; H46.1 126.01,61.76 ; H46.1 127.75,62.41 ; H46.1 125.36,60.02 ; H46.1 130.14,60.02 ; H46.1 126.01,58.28 ; 11.77,75.7 JHDMI1.23 ; JHDMI1.23 11.77,77.66 ; JHDMI1.23 13.1,77.66 ; JHDMI1.23 10.44,75.7 ; JHDMI1.23 10.44,76.68 ; JHDMI1.23 10.44,77.66 ; JHDMI1.23 13.1,76.68 ; JUSB1.11 15.8,108.74 ; JUSB1.11 14.29,110.46 ; JUSB1.11 14.29,108.74 ; JUSB1.11 15.8,110.46 ; JUSB1.11 15.8,109.6 ; 346.79,64.19 JUSB2.12 ; JUSB2.12 346.79,65.05 ; JUSB2.12 349.81,65.05 ; JUSB2.12 348.3,64.19 ; JUSB2.12 349.81,64.19 ; 10.44,92.16 JHDMI1.20 ; JHDMI1.20 13.1,90.2 ; JHDMI1.20 11.77,92.16 ; JHDMI1.20 11.77,90.2 ; JHDMI1.20 13.1,91.18 ; JHDMI1.20 10.44,90.2 ; JHDMI1.20 10.44,91.18 ; JHDMI1.20 13.1,92.16 ; 4.57,60.49 JUSBC1.4 ; JUSBC1.4 5.8,61.93 ; JUSBC1.4 4.57,61.93 ; JUSBC1.4 7.03,60.49 ; JUSBC1.4 7.03,61.21 ; JUSBC1.4 5.8,60.49 ; JUSBC1.4 4.57,61.21 ; 14.68,98.86 JUSB1.4 ; JUSB1.4 14.04,99.06 ; JUSB1.4 14.68,100.54 ; JUSB1.4 15.33,100.34 ; JUSB1.4 13.84,99.7 ; JUSB1.4 14.04,100.34 ; JUSB2.4 337.96,75.81 ; JUSB2.4 337.32,77.29 ; JUSB2.4 337.96,77.09 ; JUSB2.4 338.16,76.45 ; JUSB2.4 337.32,75.61 ; JUSB2.4 336.67,75.81 ; 1.57,61.21 JUSBC1.3 ; JUSBC1.3 2.8,61.93 ; JUSBC1.3 2.8,60.49 ; JUSBC1.3 1.57,60.49 ; JUSBC1.3 4.03,61.93 ; JUSBC1.3 4.03,60.49 ; JUSBC1.3 1.57,61.93 ; JUSBC1.3 4.03,61.21 ; 2.8,69.69 JUSBC1.1 ; JUSBC1.1 1.57,70.41 ; JUSBC1.1 2.8,71.13 ; JUSBC1.1 1.57,69.69 ; JUSBC1.1 1.57,71.13 ; JUSBC1.1 4.03,71.13 ; JUSBC1.1 4.03,69.69 ; JUSBC1.1 4.03,70.41 ; JHDMI1.8 11.13,82.93 ; JHDMI1.8 11.02,82.48 ; JHDMI1.8 10.01,82.93 ; JHDMI1.8 10.12,82.48 ; JHDMI1.8 11.02,83.38 ; JHDMI1.8 10.12,83.38 ; 333.33,34.45 JCR.22 ; JCR.22 333.33,35.17 ; JCR.22 333.33,35.9 ; JCR.22 336.07,34.45 ; JCR.22 334.7,34.45 ; JCR.22 336.07,35.9 ; JCR.22 336.07,35.17 ; JCR.22 334.7,35.9 ; JUSB1.12 5.21,111.1 ; JUSB1.12 2.19,111.1 ; JUSB1.12 3.7,111.96 ; JUSB1.12 2.19,111.96 ; JUSB1.12 5.21,111.96 ; 4.57,71.13 JUSBC1.2 ; JUSBC1.2 4.57,69.69 ; JUSBC1.2 7.03,70.41 ; JUSBC1.2 5.8,69.69 ; JUSBC1.2 5.8,71.13 ; JUSBC1.2 7.03,71.13 ; JUSBC1.2 4.57,70.41 ; H13.1 140.66,104.83 ; H13.1 141.31,103.09 ; H13.1 138.92,105.48 ; H13.1 136.53,103.09 ; H13.1 138.92,100.7 ; H13.1 137.18,104.83 ; H13.1 140.66,101.35 ; H13.1 137.18,101.35 ; 347.48,60.62 JCR.21 ; JCR.21 350.22,59.9 ; JCR.21 350.22,60.62 ; JCR.21 347.48,61.35 ; JCR.21 350.22,61.35 ; JCR.21 348.85,59.9 ; JCR.21 348.85,61.35 ; JCR.21 347.48,59.9 ; JUSB2.7 335.82,73.79 ; JUSB2.7 336.66,72.95 ; JUSB2.7 336.46,72.31 ; JUSB2.7 334.98,72.95 ; JUSB2.7 335.17,72.31 ; JUSB2.7 335.17,73.59 ; JUSB2.7 335.82,72.11 ; JUSB2.7 336.46,73.59 ; H40.1 348,4.68 ; H40.1 346.76,4.24 ; H40.1 349.24,4.24 ; H40.1 346.76,1.76 ; H40.1 348,1.32 ; H40.1 349.24,1.76 ; H40.1 346.32,3 ; H40.1 349.68,3 ; 142.36,3.18 H42.1 ; H42.1 145.04,5.86 ; H42.1 143.7,6.35 ; H42.1 143.7,2.69 ; H42.1 145.04,3.18 ; H42.1 141.87,4.52 ; H42.1 145.53,4.52 ; H42.1 142.36,5.86 ; JCR.20 334.7,61.35 ; JCR.20 336.07,61.35 ; JCR.20 333.33,61.35 ; JCR.20 334.7,59.9 ; JCR.20 333.33,59.9 ; JCR.20 333.33,60.62 ; JCR.20 336.07,59.9 ; JCR.20 336.07,60.62 ; JUSB1.7 16.83,102.56 ; JUSB1.7 15.34,103.2 ; JUSB1.7 15.54,102.56 ; JUSB1.7 16.18,102.36 ; JUSB1.7 15.54,103.84 ; JUSB1.7 17.02,103.2 ; JUSB1.7 16.18,104.04 ; JUSB1.7 16.83,103.84 ; 337.71,78.49 JUSB2.14 ; JUSB2.14 336.2,79.35 ; JUSB2.14 337.71,80.21 ; JUSB2.14 336.2,78.49 ; JUSB2.14 336.2,80.21 ; H45.1 187.53,54.59 ; H45.1 185.79,58.72 ; H45.1 184.05,54.59 ; H45.1 183.4,56.33 ; H45.1 187.53,58.07 ; H45.1 188.18,56.33 ; H45.1 185.79,53.94 ; H45.1 184.05,58.07 ; 336.2,66.55 JUSB2.11 ; JUSB2.11 337.71,65.69 ; JUSB2.11 336.2,67.41 ; JUSB2.11 336.2,65.69 ; JUSB2.11 337.71,67.41 ; H10.1 4,5.68 ; H10.1 2.32,4 ; H10.1 2.76,5.24 ; H10.1 2.76,2.76 ; H10.1 5.68,4 ; H10.1 4,2.32 ; H10.1 5.24,2.76 ; H10.1 5.24,5.24 ; JUSB1.13 5.21,95.3 ; JUSB1.13 2.19,95.3 ; JUSB1.13 3.7,94.44 ; JUSB1.13 2.19,94.44 ; JUSB1.13 5.21,94.44 ; H41.1 208.3,6.35 ; H41.1 209.64,3.18 ; H41.1 208.3,2.69 ; H41.1 209.64,5.86 ; H41.1 210.13,4.52 ; H41.1 206.96,3.18 ; H41.1 206.96,5.86 ; H41.1 206.47,4.52 ; 120.99,116.79 H39.1 ; H39.1 122.67,118.47 ; H39.1 119.75,117.23 ; H39.1 120.99,120.15 ; H39.1 119.31,118.47 ; H39.1 122.23,117.23 ; H39.1 119.75,119.71 ; H39.1 122.23,119.71 ; 2.72,23.64 H38.1 ; H38.1 6.24,22.15 ; H38.1 6.24,25.13 ; H38.1 3.26,22.15 ; H38.1 6.78,23.64 ; H38.1 4.75,25.67 ; H38.1 4.75,21.61 ; H38.1 3.26,25.13 ; JHDMI1.5 12.22,80.98 ; JHDMI1.5 12.22,81.88 ; JHDMI1.5 11.32,80.98 ; JHDMI1.5 12.33,81.43 ; JHDMI1.5 11.21,81.43 ; JHDMI1.5 11.32,81.88 ; 346.79,80.85 JUSB2.13 ; JUSB2.13 349.81,80.85 ; JUSB2.13 348.3,81.71 ; JUSB2.13 346.79,81.71 ; JUSB2.13 349.81,81.71 ; 10.12,80.38 JHDMI1.2 ; JHDMI1.2 10.12,79.48 ; JHDMI1.2 10.57,79.37 ; JHDMI1.2 11.02,79.48 ; JHDMI1.2 11.02,80.38 ; JHDMI1.2 11.13,79.93 ; JHDMI1.2 10.01,79.93 ; 14.29,95.94 JUSB1.14 ; JUSB1.14 15.8,96.8 ; JUSB1.14 15.8,95.94 ; JUSB1.14 14.29,97.66 ; JUSB1.14 15.8,97.66 ; 341.47,13.3 H48.1 ; H48.1 346.53,13.3 ; H48.1 342.16,15.14 ; H48.1 344,10.77 ; H48.1 345.84,11.46 ; H48.1 344,15.83 ; H48.1 345.84,15.14 ; H48.1 342.16,11.46 ; 2.87,74.93 JHDMI1.22 ; JHDMI1.22 2.87,73.95 ; JHDMI1.22 5.53,74.93 ; JHDMI1.22 5.53,73.95 ; JHDMI1.22 4.2,73.95 ; JUSBC1.B1 6.55,63.49 ; JUSBC1.B1 6.16,62.62 ; JUSBC1.B1 6.94,63.4 ; 11.21,84.43 JHDMI1.11 ; JHDMI1.11 12.22,83.98 ; JHDMI1.11 11.32,84.88 ; JHDMI1.11 12.33,84.43 ; JHDMI1.11 12.22,84.88 ; JHDMI1.11 11.32,83.98
  IN1 w0.203: 101.98,25.92 101.73,25.66 101.03,25.66 100.8,25.89 v2(100.8,26.37) 100.8,26.91 v2(101.23,27.34) 101.64,27.34 101.98,27 101.98,25.92
  IN1 w0.508: v2(12.97,38.68) 13.96,39.67 13.96,42.64 13.77,42.83 13.77,44.51 14.54,45.28 15.21,45.28 v2(15.21,45.29)
  IN2 w0.203: 101.73,25.66 101.03,25.66 100.8,25.89 v2(100.8,26.37) 100.8,26.91 v2(101.23,27.34) 101.64,27.34 101.98,27 101.98,25.92 101.73,25.66
  GND2 w0.203: H37.1 17.73,7.92 ; H37.1 14.21,9.41 ; H37.1 15.7,9.95 ; H37.1 17.19,6.43 ; H37.1 17.19,9.41 ; H37.1 14.21,6.43 ; H37.1 13.67,7.92 ; H37.1 15.7,5.89 ; 344,10.77 H48.1 ; H48.1 344,15.83 ; H48.1 341.47,13.3 ; H48.1 342.16,15.14 ; H48.1 345.84,15.14 ; H48.1 342.16,11.46 ; H48.1 346.53,13.3 ; H48.1 345.84,11.46 ; H13.1 140.66,104.83 ; H13.1 136.53,103.09 ; H13.1 138.92,100.7 ; H13.1 141.31,103.09 ; H13.1 138.92,105.48 ; H13.1 137.18,104.83 ; H13.1 137.18,101.35 ; H13.1 140.66,101.35 ; JUSBC1.3 4.03,61.21 ; JUSBC1.3 2.8,61.93 ; JUSBC1.3 2.8,60.49 ; JUSBC1.3 4.03,60.49 ; JUSBC1.3 1.57,60.49 ; JUSBC1.3 4.03,61.93 ; JUSBC1.3 1.57,61.93 ; JUSBC1.3 1.57,61.21 ; JUSBC1.2 7.03,71.13 ; JUSBC1.2 4.57,69.69 ; JUSBC1.2 4.57,71.13 ; JUSBC1.2 5.8,69.69 ; JUSBC1.2 5.8,71.13 ; JUSBC1.2 4.57,70.41 ; JUSBC1.2 7.03,70.41 ; 11.32,80.98 JHDMI1.5 ; JHDMI1.5 11.21,81.43 ; JHDMI1.5 12.22,80.98 ; JHDMI1.5 12.33,81.43 ; JHDMI1.5 12.22,81.88 ; JHDMI1.5 11.32,81.88 ; JHDMI1.11 12.22,83.98 ; JHDMI1.11 11.21,84.43 ; JHDMI1.11 11.32,83.98 ; JHDMI1.11 12.22,84.88 ; JHDMI1.11 11.32,84.88 ; JHDMI1.11 12.33,84.43 ; JUSBC1.B1 6.94,63.4 ; JUSBC1.B1 6.55,63.49 ; JUSBC1.B1 6.16,62.62 ; 246.31,71.76 H5.1 ; H5.1 245.66,73.5 ; H5.1 248.05,71.11 ; H5.1 248.05,75.89 ; H5.1 249.79,71.76 ; H5.1 246.31,75.24 ; H5.1 249.79,75.24 ; H5.1 250.44,73.5 ; H45.1 188.18,56.33 ; H45.1 183.4,56.33 ; H45.1 185.79,53.94 ; H45.1 184.05,54.59 ; H45.1 185.79,58.72 ; H45.1 184.05,58.07 ; H45.1 187.53,54.59 ; H45.1 187.53,58.07 ; 346.79,65.05 JUSB2.12 ; JUSB2.12 349.81,65.05 ; JUSB2.12 349.81,64.19 ; JUSB2.12 348.3,64.19 ; JUSB2.12 346.79,64.19 ; JHDMI1.2 11.02,80.38 ; JHDMI1.2 10.12,80.38 ; JHDMI1.2 10.01,79.93 ; JHDMI1.2 10.57,79.37 ; JHDMI1.2 11.13,79.93 ; JHDMI1.2 11.02,79.48 ; JHDMI1.2 10.12,79.48 ; 2.76,5.24 H10.1 ; H10.1 2.76,2.76 ; H10.1 4,5.68 ; H10.1 5.24,5.24 ; H10.1 2.32,4 ; H10.1 5.24,2.76 ; H10.1 4,2.32 ; H10.1 5.68,4 ; JUSB1.13 5.21,95.3 ; JUSB1.13 3.7,94.44 ; JUSB1.13 2.19,95.3 ; JUSB1.13 2.19,94.44 ; JUSB1.13 5.21,94.44 ; JHDMI1.8 11.02,82.48 ; JHDMI1.8 11.02,83.38 ; JHDMI1.8 10.01,82.93 ; JHDMI1.8 11.13,82.93 ; JHDMI1.8 10.12,82.48 ; JHDMI1.8 10.12,83.38 ; 14.29,95.94 JUSB1.14 ; JUSB1.14 14.29,97.66 ; JUSB1.14 15.8,97.66 ; JUSB1.14 15.8,95.94 ; JUSB1.14 15.8,96.8 ; 11.77,90.2 JHDMI1.20 ; JHDMI1.20 10.44,91.18 ; JHDMI1.20 11.77,92.16 ; JHDMI1.20 10.44,92.16 ; JHDMI1.20 13.1,91.18 ; JHDMI1.20 13.1,92.16 ; JHDMI1.20 13.1,90.2 ; JHDMI1.20 10.44,90.2 ; JCR.20 336.07,59.9 ; JCR.20 334.7,61.35 ; JCR.20 336.07,60.62 ; JCR.20 333.33,60.62 ; JCR.20 333.33,61.35 ; JCR.20 334.7,59.9 ; JCR.20 336.07,61.35 ; JCR.20 333.33,59.9 ; JUSB2.7 336.46,73.59 ; JUSB2.7 335.17,72.31 ; JUSB2.7 335.17,73.59 ; JUSB2.7 335.82,73.79 ; JUSB2.7 336.66,72.95 ; JUSB2.7 335.82,72.11 ; JUSB2.7 334.98,72.95 ; JUSB2.7 336.46,72.31 ; H38.1 6.78,23.64 ; H38.1 3.26,22.15 ; H38.1 4.75,25.67 ; H38.1 2.72,23.64 ; H38.1 6.24,22.15 ; H38.1 3.26,25.13 ; H38.1 4.75,21.61 ; H38.1 6.24,25.13 ; 336.2,65.69 JUSB2.11 ; JUSB2.11 336.2,67.41 ; JUSB2.11 337.71,67.41 ; JUSB2.11 336.2,66.55 ; JUSB2.11 337.71,65.69 ; 1.57,69.69 JUSBC1.1 ; JUSBC1.1 2.8,69.69 ; JUSBC1.1 4.03,71.13 ; JUSBC1.1 4.03,70.41 ; JUSBC1.1 2.8,71.13 ; JUSBC1.1 1.57,71.13 ; JUSBC1.1 1.57,70.41 ; JUSBC1.1 4.03,69.69 ; 11.77,75.7 JHDMI1.23 ; JHDMI1.23 11.77,77.66 ; JHDMI1.23 10.44,77.66 ; JHDMI1.23 13.1,76.68 ; JHDMI1.23 10.44,75.7 ; JHDMI1.23 13.1,77.66 ; JHDMI1.23 10.44,76.68 ; 15.34,103.2 JUSB1.7 ; JUSB1.7 16.83,102.56 ; JUSB1.7 15.54,102.56 ; JUSB1.7 16.83,103.84 ; JUSB1.7 16.18,102.36 ; JUSB1.7 17.02,103.2 ; JUSB1.7 16.18,104.04 ; JUSB1.7 15.54,103.84 ; JHDMI1.22 5.53,73.95 ; JHDMI1.22 4.2,73.95 ; JHDMI1.22 5.53,74.93 ; JHDMI1.22 2.87,74.93 ; JHDMI1.22 2.87,73.95 ; JCR.23 350.22,34.45 ; JCR.23 348.85,34.45 ; JCR.23 347.48,35.9 ; JCR.23 350.22,35.9 ; JCR.23 348.85,35.9 ; JCR.23 347.48,35.17 ; JCR.23 347.48,34.45 ; JCR.23 350.22,35.17 ; JCR.21 350.22,61.35 ; JCR.21 347.48,59.9 ; JCR.21 350.22,60.62 ; JCR.21 348.85,59.9 ; JCR.21 350.22,59.9 ; JCR.21 347.48,60.62 ; JCR.21 348.85,61.35 ; JCR.21 347.48,61.35 ; 119.75,119.71 H39.1 ; H39.1 119.31,118.47 ; H39.1 122.23,117.23 ; H39.1 119.75,117.23 ; H39.1 122.23,119.71 ; H39.1 122.67,118.47 ; H39.1 120.99,116.79 ; H39.1 120.99,120.15 ; H40.1 349.68,3 ; H40.1 348,4.68 ; H40.1 349.24,1.76 ; H40.1 349.24,4.24 ; H40.1 346.76,4.24 ; H40.1 346.32,3 ; H40.1 348,1.32 ; H40.1 346.76,1.76 ; 142.36,3.18 H42.1 ; H42.1 145.04,3.18 ; H42.1 143.7,2.69 ; H42.1 142.36,5.86 ; H42.1 145.53,4.52 ; H42.1 141.87,4.52 ; H42.1 143.7,6.35 ; H42.1 145.04,5.86 ; 127.75,57.63 H46.1 ; H46.1 127.75,62.41 ; H46.1 129.49,61.76 ; H46.1 126.01,61.76 ; H46.1 129.49,58.28 ; H46.1 125.36,60.02 ; H46.1 126.01,58.28 ; H46.1 130.14,60.02 ; 6.55,68.13 JUSBC1.B12 ; JUSBC1.B12 6.16,69 ; JUSBC1.B12 6.94,68.22 ; JUSBC1.B12 7.03,68.61 ; 333.33,35.17 JCR.22 ; JCR.22 333.33,35.9 ; JCR.22 334.7,34.45 ; JCR.22 336.07,35.9 ; JCR.22 334.7,35.9 ; JCR.22 336.07,35.17 ; JCR.22 333.33,34.45 ; JCR.22 336.07,34.45 ; JUSB1.12 5.21,111.1 ; JUSB1.12 2.19,111.1 ; JUSB1.12 5.21,111.96 ; JUSB1.12 3.7,111.96 ; JUSB1.12 2.19,111.96 ; JHDMI1.21 4.2,93.91 ; JHDMI1.21 2.87,92.93 ; JHDMI1.21 2.87,93.91 ; JHDMI1.21 5.53,92.93 ; JHDMI1.21 5.53,93.91 ; JUSB1.4 14.68,100.54 ; JUSB1.4 15.33,100.34 ; JUSB1.4 14.04,99.06 ; JUSB1.4 14.04,100.34 ; JUSB1.4 14.68,98.86 ; JUSB1.4 13.84,99.7 ; H41.1 208.3,6.35 ; H41.1 206.96,5.86 ; H41.1 209.64,3.18 ; H41.1 208.3,2.69 ; H41.1 206.96,3.18 ; H41.1 210.13,4.52 ; H41.1 206.47,4.52 ; H41.1 209.64,5.86 ; 346.79,80.85 JUSB2.13 ; JUSB2.13 349.81,81.71 ; JUSB2.13 348.3,81.71 ; JUSB2.13 349.81,80.85 ; JUSB2.13 346.79,81.71 ; 11.32,86.98 JHDMI1.17 ; JHDMI1.17 12.22,87.88 ; JHDMI1.17 11.32,87.88 ; JHDMI1.17 12.22,86.98 ; JHDMI1.17 12.33,87.43 ; JHDMI1.17 11.21,87.43 ; 336.2,80.21 JUSB2.14 ; JUSB2.14 337.71,78.49 ; JUSB2.14 337.71,80.21 ; JUSB2.14 336.2,79.35 ; JUSB2.14 336.2,78.49 ; JUSB2.4 337.96,75.81 ; JUSB2.4 337.32,77.29 ; JUSB2.4 338.16,76.45 ; JUSB2.4 337.32,75.61 ; JUSB2.4 337.96,77.09 ; JUSB2.4 336.67,75.81 ; JUSBC1.4 7.03,61.21 ; JUSBC1.4 5.8,61.93 ; JUSBC1.4 4.57,61.21 ; JUSBC1.4 4.57,61.93 ; JUSBC1.4 4.57,60.49 ; JUSBC1.4 7.03,60.49 ; JUSBC1.4 5.8,60.49 ; JUSB1.11 15.8,109.6 ; JUSB1.11 14.29,110.46 ; JUSB1.11 15.8,110.46 ; JUSB1.11 15.8,108.74 ; JUSB1.11 14.29,108.74
  IN3 w0.203: 101.73,25.66 101.03,25.66 100.8,25.89 v2(100.8,26.37) 100.8,26.91 v2(101.23,27.34) 101.64,27.34 101.98,27 101.98,25.92 101.73,25.66
  IN3 w0.508: v2(3.43,33.92) 3.43,33.46 4.57,32.32 v2(4.57,31.62)
  IN4 w0.203: 100.8,25.89 v2(100.8,26.37) 100.8,26.91 v2(101.23,27.34) 101.64,27.34 101.98,27 101.98,25.92 101.73,25.66 101.03,25.66 100.8,25.89
  VCC w0.203: 337.71,78.49 JUSB2.14 ; JUSB2.14 337.71,80.21 ; JUSB2.14 336.2,80.21 ; JUSB2.14 336.2,79.35 ; JUSB2.14 336.2,78.49 ; 10.44,90.2 JHDMI1.20 ; JHDMI1.20 10.44,91.18 ; JHDMI1.20 11.77,92.16 ; JHDMI1.20 13.1,90.2 ; JHDMI1.20 11.77,90.2 ; JHDMI1.20 13.1,91.18 ; JHDMI1.20 13.1,92.16 ; JHDMI1.20 10.44,92.16 ; 3.26,22.15 H38.1 ; H38.1 3.26,25.13 ; H38.1 2.72,23.64 ; H38.1 6.24,22.15 ; H38.1 4.75,21.61 ; 2.76,2.76 H10.1 ; H10.1 5.24,2.76 ; H10.1 2.32,4 ; H10.1 4,5.68 ; H10.1 5.24,5.24 ; H10.1 4,2.32 ; H10.1 5.68,4 ; H10.1 2.76,5.24 ; JUSB2.13 349.81,80.85 ; JUSB2.13 346.79,81.71 ; JUSB2.13 346.79,80.85 ; JUSB2.13 348.3,81.71 ; JUSB2.13 349.81,81.71 ; 347.48,61.35 JCR.21 ; JCR.21 350.22,59.9 ; JCR.21 347.48,60.62 ; JCR.21 348.85,59.9 ; JCR.21 350.22,61.35 ; JCR.21 350.22,60.62 ; JCR.21 348.85,61.35 ; JCR.21 347.48,59.9 ; H37.1 17.19,6.43 ; H37.1 17.73,7.92 ; H37.1 13.67,7.92 ; H37.1 14.21,9.41 ; H37.1 17.19,9.41 ; H37.1 14.21,6.43 ; H37.1 15.7,5.89 ; H37.1 15.7,9.95 ; JHDMI1.8 11.02,82.48 ; JHDMI1.8 11.02,83.38 ; JHDMI1.8 10.12,83.38 ; JHDMI1.8 11.13,82.93 ; JHDMI1.8 10.01,82.93 ; JHDMI1.8 10.12,82.48 ; JUSB1.4 15.33,100.34 ; JUSB1.4 13.84,99.7 ; JUSB1.4 14.04,100.34 ; JUSB1.4 14.68,98.86 ; JUSB1.4 14.68,100.54 ; JUSB1.4 14.04,99.06 ; JUSBC1.4 7.03,60.49 ; JUSBC1.4 7.03,61.21 ; JUSBC1.4 5.8,61.93 ; JUSBC1.4 4.57,60.49 ; JUSBC1.4 5.8,60.49 ; JUSBC1.4 4.57,61.21 ; JUSBC1.4 4.57,61.93 ; JUSB2.4 337.96,77.09 ; JUSB2.4 336.67,75.81 ; JUSB2.4 337.32,75.61 ; JUSB2.4 337.96,75.81 ; JUSB2.4 338.16,76.45 ; JUSB2.4 337.32,77.29 ; 336.2,65.69 JUSB2.11 ; JUSB2.11 337.71,65.69 ; JUSB2.11 336.95,65.69 ; 346.76,4.24 H40.1 ; H40.1 349.24,4.24 ; H40.1 348,4.68 ; H40.1 349.68,3 ; H40.1 348,1.32 ; H40.1 346.32,3 ; H40.1 346.76,1.76 ; H40.1 349.24,1.76 ; 334.98,72.95 JUSB2.7 ; JUSB2.7 336.66,72.95 ; JUSB2.7 336.46,73.59 ; JUSB2.7 335.17,73.59 ; JUSB2.7 335.82,73.79 ; JUSB1.13 5.21,94.44 ; JUSB1.13 5.21,95.3 ; JUSB1.13 2.19,95.3 ; JUSB1.13 3.7,94.44 ; JUSB1.13 2.19,94.44 ; JHDMI1.21 4.2,93.91 ; JHDMI1.21 5.53,93.91 ; JHDMI1.21 5.53,92.93 ; JHDMI1.21 2.87,93.91 ; JHDMI1.21 2.87,92.93 ; JUSBC1.1 4.03,71.13 ; JUSBC1.1 1.57,69.69 ; JUSBC1.1 1.57,70.41 ; JUSBC1.1 2.8,71.13 ; JUSBC1.1 2.8,69.69 ; JUSBC1.1 1.57,71.13 ; JUSBC1.1 4.03,69.69 ; JUSBC1.1 4.03,70.41 ; H39.1 120.99,120.15 ; H39.1 119.31,118.47 ; H39.1 122.67,118.47 ; H39.1 119.75,117.23 ; H39.1 122.23,119.71 ; H39.1 120.99,116.79 ; H39.1 119.75,119.71 ; H39.1 122.23,117.23 ; JHDMI1.5 12.22,81.88 ; JHDMI1.5 12.33,81.43 ; JHDMI1.5 11.21,81.43 ; JHDMI1.5 11.32,80.98 ; JHDMI1.5 11.32,81.88 ; JHDMI1.5 12.22,80.98 ; JUSB1.14 15.8,97.66 ; JUSB1.14 14.29,97.66 ; JUSB1.14 15.8,96.8 ; JUSB1.14 14.29,95.94 ; JUSB1.14 15.8,95.94 ; 10.44,76.68 JHDMI1.23 ; JHDMI1.23 10.44,75.7 ; JHDMI1.23 11.77,77.66 ; JHDMI1.23 10.44,77.66 ; JHDMI1.23 11.77,75.7 ; JHDMI1.23 13.1,77.66 ; JHDMI1.23 13.1,76.68 ; 1.57,60.49 JUSBC1.3 ; JUSBC1.3 4.03,60.49 ; JUSBC1.3 4.03,61.93 ; JUSBC1.3 1.57,61.93 ; JUSBC1.3 2.8,61.93 ; JUSBC1.3 1.57,61.21 ; JUSBC1.3 4.03,61.21 ; JUSBC1.3 2.8,60.49 ; JUSB2.12 349.81,65.05 ; JUSB2.12 346.79,65.05 ; JUSB2.12 348.3,64.19 ; JUSB2.12 346.79,64.19 ; JUSB2.12 349.81,64.19 ; JCR.23 350.22,35.9 ; JCR.23 348.85,34.45 ; JCR.23 347.48,35.9 ; JCR.23 348.85,35.9 ; JCR.23 350.22,34.45 ; JCR.23 347.48,35.17 ; JCR.23 350.22,35.17 ; JCR.23 347.48,34.45 ; 10.01,79.93 JHDMI1.2 ; JHDMI1.2 11.13,79.93 ; JHDMI1.2 10.57,79.37 ; JHDMI1.2 10.12,80.38 ; JHDMI1.2 11.02,79.48 ; JHDMI1.2 10.12,79.48 ; JHDMI1.2 11.02,80.38 ; JCR.20 336.07,61.35 ; JCR.20 336.07,60.62 ; JCR.20 333.33,59.9 ; JCR.20 333.33,61.35 ; JCR.20 336.07,59.9 ; JCR.20 334.7,59.9 ; JCR.20 334.7,61.35 ; JCR.20 333.33,60.62 ; JHDMI1.11 12.22,83.98 ; JHDMI1.11 12.22,84.88 ; JHDMI1.11 11.32,83.98 ; JHDMI1.11 11.21,84.43 ; JHDMI1.11 12.33,84.43 ; JHDMI1.11 11.32,84.88 ; JUSB1.11 14.29,110.46 ; JUSB1.11 15.8,110.46 ; JUSB1.11 14.29,108.74 ; JUSB1.11 15.8,108.74 ; JUSB1.11 15.8,109.6 ; 342.16,15.14 H48.1 ; H48.1 345.84,11.46 ; H48.1 345.84,15.14 ; H48.1 342.16,11.46 ; H48.1 346.53,13.3 ; H48.1 341.47,13.3 ; H48.1 344,15.83 ; H48.1 344,10.77 ; JUSBC1.2 7.03,70.41 ; JUSBC1.2 4.57,71.13 ; JUSBC1.2 5.8,69.69 ; JUSBC1.2 4.57,69.69 ; JUSBC1.2 7.03,71.13 ; JUSBC1.2 4.57,70.41 ; JUSBC1.2 5.8,71.13 ; JUSB1.7 17.02,103.2 ; JUSB1.7 16.83,103.84 ; JUSB1.7 15.34,103.2 ; JUSB1.7 15.54,102.56 ; JUSB1.7 15.54,103.84 ; JUSB1.7 16.18,102.36 ; JUSB1.7 16.18,104.04 ; JUSB1.7 16.83,102.56 ; JHDMI1.22 5.53,74.93 ; JHDMI1.22 4.2,73.95 ; JHDMI1.22 2.87,74.93 ; JHDMI1.22 2.87,73.95 ; JHDMI1.22 5.53,73.95 ; 2.19,111.96 JUSB1.12 ; JUSB1.12 5.21,111.96 ; JUSB1.12 2.19,111.1 ; JUSB1.12 3.7,111.96 ; JUSB1.12 5.21,111.1 ; JHDMI1.17 12.22,87.88 ; JHDMI1.17 11.32,86.98 ; JHDMI1.17 11.32,87.88 ; JHDMI1.17 12.22,86.98 ; JHDMI1.17 12.33,87.43 ; JHDMI1.17 11.21,87.43
  IN5 w0.203: 100.8,26.91 v2(101.23,27.34) 101.64,27.34 101.98,27 101.98,25.92 101.73,25.66 101.03,25.66 100.8,25.89 v2(100.8,26.37) 100.8,26.91
  IN5 w0.508: v2(21.09,41.64) 21.51,41.64 21.91,42.04 21.91,44.27 22.35,44.71 22.35,45.76 21.79,46.32 v2(21.68,46.32)
  IN6 w0.203: v2(100.8,26.37) 100.8,25.89 101.03,25.66 101.71,25.66 101.98,25.93 101.98,27 101.64,27.34 v2(101.23,27.34) 100.8,26.91 v2(100.8,26.37)
  GND3 w0.203: H10.1 4,5.68 ; H10.1 2.76,2.76 ; H10.1 2.32,4 ; H10.1 4,2.32 ; H10.1 5.68,4 ; H10.1 5.24,2.76 ; H10.1 5.24,5.24 ; H10.1 2.76,5.24 ; 184.05,91.51 H16.1 ; H16.1 183.4,89.77 ; H16.1 187.53,91.51 ; H16.1 187.53,88.03 ; H16.1 188.18,89.77 ; H16.1 185.79,87.38 ; H16.1 184.05,88.03 ; H16.1 185.79,92.16 ; 11.32,80.98 JHDMI1.5 ; JHDMI1.5 12.22,81.88 ; JHDMI1.5 11.32,81.88 ; JHDMI1.5 12.33,81.43 ; JHDMI1.5 11.21,81.43 ; JHDMI1.5 12.22,80.98 ; H39.1 122.67,118.47 ; H39.1 119.75,119.71 ; H39.1 120.99,116.79 ; H39.1 119.75,117.23 ; H39.1 122.23,119.71 ; H39.1 120.99,120.15 ; H39.1 122.23,117.23 ; H39.1 119.31,118.47 ; 3.26,22.15 H38.1 ; H38.1 6.24,25.13 ; H38.1 4.75,25.67 ; H38.1 6.78,23.64 ; H38.1 4.75,21.61 ; H38.1 2.72,23.64 ; H38.1 3.26,25.13 ; H38.1 6.24,22.15 ; JUSB1.12 3.7,111.96 ; JUSB1.12 5.21,111.96 ; JUSB1.12 5.21,111.1 ; JUSB1.12 2.19,111.96 ; JUSB1.12 2.19,111.1 ; JHDMI1.11 12.22,83.98 ; JHDMI1.11 11.32,83.98 ; JHDMI1.11 11.32,84.88 ; JHDMI1.11 12.22,84.88 ; JHDMI1.11 11.21,84.43 ; JHDMI1.11 12.33,84.43 ; 1.57,71.13 JUSBC1.1 ; JUSBC1.1 1.57,69.69 ; JUSBC1.1 4.03,69.69 ; JUSBC1.1 2.8,69.69 ; JUSBC1.1 4.03,70.41 ; JUSBC1.1 2.8,71.13 ; JUSBC1.1 1.57,70.41 ; JUSBC1.1 4.03,71.13 ; 143.7,2.69 H42.1 ; H42.1 142.36,5.86 ; H42.1 145.04,5.86 ; H42.1 141.87,4.52 ; H42.1 145.53,4.52 ; H42.1 143.7,6.35 ; H42.1 142.36,3.18 ; H42.1 145.04,3.18 ; 15.54,103.84 JUSB1.7 ; JUSB1.7 16.18,102.36 ; JUSB1.7 17.02,103.2 ; JUSB1.7 16.83,102.56 ; JUSB1.7 16.18,104.04 ; JUSB1.7 15.34,103.2 ; JUSB1.7 15.54,102.56 ; JUSB1.7 16.83,103.84 ; 183.4,56.33 H45.1 ; H45.1 187.53,58.07 ; H45.1 184.05,54.59 ; H45.1 184.05,58.07 ; H45.1 188.18,56.33 ; H45.1 185.79,58.72 ; H45.1 187.53,54.59 ; H45.1 185.79,53.94 ; H37.1 17.19,9.41 ; H37.1 17.73,7.92 ; H37.1 14.21,9.41 ; H37.1 15.7,5.89 ; H37.1 14.21,6.43 ; H37.1 15.7,9.95 ; H37.1 17.19,6.43 ; H37.1 13.67,7.92 ; 1.57,61.21 JUSBC1.3 ; JUSBC1.3 4.03,61.21 ; JUSBC1.3 4.03,60.49 ; JUSBC1.3 2.8,61.93 ; JUSBC1.3 1.57,61.93 ; JUSBC1.3 1.57,60.49 ; JUSBC1.3 4.03,61.93 ; JUSBC1.3 2.8,60.49 ; 334.98,72.95 JUSB2.7 ; JUSB2.7 335.17,73.59 ; JUSB2.7 336.46,72.31 ; JUSB2.7 335.17,72.31 ; JUSB2.7 335.82,73.79 ; JUSB2.7 336.66,72.95 ; JUSB2.7 335.82,72.11 ; JUSB2.7 336.46,73.59 ; H40.1 348,4.68 ; H40.1 346.76,1.76 ; H40.1 346.32,3 ; H40.1 349.68,3 ; H40.1 349.24,4.24 ; H40.1 348,1.32 ; H40.1 346.76,4.24 ; H40.1 349.24,1.76 ; JHDMI1.17 12.22,86.98 ; JHDMI1.17 11.32,86.98 ; JHDMI1.17 12.33,87.43 ; JHDMI1.17 12.22,87.88 ; JHDMI1.17 11.21,87.43 ; JHDMI1.17 11.32,87.88 ; H5.1 250.44,73.5 ; H5.1 246.31,71.76 ; H5.1 248.05,75.89 ; H5.1 248.05,71.11 ; H5.1 245.66,73.5 ; H5.1 246.31,75.24 ; H5.1 249.79,75.24 ; H5.1 249.79,71.76 ; 4.57,61.93 JUSBC1.4 ; JUSBC1.4 5.8,60.49 ; JUSBC1.4 5.8,61.93 ; JUSBC1.4 4.57,60.49 ; JUSBC1.4 7.03,61.21 ; JUSBC1.4 4.57,61.21 ; JUSBC1.4 7.03,60.49 ; JHDMI1.20 13.1,90.2 ; JHDMI1.20 10.44,92.16 ; JHDMI1.20 11.77,92.16 ; JHDMI1.20 13.1,91.18 ; JHDMI1.20 10.44,91.18 ; JHDMI1.20 10.44,90.2 ; JHDMI1.20 11.77,90.2 ; JHDMI1.20 13.1,92.16 ; JCR.20 336.07,59.9 ; JCR.20 333.33,60.62 ; JCR.20 336.07,60.62 ; JCR.20 336.07,61.35 ; JCR.20 333.33,61.35 ; JCR.20 334.7,59.9 ; JCR.20 334.7,61.35 ; JCR.20 333.33,59.9 ; 348.85,34.45 JCR.23 ; JCR.23 350.22,34.45 ; JCR.23 347.48,35.9 ; JCR.23 350.22,35.9 ; JCR.23 347.48,34.45 ; JCR.23 350.22,35.17 ; JCR.23 348.85,35.9 ; JCR.23 347.48,35.17 ; JUSBC1.2 7.03,70.41 ; JUSBC1.2 4.57,71.13 ; JUSBC1.2 4.57,69.69 ; JUSBC1.2 4.57,70.41 ; JUSBC1.2 7.03,71.13 ; JUSBC1.2 5.8,71.13 ; JUSBC1.2 5.8,69.69 ; 337.71,65.69 JUSB2.11 ; JUSB2.11 336.2,66.55 ; JUSB2.11 336.2,65.69 ; JUSB2.11 337.71,67.41 ; JUSB2.11 336.2,67.41 ; 14.68,98.86 JUSB1.4 ; JUSB1.4 14.68,100.54 ; JUSB1.4 13.84,99.7 ; JUSB1.4 14.04,100.34 ; JUSB1.4 14.04,99.06 ; JUSB1.4 15.33,100.34 ; JHDMI1.21 5.53,93.91 ; JHDMI1.21 4.2,93.91 ; JHDMI1.21 2.87,93.91 ; JHDMI1.21 2.87,92.93 ; JHDMI1.21 5.53,92.93 ; JHDMI1.22 5.53,74.93 ; JHDMI1.22 2.87,73.95 ; JHDMI1.22 4.2,73.95 ; JHDMI1.22 5.53,73.95 ; JHDMI1.22 2.87,74.93 ; JUSB1.14 15.8,97.66 ; JUSB1.14 14.29,95.94 ; JUSB1.14 14.29,97.66 ; JUSB1.14 15.8,95.94 ; JUSB1.14 15.8,96.8 ; 342.16,11.46 H48.1 ; H48.1 345.84,11.46 ; H48.1 344,10.77 ; H48.1 344,15.83 ; H48.1 342.16,15.14 ; H48.1 346.53,13.3 ; H48.1 345.84,15.14 ; H48.1 341.47,13.3 ; JHDMI1.23 11.77,77.66 ; JHDMI1.23 10.44,75.7 ; JHDMI1.23 10.44,76.68 ; JHDMI1.23 10.44,77.66 ; JHDMI1.23 13.1,76.68 ; JHDMI1.23 11.77,75.7 ; JHDMI1.23 13.1,77.66 ; 6.16,69 JUSBC1.B12 ; JUSBC1.B12 6.55,68.13 ; JUSBC1.B12 6.94,68.22 ; JUSBC1.B12 7.03,68.61 ; JUSB2.14 337.71,80.21 ; JUSB2.14 336.2,80.21 ; JUSB2.14 337.71,78.49 ; JUSB2.14 336.2,78.49 ; JUSB2.14 336.2,79.35 ; H13.1 141.31,103.09 ; H13.1 136.53,103.09 ; H13.1 140.66,101.35 ; H13.1 137.18,104.83 ; H13.1 137.18,101.35 ; H13.1 140.66,104.83 ; H13.1 138.92,105.48 ; H13.1 138.92,100.7 ; JHDMI1.8 11.02,83.38 ; JHDMI1.8 10.12,82.48 ; JHDMI1.8 11.02,82.48 ; JHDMI1.8 10.01,82.93 ; JHDMI1.8 11.13,82.93 ; JHDMI1.8 10.12,83.38 ; 127.75,57.63 H46.1 ; H46.1 125.36,60.02 ; H46.1 129.49,58.28 ; H46.1 130.14,60.02 ; H46.1 126.01,58.28 ; H46.1 127.75,62.41 ; H46.1 126.01,61.76 ; H46.1 129.49,61.76 ; JUSBC1.B1 6.94,63.4 ; JUSBC1.B1 6.55,63.49 ; JUSBC1.B1 6.16,62.62 ; JUSB1.11 15.8,109.6 ; JUSB1.11 14.29,108.74 ; JUSB1.11 15.8,108.74 ; JUSB1.11 14.29,110.46 ; JUSB1.11 15.8,110.46 ; 347.48,59.9 JCR.21 ; JCR.21 350.22,60.62 ; JCR.21 350.22,61.35 ; JCR.21 347.48,60.62 ; JCR.21 347.48,61.35 ; JCR.21 348.85,59.9 ; JCR.21 348.85,61.35 ; JCR.21 350.22,59.9 ; JCR.22 336.07,35.17 ; JCR.22 336.07,34.45 ; JCR.22 334.7,34.45 ; JCR.22 333.33,35.9 ; JCR.22 333.33,35.17 ; JCR.22 334.7,35.9 ; JCR.22 333.33,34.45 ; JCR.22 336.07,35.9 ; 206.96,5.86 H41.1 ; H41.1 209.64,3.18 ; H41.1 209.64,5.86 ; H41.1 210.13,4.52 ; H41.1 208.3,2.69 ; H41.1 206.96,3.18 ; H41.1 208.3,6.35 ; H41.1 206.47,4.52 ; 10.57,79.37 JHDMI1.2 ; JHDMI1.2 11.02,79.48 ; JHDMI1.2 11.02,80.38 ; JHDMI1.2 10.12,80.38 ; JHDMI1.2 10.12,79.48 ; JHDMI1.2 11.13,79.93 ; JHDMI1.2 10.01,79.93 ; JUSB2.12 349.81,64.19 ; JUSB2.12 349.81,65.05 ; JUSB2.12 346.79,65.05 ; JUSB2.12 348.3,64.19 ; JUSB2.12 346.79,64.19 ; 337.32,75.61 JUSB2.4 ; JUSB2.4 338.16,76.45 ; JUSB2.4 337.32,77.29 ; JUSB2.4 337.96,75.81 ; JUSB2.4 336.67,75.81 ; JUSB2.4 337.96,77.09 ; JUSB1.13 5.21,94.44 ; JUSB1.13 2.19,94.44 ; JUSB1.13 3.7,94.44 ; JUSB1.13 2.19,95.3 ; JUSB1.13 5.21,95.3 ; JUSB2.13 348.3,81.71 ; JUSB2.13 346.79,80.85 ; JUSB2.13 346.79,81.71 ; JUSB2.13 349.81,81.71 ; JUSB2.13 349.81,80.85
  BOTTOM w0.102: 140.96,108.5 140.96,108.5 141.09,108.63 141.1,108.63 ; v2(20.38,102) v3(20.38,101.23) ; v3(8.22,15.57) 7.75,16.04 CA122.2 ; UV26.J10 242.56,86.68 241.74,86.68 v2(241.71,86.65) ; 141.03,114.12 141.23,114.31 ; v2(15.21,45.29) 15.24,45.32 15.24,45.73 v3(14.86,46.11) ; PU1301.11 106.51,71.97 106.87,72.34 ; v2(338.01,60.59) 338.67,59.93 v3(339.37,59.93)
  BOTTOM w0.107: UV23.J10 v2(235.21,103.58)
  BOTTOM w0.127: v2(344.89,46.58) 344.89,46.59 344.91,46.61 344.91,47.32 v3(344.39,47.84) ; v3(349.71,45.41) 349.71,45.97 v2(349.19,46.49) ; v2(112.22,114.28) v3(111.44,114.28) ; 97.35,26.49 97.35,26.36 97.01,26.02 96.86,26.02 96.7,25.86 96.7,25.5 UH2.B6 ; v3(308.66,35.06) v2(307.91,35.06)
  BOTTOM w0.152: UH2.V29 85.71,17.54 ; UH2.V29 85.14,16.97 ; UH2.V29 85.14,17.54 ; UH2.AE18 91.13,13.87 ; UH2.AE18 90.56,13.87 ; UH2.AE18 90.56,14.44 ; UH2.BB11 94.07,5.83 v2(94.07,5.98) ; 89.04,12.86 UH2.AH21 89.31,12.61 89.55,12.85 ; UH2.AU45 77.22,8.09 v2(77.14,8.01) ; 85.71,15.22 UH2.AC29 ; UH2.AC29 85.71,14.65 ; UH2.AC29 85.14,14.65 ; UH2.AC29 85.14,15.22 ; UH2.AJ18 90.84,12.24 ; UH2.AJ18 90.44,11.83 ; UH2.AJ18 90.84,11.43 ; UH2.Y21 89.58,16.2 ; UH2.Y21 89.58,16.77 ; UH2.Y21 89.01,16.2 ; UH2.Y21 89.01,16.77 ; 85.91,13.67 UH2.AF28 ; UH2.AF28 85.91,13.1 ; UH2.AF28 86.48,13.1 ; UH2.AF28 86.48,13.67 ; 86.2,11.43 UH2.AJ28 ; UH2.AJ28 85.79,11.83 ; UH2.AJ28 86.2,12.24 ; UH2.AF20 90.35,13.1 ; UH2.AF20 90.35,13.67 ; UH2.AF20 89.78,13.1 ; UH2.AF20 89.78,13.67 ; 86.69,12.32 UH2.AH26 ; UH2.AH26 87.26,12.32 ; UH2.AH26 86.69,12.89 ; UH2.AH26 87.26,12.89 ; 85.91,14.44 UH2.AE28 ; UH2.AE28 86.48,13.87 ; UH2.AE28 85.91,13.87 ; UH2.C37 UH2.B37 81.6,25.67 UH2.A37 ; UH2.AF26 86.69,13.1 ; UH2.AF26 87.26,13.67 ; UH2.AF26 86.69,13.67 ; UH2.AF26 87.26,13.1 ; UH2.T2 UH2.T1 99.49,18.59 v2(99.49,19.03) ; UH2.Y18 91.13,16.2 ; UH2.Y18 90.56,16.2 ; UH2.Y18 90.56,16.77 ; v2(144.38,60.62) 144.79,61.04 UH1.BE3 ; UH2.AA20 90.35,15.42 ; UH2.AA20 89.78,15.99 ; UH2.AA20 90.35,15.99 ; UH2.AA20 89.78,15.42 ; UH2.G42 v2(78.74,22.74) UH2.F44 ; UH2.BE32 83.97,3.45 83.3,2.79 v2(83.09,2.79) ; 91.33,12.32 UH2.AH17 ; UH2.AH17 92,12.24 UH2.AJ15 ; UH2.AH17 91.33,12.89 ; UT1.AB2 UT1.AC2 32.22,45.4 32.4,45.4 v2(32.5,45.5) 32.27,45.73 UT1.AC1 UT1.AB1 ; 88.03,13.87 UH2.AE25 87.46,13.87 ; UH2.AK42 78.79,11.43 v2(78.71,11.51) ; v2(78.73,9.26) 78.83,9.16 UH2.AR42 ; UH2.BB21 89.75,5.96 89.95,6.17 89.95,6.41 UH2.AW19 ; 89.78,13.87 UH2.AE20 ; UH2.AE20 90.35,14.44 ; UH2.AE20 89.78,14.44 ; UH2.AE20 90.35,13.87 ; 85.91,16.2 UH2.Y28 86.48,16.2 ; UH2.AF23 88.8,13.1 ; UH2.AF23 88.8,13.67 ; UH2.AF23 88.24,13.67 ; UH2.AF23 88.24,13.1 ; 89.78,16.77 UH2.Y20 ; UH2.Y20 90.35,16.2 ; UH2.Y20 90.35,16.77 ; UH2.Y20 89.78,16.2 ; UH2.BE14 93.06,3.75 92.8,3.49 92.8,3.13 93.2,2.73 v2(93.28,2.73) ; UH2.AC20 90.35,15.22 ; UH2.AC20 89.78,14.65 ; UH2.AC20 90.35,14.65 ; UH2.AC20 89.78,15.22 ; 91.13,15.22 UH2.AC18 ; UH2.AC18 90.56,14.65 ; UH2.AC18 90.56,15.22 ; v2(167.02,60.73) 167.33,61.04 UH1.T3 ; UH2.AC1 99.33,15.27 v2(99.4,15.34) ; UT1.R22 UT1.R23 ; UH1.BE3 UH1.BE4 UH1.BE5 ; UH1.BE3 UH1.BE2 UH1.BE1 144.83,59.22 v2(144.39,58.77) ; UH2.AA29 85.71,15.42 ; UH2.AA29 85.14,15.42 ; UH2.AA29 85.14,15.99 ; UH2.AA29 85.71,15.99 ; UH2.AH18 91.13,12.32 ; UH2.AH18 91.13,12.89 ; UH2.AH18 90.56,12.32 ; UH2.AH18 90.56,12.89 ; UH2.Y29 85.14,16.2 ; UH2.Y29 85.71,16.2 ; UH2.Y29 85.14,16.77 ; 89.01,15.42 UH2.AA21 ; UH2.AA21 89.58,15.42 ; UH2.AA21 89.01,15.99 ; UH2.AA21 89.58,15.99 ; UH2.AJ15 UH2.AJ14 ; UH2.AJ15 91.95,11.91 UH2.AJ17 ; 91.33,15.42 UH2.AA17 91.33,15.99 ; 91.87,16.23 UH2.Y17 ; UH2.Y17 91.38,16.24 ; UH2.Y17 91.89,16.75 ; v2(100.55,12.63) 100.55,12.47 100.29,12.21 99.89,12.21 99.69,12.41 99.66,12.44 99.54,12.44 UH2.AH1 ; UH1.BB6 147.37,62.96 147.37,62.36 UH1.BB5 147.37,62.31 147.37,61.71 UH1.BB4 147.37,61.66 147.37,61.06 UH1.BB3 ; 85.14,14.44 UH2.AE29 ; UH2.AE29 85.71,14.44 ; UH2.AE29 85.14,13.87 ; UH2.AE29 85.71,13.87 ; v2(77.26,15.1) 77.42,14.94 UH2.AC45 ; 90.56,13.67 UH2.AF18 ; UH2.AF18 91.13,13.67 ; UH2.AF18 90.56,13.1 ; UH2.AF18 91.13,13.1 ; 174.18,78.26 173.85,78.59 173.85,79.47 UH1.G28 ; UH2.V45 76.98,17.21 v2(76.85,17.34) ; UH2.P45 77.71,19.57 77.41,19.87 v2(77.34,19.87) ; UH2.BB25 87.34,5.74 v2(87.34,6.07) ; 85.14,13.1 UH2.AF29 ; UH2.AF29 85.71,13.1 ; UH2.AF29 85.71,13.67 ; UH2.AF29 85.14,13.67 ; v2(99.85,7.91) 99.5,7.91 UH2.AU1 ; UH2.AJ17 v2(91.23,12.22) ; UH2.AJ17 91.62,11.43 ; UH2.AJ17 91.62,12.24 ; UH2.AJ17 91.21,11.83 ; 85.14,12.32 UH2.AH29 ; UH2.AH29 85.71,12.32 ; UH2.AH29 85.14,12.89 ; UH2.AH29 85.71,12.89 ; UH1.BB3 147.3,61.04 v2(146.97,60.71) ; UH1.BB3 147.37,61.01 147.37,60.41 UH1.BB2 147.37,60.36 147.37,59.76 UH1.BB1 147.4,59.69 147.4,59.2 v2(147,58.8) ; UH2.AH45 77.52,12.66 v2(77.29,12.9) ; 89.01,14.44 UH2.AE21 ; UH2.AE21 89.58,13.87 ; UH2.AE21 89.01,13.87 ; UH2.AE21 89.58,14.44 ; UH2.D45 77.34,24.39 v2(77.17,24.22) ; 90.56,15.42 UH2.AA18 ; UH2.AA18 90.56,15.99 ; UH2.AA18 91.13,15.99 ; UH2.AA18 91.13,15.42 ; UH1.AF4 UH1.AF3 UH1.AF2 UH1.AF1 v2(159.92,59.19) ; UH1.N3 169.86,61.04 v2(169.54,60.71) ; UH1.N3 UH1.N2 UH1.N1 v2(169.98,58.96) ; UH1.N3 UH1.N4 UH1.N5 ; UH2.AJ26 86.56,11.83 ; UH2.AJ26 87.38,11.83 ; UH2.AJ26 86.97,11.43 ; UH2.AJ26 86.97,12.24 ; 89.01,16.97 UH2.V21 89.58,16.97 ; 88.24,16.97 UH2.V23 88.8,16.97 ; 87.26,16.77 UH2.Y26 86.69,16.2 ; UH2.AH20 90.35,12.32 ; UH2.AH20 90.35,12.89 ; UH2.AH20 89.78,12.89 ; UH1.T5 UH1.T4 UH1.T3 ; v2(91.83,5.11) 91.83,5.11 91.83,5.42 UH2.BB16 ; UH2.AC21 89.58,15.22 ; UH2.AC21 89.01,14.65 ; UH2.AC21 89.01,15.22 ; UH2.AC21 89.58,14.65 ; v2(90.55,26.5) 90.8,26.25 UH2.A18 ; v2(84.4,26.49) 84.4,26.32 83.98,25.9 UH2.A32 ; v2(77.26,10.43) 77.67,10.43 UH2.AM45 ; v2(82.74,5.15) 82.85,5.22 UH2.BB34 ; UT1.K2 UT1.K1 ; UH2.V20 90.35,17.54 ; UH2.V20 90.35,16.97 ; UH2.V20 89.78,16.97 ; 88.29,12.84 UH2.AH23 88.76,12.85 ; UH2.AF25 88.03,13.67 ; UH2.AF25 87.46,13.67 ; UH2.AF25 88.03,13.1 ; UH2.AF25 87.46,13.1 ; 85.91,12.89 UH2.AH28 ; UH2.AH28 86.48,12.32 ; UH2.AH28 85.91,12.32 ; UH2.AH28 86.48,12.89 ; UT1.H2 UT1.H1 ; UH2.BB30 v2(85,5.14) ; UH2.B25 UH2.A25 87.29,25.8 87.53,26.03 88.2,26.03 v2(88.47,26.3) ; UH1.T3 UH1.T2 UH1.T1 167.47,59.22 v2(167.02,58.77) ; UH2.V18 91.13,17.54 ; UH2.V18 90.56,17.54 ; UH2.V18 90.56,16.97 ; UT1.N22 UT1.N23 ; 89.01,13.1 UH2.AF21 ; UH2.AF21 89.58,13.1 ; UH2.AF21 89.01,13.67 ; UH2.AF21 89.58,13.67 ; 87.46,16.97 UH2.V25 88.03,16.97 ; 88.03,12.89 UH2.AH25 ; UH2.AH25 87.46,12.32 ; UH2.AH25 87.46,12.89 ; UT1.AC6 UT1.AB6 ; UH2.AM29 UH2.AL29 UH2.AJ29 ; 85.42,12.24 UH2.AJ29 ; UH2.AJ29 85.01,11.83 ; UH2.T42 v2(78.78,18.44) ; UT1.P1 UT1.P2 ; UH2.U28 85.98,17.81 ; UH2.AC25 v2(88.13,15.32) UH2.AA25
  BOTTOM w0.178: UH2.AN39 80.79,9.84 81.37,10.42 v2(81.47,10.42) ; UT1.AA22 UT1.AA23 ; UT1.T1 UT1.T2 ; UT1.AC10 UT1.AB10 ; UT1.E22 UT1.E23 ; UT1.B8 UT1.A8 ; UT1.U22 UT1.U23 ; v2(21.05,37) 21.06,36.99 UT1.A20 UT1.B20 ; UT1.C22 UT1.C23 22.89,34.81 22.67,34.59 21.7,34.59 ; UT1.AC16 UT1.AB16 ; UT1.A12 UT1.B12 ; v2(26.63,34.77) 26.57,34.83 UT1.L23 UT1.L22 ; UT1.AC12 UT1.AB12 ; UT1.A6 UT1.B6 ; UT1.AC22 UT1.AB22 ; UT1.B16 UT1.A16 ; UT1.M1 UT1.M2 ; UT1.B10 UT1.A10 ; UT1.AC8 UT1.AB8 ; UT1.J22 UT1.J23 ; UT1.G22 UT1.G23 ; UT1.W23 UT1.W22 ; UT1.AC18 UT1.AB18 ; UT1.AC20 UT1.AB20 ; UT1.B22 UT1.A22 21.2,35.29 ; UT1.B18 UT1.A18 ; UT1.AB14 UT1.AC14 ; UT1.B14 UT1.A14
  BOTTOM w0.203: v2(157.41,59.19) UH1.AJ1 UH1.AJ2 UH1.AJ3 ; UH1.AG6 158.96,63.11 UH1.AG7 UH1.AG8 ; UH1.AG6 UH1.AH6 UH1.AJ6 UH1.AJ5 UH1.AJ4 UH1.AJ3 ; UH1.AG6 159.34,63.24 v2(159.5,63.24) ; 145.65,64.7 v2(145.7,64.7) ; 145.65,64.7 UH1.BD8 ; 145.65,64.7 145.49,64.7 UH1.BD9 ; UH1.AD12 161.87,66.9 v2(162.16,66.61) ; v2(142.96,64.7) 142.96,64.1 UH1.BH7 ; UH1.C2 176.82,60.54 v2(176.82,61.07) ; v2(175.16,77.05) 175.16,77.11 UH1.F25 ; v2(174.51,76.26) 174.83,75.94 UH1.F23 ; v2(174.51,76.26) 174.51,76.33 UH1.G24 ; v2(174.51,76.26) 174.51,76.19 UH1.G23 174.51,75.54 v2(174.51,75.47) ; UH1.BP21 138.82,74 139.34,74 UH1.BN21 ; v2(141.9,62.61) 141.53,62.99 UH1.BK6 UH1.BL6 139.93,62.99 UH1.BM6 139.85,62.36 UH1.BM5 ; v2(141.9,62.61) 142.18,62.34 UH1.BH5 UH1.BH4 UH1.BH3 UH1.BH2 142.07,60.13 UH1.BH1 142.07,59.18 v2(142.28,58.97) ; v2(141.9,62.61) 142.28,62.99 UH1.BH6 ; UH1.BM5 139.87,62.26 UH1.BN4 ; UH1.BM5 140.19,62.02 v2(140.19,61.81) 139.95,61.58 UH1.BM3 139.95,60.77 UH1.BM2 139.72,60.39 UH1.BN2 ; UH1.N34 169.94,83.76 169.55,83.43 ; UH1.BH7 UH1.BH8 UH1.BH9 ; UH1.BH7 142.32,63.46 UH1.BH6 ; UH1.BM23 140.05,75.7 v2(139.73,76.03) 139.4,76.35 UH1.BN24 139.35,76.48 138.81,76.48 UH1.BP24 138.73,76.45 138.13,76.45 UH1.BR24 UH1.BT24 ; v2(146.74,82.78) 146.41,83.11 UH1.BC33 ; UH2.BE23 88.78,3.85 v2(88.78,3.28) ; UH1.AC4 UH1.AC5 UH1.AC6 ; UH1.AC4 UH1.AC3 UH1.AC2 UH1.AC1 v2(162.44,59.19) ; UH1.AC4 162.32,61.69 v2(161.99,61.36) ; UH1.BJ29 142.11,80.23 v2(142.43,79.91) ; UH1.AL7 UH1.AL8 156.27,64.3 v2(156.68,64.7) v2(156.68,65.34) ; v2(146.74,84.08) 146.42,83.76 UH1.BC34 ; UH1.P37 v2(169.57,86.04) UH1.P38 ; UH1.AW3 149.75,61.04 v2(149.42,60.71) ; UH1.AW3 UH1.AW2 UH1.AW1 149.75,59.74 v2(149.42,60.06) ; UH1.AW3 UH1.AW4 UH1.AW5 150.26,62.73 150.45,62.73 UH1.AU6 150.7,63.62 UH1.AU7 ; UH1.AJ3 157.08,60.71 v2(156.96,60.71) 156.96,61.24 UH1.AK4 UH1.AL4 ; v2(151.46,84.08) 151.14,83.76 UH1.AU34 ; UH1.AL33 155.72,83.11 v2(155.4,83.43) 155.73,83.76 UH1.AL34 ; UH1.AU9 150.98,64.7 v2(151.19,64.7) v2(151.19,65.34) ; UH1.AU9 UH1.AU10 ; UH1.AU9 UH1.AU8 UH1.AU7 ; UH1.A28 178.84,79.8 v2(178.93,79.89) ; UH1.BH6 UH1.BG6 UH1.BF6 UH1.BE6 ; v2(153.94,65.97) 153.75,65.97 UH1.AP11 153.84,66.61 v2(153.93,66.61) ; v2(153.94,65.97) 153.94,66.61 v2(153.93,66.61) ; v2(153.94,65.97) 153.93,65.97 v2(153.93,65.34) ; v2(160.33,68.51) 160.19,68.51 UH1.AF14 UH1.AF13 UH1.AF12 159.71,66.9 v2(159.38,66.57) 159.28,66.57 UH1.AG11 ; UH1.BN9 139.73,65.72 139.73,65.79 ; UH1.D6 176.78,63.92 UH1.C8 176.78,64.12 v2(177.11,64.45) ; UH1.N9 UH1.N10 UH1.N11 ; UH1.N9 170.12,64.95 v2(170.39,65.22) 170.39,64.75 UH1.N8 ; UH1.N9 UH1.N8 ; UH1.AY33 148.78,83.11 v2(149.1,83.43) 148.77,83.76 UH1.AY34 ; v2(172.05,62.69) 172.14,62.69 UH1.K5 UH1.K4 ; UH1.F31 174.78,82.22 174.15,82.22 UH1.H32 173.59,82.78 v2(173.51,82.78) ; v2(172.05,60.65) 172.44,61.04 UH1.K3 ; UH1.C37 177.38,85.64 UH1.B37 177.94,85.64 UH1.A37 178.81,86.52 v2(178.81,86.75) ; 139.73,65.79 140.05,66.12 UH1.BM11 139.73,66.51 v2(139.73,66.61) ; 139.73,65.79 140.05,65.47 UH1.BM9 139.96,65.3 139.96,64.71 UH1.BM8 139.98,64.54 139.98,63.9 UH1.BM7 UH1.BN7 ; UH1.G10 174.51,65.3 v2(174.51,65.24) ; v2(173.51,82.78) 173.18,83.11 UH1.J33 ; v2(173.51,82.78) 173.2,82.46 UH1.J32 ; v2(159.42,65.97) 159.34,65.97 UH1.AG10 ; UH1.AB33 v2(163.27,83.43) UH1.AB34 ; UH1.AU10 UH1.AU11 ; UH1.AU10 150.99,65.34 v2(151.19,65.34) ; UH1.AU11 150.92,66.25 v2(151.19,65.97) 151.19,65.34 v2(151.19,65.34) ; UH1.AU11 UH1.AU12 ; PU600.1 287.47,31.53 287.05,31.95 v2(286.96,31.95) ; UH1.BD9 UH1.BD10 ; UH1.BD9 UH1.BD8 ; UH1.BD9 145.31,64.95 v2(145.7,65.34) 145.51,65.34 UH1.BD10 ; v2(90.95,3.63) 90.79,3.79 UH2.BE18 ; UH1.N8 UH1.N7 169.93,63.03 UH1.N6 ; UH1.A22 v2(178.72,75.08) ; UH1.D3 176.36,61.07 v2(176.82,61.07) ; UH1.BK18 UH1.BJ18 142.44,71.7 v2(142.6,71.54) ; UH1.BD11 UH1.BD10 ; UH1.BD11 145.61,66.61 v2(145.7,66.61) 145.42,66.9 UH1.BD12 145.11,66.9 v2(144.79,67.22) 144.66,67.22 UH1.BF12 144.03,67.2 v2(143.92,67.2) ; UH1.BD11 145.43,66.25 v2(145.71,65.97) 145.62,65.97 UH1.BD10 ; v2(160.91,82.78) UH1.AE33 UH1.AE34 ; v2(172.26,77.89) 172.71,77.44 UH1.J25 UH1.H25 ; UH1.AM38 155.07,86.36 v2(155.4,86.04) 155.08,85.71 UH1.AM37 ; v2(170.39,66.58) 170.71,66.9 UH1.M12 UH1.M13 UH1.M14 ; v2(170.39,66.58) 170.06,66.25 UH1.N11 ; v2(170.39,66.58) 170.08,66.9 UH1.N12 ; UH1.A6 177.64,62.84 177.14,62.84 UH1.C5 176.29,61.99 v2(175.95,61.99) ; v2(173.86,66.81) 173.86,66.74 UH1.H11 ; v2(173.86,66.81) 174.18,67.14 UH1.G12 174.18,67.34 174.29,67.45 174.29,67.45 UH1.F13 ; v2(173.86,66.81) 173.53,67.14 UH1.H12 ; UH1.BD8 UH1.BD7 145.25,63.4 UH1.BE6 ; UH1.BT14 UH1.BR14 138.1,68.62 v2(138.43,68.94) 138.75,68.62 UH1.BP14 UH1.BN14 ; v2(151.46,82.78) 151.13,83.11 UH1.AU33 ; UH1.A3 177.51,60.99 UH1.B3 176.88,61.12 v2(176.82,61.07) ; UH1.A3 UH1.A4 ; UH1.A3 178.08,60.47 v2(178,60.39) ; UH1.BP33 138.75,82.59 UH1.BN31 139.72,81.62 v2(139.72,81.57) 139.72,81.46 UH1.BN30 ; UH1.BA12 148.33,67.24 v2(148.45,67.24) 148.56,67.24 UH1.AY12 149.27,67.26 v2(149.37,67.26) 149.45,67.26 UH1.AW12 150.15,67.23 v2(150.3,67.23) 150.4,67.23 UH1.AU12 ; UH1.BA12 UH1.BA11 ; UH1.BA12 147.66,67.22 v2(147.53,67.22) 147.4,67.22 UH1.BB12 146.81,67.17 v2(146.62,67.17) ; UH1.BA12 148.28,66.61 v2(148.45,66.61) 148.08,66.25 UH1.BA11 ; UH1.BA11 UH1.BA10 UH1.BA9 UH1.BA8 UH1.BA7 147.99,63.63 UH1.BB6 ; UH1.BA11 148.26,65.97 v2(148.45,65.97) ; v2(136.93,61.69) 136.99,61.75 UH1.BT4 ; UH1.F11 174.83,66.35 v2(175.16,66.02) ; UH1.D14 176.78,68.13 UH1.C13 176.78,67.92 v2(177.11,67.6) ; v2(177.11,75.47) 176.78,75.8 UH1.C23 176.78,76 UH1.D24 ; v2(151.18,67.26) 151.09,67.26 UH1.AU12 ; UH1.BF33 144.05,83.11 v2(144.38,83.43) 144.05,83.76 UH1.BF34 ; v2(79.72,16.15) 79.37,16.15 UH2.AA42 ; v2(153.93,66.61) 154.22,66.9 UH1.AN12 ; v2(153.93,66.61) 153.65,66.9 UH1.AP12 ; v2(154.5,62.01) 154.33,62.01 UH1.AN5 154,62.94 UH1.AN6 153.91,63.13 153.91,63.86 UH1.AP8 153.53,64.3 v2(153.93,64.7) ; v2(154.5,62.01) 154.83,62.34 UH1.AM5 ; v2(154.5,62.01) 154.83,61.69 UH1.AM4 154.93,61.65 154.93,61.07 UH1.AM3 UH1.AM2 UH1.AM1 v2(154.89,59.19) ; UH1.AR13 152.89,67.87 v2(153.02,67.87) 152.69,68.2 UH1.AR14 152.43,68.2 v2(152.1,67.87) ; UH1.AR13 152.45,67.55 v2(152.12,67.22) ; UH1.AR13 152.88,67.23 v2(153.02,67.23) 153.14,67.23 UH1.AP12 ; UH1.A14 v2(178.64,68.78) ; UH1.AL12 156.01,67.1 v2(155.77,67.1) 155.56,66.9 UH1.AM12 155.04,67.16 154.65,67.16 UH1.AN12 ; UH1.BM26 140.38,77.67 v2(140.38,77.6) 140.38,77.54 UH1.BM25 ; UH1.BG12 UH1.BG13 ; UH1.BG12 143.25,66.9 v2(142.96,66.61) 142.67,66.9 UH1.BH12 ; UH1.BG12 143.62,66.9 v2(143.92,67.2) ; UH1.BG13 143.57,67.55 v2(143.92,67.2) ; UH1.BG13 UH1.BG14 143.28,68.2 v2(142.96,67.88) 142.64,68.2 UH1.BH14 ; UH1.D16 176.78,69.7 UH1.C15 176.78,69.5 v2(177.11,69.17) ; UH1.BN12 139.72,67.29 139.72,67.36 v2(139.72,67.36) 139.72,67.43 UH1.BM13 ; UH1.BN12 139.36,66.93 138.8,66.93 UH1.BP12 UH1.BR12 UH1.BT12 136.88,66.97 v2(136.67,67.18) ; UH1.BN12 139.4,66.93 v2(139.73,66.61) ; v2(173.04,65.93) 172.92,65.93 UH1.K11 ; v2(173.04,65.93) 172.71,65.6 UH1.K10 172.55,65.6 v2(172.2,65.25) 172.5,64.95 UH1.K9 172.66,64.89 172.66,64.35 UH1.K8 172.63,64.3 v2(173.03,63.89) ; v2(173.04,65.93) 173.35,65.63 UH1.J10 ; UH1.A10 178.61,65.63 v2(178.65,65.59) ; UH1.BR29 UH1.BP29 UH1.BN29 UH1.BM29 ; UH1.AD10 UH1.AD11 162.07,66.61 v2(162.16,66.61) ; UH1.AD10 UH1.AD9 ; UH1.AD10 162.08,65.97 v2(162.17,65.97) ; UV18.B10 UV18.C10 220.33,65.55 220.04,65.25 220.04,64.54 219.8,64.3 219.76,64.3 219.76,64.3 218.55,64.3 218.41,64.43 218.41,65.15 v2(218.41,65.15) ; UH1.BC13 145.97,67.55 v2(145.69,67.27) 146.06,66.9 UH1.BC12 UH1.BC13 ; UH1.BC13 UH1.BC14 146.03,68.2 v2(145.7,68.52) ; UH2.U32 v2(84.62,17.29) ; v2(84.62,17.29) UH2.U31 84.86,18.03 UH2.U29 ; v2(84.62,17.29) UH2.W31 ; UH1.AT6 151.39,62.99 UH1.AU7 ; v2(178.56,78.29) 178.5,78.23 UH1.A26 ; UH2.AV31 v2(84.02,7.97) UH2.AV33 ; 141.04,68.1 141.35,67.79 UH1.BK13 141.35,67.34 v2(141.18,67.17) ; 141.04,68.1 UH1.BL13 140.7,67.69 v2(140.38,67.37) 140.38,67.3 UH1.BM12 140.05,66.93 v2(139.73,66.61) ; 141.04,68.1 141.35,68.41 UH1.BK14 141.35,68.55 v2(140.96,68.94) UH1.BK15 UH1.BJ15 ; v2(173.03,63.89) 173.3,63.63 UH1.J7 173.76,63.63 UH1.G8 UH1.F8 174.83,64.12 v2(175.16,64.45) ; v2(173.03,63.89) 172.79,63.65 UH1.K7 ; UV18.B4 221.24,60.28 221.44,60.08 222.2,60.08 222.42,59.86 222.73,59.86 222.83,59.95 223.81,59.95 v2(224.28,59.48) ; UH1.K38 172.3,86.36 v2(171.88,86.79) ; v2(26.63,34.77) 26.63,34.23 27.09,33.78 v2(27.09,33.47) 27.09,33.16 27.12,33.14 27.12,31.83 26.82,31.53 CT44.2 ; v2(136.87,82.76) 136.97,82.66 UH1.BT32 ; UH1.A16 v2(178.72,70.35) ; UH1.A12 v2(178.72,67.2) ; v2(174.51,73.9) 174.83,74.22 UH1.F21 174.83,74.36 v2(174.51,74.69) 174.51,74.75 UH1.G22 174.13,75.03 173.53,75.03 UH1.H22 UH1.J22 ; v2(174.51,65.24) 174.83,64.91 UH1.F9 174.83,64.77 v2(175.16,64.45) ; v2(174.51,65.24) 174.51,65.17 UH1.G9 ; UH1.BM18 140.05,71.63 v2(139.73,71.3) 139.4,71.63 UH1.BN18 UH1.BP18 UH1.BR18 UH1.BT18 136.73,71.7 v2(136.69,71.66) ; UH1.Y13 164.55,67.55 v2(164.88,67.87) 164.55,68.2 UH1.Y14 ; UH1.AC6 UH1.AB6 163.61,62.99 164.27,63.65 UH1.Y7 UH1.Y8 UH1.Y9 UH1.Y10 ; UH1.AC6 162.39,62.99 v2(162.06,63.32) ; v2(136.85,60.84) 136.94,60.93 137.35,60.93 UH1.BT3 ; v2(137.9,87.02) 137.9,86.51 UH1.BR38 ; v2(162.16,66.61) 162.45,66.9 162.62,66.9 UH1.AC12 162.88,67.16 163.27,67.16 UH1.AA12 ; UH1.N11 UH1.N12 ; UH1.BJ12 141.68,66.94 v2(142.05,66.57) 142.37,66.9 UH1.BH12 ; UH1.AD9 UH1.AD8 UH1.AD7 161.73,63.65 v2(162.06,63.32) ; UH1.AD9 161.49,64.95 v2(161.23,64.68) ; 169.55,83.43 v2(169.53,83.43) ; 169.55,83.43 169.94,83.11 UH1.N33 ; v2(156.68,65.34) 156.28,64.95 UH1.AL9 ; v2(156.68,65.34) 156.68,65.34 v2(156.68,65.97) 156.31,65.6 UH1.AL10 ; UH1.F4 UH1.G4 174.06,61.69 173.74,62.01 ; UH1.F4 174.82,61.38 174.92,61.27 UH1.F3 174.85,61.04 v2(174.53,60.71) 174.71,60.52 174.74,60.52 174.88,60.39 UH1.F2 ; UH1.F4 UH1.E4 ; UH1.BH10 142.7,65.6 v2(142.96,65.34) 142.57,64.95 UH1.BH9 ; UH1.BH10 142.88,65.97 v2(142.96,65.97) 142.69,66.25 UH1.BH11 ; UH1.BH10 UH1.BH11 ; UH1.BH10 UH1.BH9 ; UH2.AE42 78.82,13.71 v2(78.74,13.79) ; 173.74,62.01 173.66,62.01 UH1.J4 UH1.K4 ; 173.74,62.01 174.07,62.34 UH1.G5 ; v2(178.77,73.61) 178.66,73.5 UH1.A20 ; UH2.U29 85.42,17.62 ; UH2.U29 85.42,18.44 ; UH1.BB6 147.02,62.66 v2(146.97,62.66) 146.84,62.66 UH1.BC6 UH1.BD6 145.56,62.99 v2(145.23,62.66) ; UH1.BB6 UH1.BA6 ; UH1.Y37 v2(164.85,86.04) UH1.Y38 ; v2(145.23,62.66) 145.16,62.66 UH1.BE5 144.79,62.38 144.79,62.95 UH1.BE6 ; v2(145.23,62.66) 144.9,62.99 UH1.BE6 ; UH1.AN12 154.03,67.26 v2(153.95,67.26) 153.83,67.26 UH1.AP12 ; v2(175.16,64.45) 175.48,64.77 UH1.E9 ; UH1.AH33 158.23,83.11 v2(158.55,83.43) 158.22,83.76 UH1.AH34 ; UH1.AP33 153.5,83.11 v2(153.82,83.43) 153.49,83.76 UH1.AP34 ; UH1.J36 173.77,84.41 UH1.H35 174.55,85.06 UH1.F36 174.76,85.06 v2(175.08,85.38) 175.08,86.26 UH1.E38 ; UH1.BN21 139.4,74.13 v2(139.73,74.45) 140.05,74.13 UH1.BM21 140.05,73.97 v2(140.36,73.67) ; UH1.BN21 UH1.BN20 139.24,73.11 139.24,72.65 UH1.BN19 ; UH1.BN7 UH1.BP7 UH1.BR7 137.97,63.82 137.88,63.91 136.69,63.91 136.23,63.45 135.89,63.45 135.45,63.01 v2(135.2,63.01) ; UH1.BN7 139.4,63.36 v2(139.47,63.29) ; UH1.G5 174.18,62.38 174.18,62.94 UH1.G6 ; UH1.G5 174.67,62.34 UH1.F5 ; v2(171.17,81.51) 171.54,81.15 UH1.L30 UH1.L29 ; v2(84.87,7.21) 85.22,6.86 UH2.AW29 ; v2(177.11,78.66) 177.11,78.69 UH1.C27 176.78,79.15 UH1.D28 ; v2(177.11,66.02) 176.78,66.35 UH1.C11 176.78,66.55 UH1.D12 ; v2(177.11,64.45) 176.78,64.77 UH1.C9 176.73,64.89 176.18,64.89 ; v2(177.11,64.45) 177.43,64.77 UH1.B9 UH1.A9 ; UH2.AD14 v2(93.29,13.77) ; 86.2,18.44 UH2.U28 85.79,18.03 ; UH1.AP10 153.73,65.34 v2(153.93,65.34) ; UH1.BR36 137.99,85.05 UH1.BT36 v2(136.86,85.05) ; UH1.W34 165.3,83.76 v2(165.65,83.42) ; v2(141.23,82.78) 141.55,82.46 UH1.BJ32 ; UV18.AH7 199.14,62.6 199.14,61.75 UV18.AH5 ; UH1.Y10 164.82,65.97 v2(164.91,65.97) 164.64,66.25 UH1.Y11 UH1.Y10 ; UH1.AP9 153.72,64.7 v2(153.93,64.7) ; UH1.W12 165.53,67.06 166.11,67.06 UH1.V12 166.44,67.06 167.02,67.06 UH1.T12 ; v2(197.44,60.92) 197.04,61.32 UV18.AL5 ; UH1.AE6 161.09,62.65 v2(161.18,62.65) 161.26,62.65 UH1.AD6 161.73,62.99 v2(162.06,63.32) ; v2(143.59,85.38) 143.26,85.71 UH1.BG37 ; 91.21,18.03 UH2.U17 91.62,17.62 ; UH1.F17 174.83,71.03 v2(174.51,70.71) ; UH1.BM38 140.19,86.37 v2(140.56,86.74) 140.91,86.4 UH1.BL38 ; UH1.K4 UH1.K3 ; UH1.BM29 140.08,80.39 140.68,80.39 UH1.BL29 141.14,80.36 UH1.BK29 141.75,80.97 UH1.BJ30 141.62,81.09 v2(141.23,81.48) 141.55,81.81 UH1.BJ31 ; UH1.BM29 139.93,80.24 139.93,79.7 UH1.BM28 140.05,79.5 v2(140.38,79.18) 140.05,78.85 UH1.BM27 ; UH1.N6 UH1.P6 ; UH1.N6 UH1.M6 ; UH1.N6 UH1.N5 ; UH1.C25 176.78,77.58 UH1.D26 176.13,78.26 v2(176.47,78.6) ; UH1.T33 v2(168,83.43) 167.67,83.76 UH1.T34 ; UH1.L34 171.61,83.76 v2(171.93,83.43) 171.61,83.11 UH1.L33 ; UH2.U18 90.84,18.44 ; UH2.U18 90.84,17.62 ; UH2.U18 90.44,18.03 ; UH1.BH12 UH1.BH11 ; UH1.T12 167.36,66.9 v2(167.65,66.61) 167.93,66.9 UH1.R12 168.37,67.16 168.76,67.16 UH1.P12 169.24,67.12 169.72,67.12 UH1.N12 ; UH1.T12 UH1.T11 ; UH1.T12 UH1.T13 167.05,67.55 v2(166.75,67.85) 167.09,68.2 UH1.T14 ; UH1.T9 167.27,64.95 v2(167.66,65.34) 167.45,65.34 UH1.T10 ; UH1.T9 UH1.T10 ; UH1.T9 UH1.T8 UH1.T7 167.19,63.55 UH1.U6 UH1.V6 165.6,62.99 UH1.W5 UH1.W4 UH1.W3 ; v2(153.93,64.7) v2(153.93,65.34) ; UH1.G16 174.51,70.03 v2(174.51,69.96) 174.83,69.64 UH1.F15 174.83,69.43 UH1.G14 ; UH1.AH12 158.19,66.9 v2(158.5,67.21) ; v2(153.04,85.38) 152.71,85.71 UH1.AR37 ; UH1.BD38 145.62,86.36 v2(145.95,86.04) 145.63,85.71 UH1.BD37 ; v2(174.51,72.32) 174.83,72.64 UH1.F19 174.83,72.79 v2(174.51,73.11) 174.51,73.18 UH1.G20 ; v2(164.51,60.74) 164.81,61.04 UH1.W3 ; v2(142.58,77.21) UH1.BJ25 UH1.BK25 ; v2(155.77,68.51) 155.9,68.51 UH1.AL14 ; UH1.C29 177.1,80.27 v2(177.1,80.22) ; UH1.BL35 140.64,84.41 v2(140.4,84.65) 140.4,84.64 UH1.BM35 ; v2(164.51,58.81) 164.95,59.25 UH1.W1 UH1.W2 UH1.W3 ; UH2.BE9 95.29,4.05 95.29,3.4 v2(95.49,3.2) ; UH1.T10 167.57,65.97 v2(167.65,65.97) 167.38,66.25 UH1.T11 ; UH1.T10 UH1.T11 ; UH1.A30 178.48,81.58 v2(178.68,81.78) ; UH1.U38 v2(167.21,86.04) UH1.U37 ; UH1.W33 v2(165.63,82.78) ; UH1.E35 175.53,84.36 175.53,83.79 UH1.E34 175.48,83.6 UH1.D33 176.45,82.64 v2(176.45,82.56) 176.45,82.5 UH1.C31 176.44,81.83 v2(176.44,81.77) 176.44,81.69 UH1.D30 ; UH1.A24 v2(178.72,76.65) ; v2(142.56,74.9) 142.51,74.85 UH1.BJ22 UH1.BK22 ; v2(197.49,59.3) UV18.AL2 ; UH2.AY45 77.13,6.47 76.74,6.09 v2(76.74,5.82) ; 176.18,64.89 UH1.D9 ; 176.18,64.89 176.25,64.96 176.25,65.51 UH1.D10 ; v2(175.16,80.2) 174.83,80.52 UH1.F29 ; v2(80.53,3.56) 80.53,3.65 UH2.BE40 ; UH1.AJ38 UH1.AJ37 157.3,85.71 v2(156.97,85.39) ; v2(148.31,85.38) 147.98,85.71 UH1.BA37 147.92,85.78 147.98,85.85 147.98,86.22 147.92,86.29 UH1.BA38 ; UH1.BN34 139.4,83.44 v2(139.08,83.12) 138.75,83.44 UH1.BP34 UH1.BR34 ; v2(136.68,78) UH1.BT26 UH1.BR26 UH1.BP26 ; v2(136.51,65.41) 137.44,65.41 UH1.BT9 ; 21.28,32.85 21.23,32.8 20.94,32.8 20.85,32.7 20.85,31.28 21.1,31.03 21.1,31.03 21.51,30.62 v2(21.59,30.62) ; v2(136.46,62.51) 136.51,62.55 UH1.BT5 ; UH1.D18 176.78,71.28 UH1.C17 176.78,71.07 v2(177.11,70.75) ; UV18.AH32 199.16,83.47 199.16,82.75 v2(199.2,82.71) ; UH1.BG38 v2(143.59,86.69) ; UH1.K1 UH1.K2 UH1.K3 ; UH1.F27 174.52,78.7 v2(174.52,78.6) 174.18,78.26 UH1.G26 ; UH1.BR21 UH1.BT21 v2(136.59,74.06) ; UH2.BE28 v2(86.24,3.42) ; UH1.AC37 v2(162.49,85.38) ; v2(216.09,56.52) 216.28,56.33 216.28,55.25 217.04,54.49 217.04,53.86 216.54,53.35 v2(216.54,53.16) 216.54,52.97 217.04,52.46 218.38,52.46 218.76,52.84 218.76,53.41 218.19,53.98 218.19,54.99 217.3,55.88 217.3,58.68 217.09,58.89 UV18.G2 ; v2(177.11,73.9) 176.78,74.22 UH1.C21 176.78,74.43 UH1.D22 ; UH1.D20 176.78,72.85 UH1.C19 176.78,72.65 v2(176.45,72.32) ; v2(172.31,71.93) UH1.J18 UH1.H18 173.5,71.9 174.16,71.9 UH1.G18 ; UH1.AV37 150.35,85.71 v2(150.67,86.04) 150.35,86.36 UH1.AV38 ; UH1.AR38 152.72,86.36 v2(153.04,86.69) ; v2(25.46,30.81) v2(23.83,30.81) ; UV18.N33 212.09,85.84 211.98,85.95 v2(211.98,85.97) ; v2(152.39,58.27) 152.38,58.29 UH1.AR1 UH1.AR2 UH1.AR3 UH1.AR4 UH1.AR5 ; PU600.3 v2(288.27,32.01) ; UH2.BE37 v2(81.67,3.56) ; UH1.AC38 v2(162.49,86.69) ; UH1.A18 v2(178.72,71.93)
  BOTTOM w0.229: v2(20.58,55.95) 20.6,55.98 20.6,56.04 20.87,56.31 UT4.A1 ; UT4.L11 25.9,61.4 26.06,61.57 v2(26.39,61.57)
  BOTTOM w0.254: v2(238.36,107.57) 238.33,107.54 238.33,107.5 238.31,107.48 238.31,107.48 UV23.N14 ; UV26.E14 246.12,90.76 v2(246.08,90.8) ; UV25.E12 239.35,56.94 v2(239.35,56.9) ; UV24.T10 208.33,98.76 v2(208.33,98.77) ; RT191.2 18.54,61.03 19.36,60.22 v2(19.45,60.22) ; RT191.2 17.91,60.41 17.91,59.7 18.12,59.48 RT190.2 ; RT191.2 18.53,61.06 CT151.2 ; v2(206.54,66.74) 206.57,66.77 206.57,66.88 206.84,67.15 UV18.W13 ; UV18.K2 214.62,58.9 214.99,58.53 v2(215.02,58.53) ; v2(197.45,63.46) 197.84,63.08 UV18.AK7 UV18.AJ7 ; v2(8.07,62.24) 8.44,61.86 v2(8.48,61.86) DT27.2 ; UV18.P17 211.84,71.51 v2(212.17,71.85) 211.84,72.18 UV18.P18 ; v2(199.06,75.17) 199.14,75.17 199.51,75.55 UV18.AH22 ; UH2.AL38 81.13,10.83 81.47,10.49 ; UV26.H13 UV26.H14 243.39,90.56 v2(243.32,90.56) ; UV26.B5 v2(248.88,83.4) ; UV26.R14 v2(238.52,89.84) ; v2(229.09,96.99) 229.09,97.07 229.21,97.19 UV23.A3 ; v2(201.63,59.29) 202.02,58.9 UV18.AE2 ; UV26.M5 240.93,83.44 ; 240.93,83.44 241.32,83.05 UV26.L5 ; 240.93,83.44 v2(240.93,83.45) ; v2(23.83,30.81) 21.78,30.81 v2(21.59,30.62) 21.5,30.71 21.5,31.16 21.87,31.53 CT43.2 22.82,31.55 YT1.4 ; UH1.A34 178.23,84.2 178.5,83.93 v2(178.79,83.93) ; v2(238.33,108.37) 238.33,108.46 UV23.R14 ; UV26.H2 244.09,80.26 v2(244.09,80.21) UV26.H1 ; v2(178.79,84.76) 178.59,84.76 178.35,85.01 UH1.A36 ; UV24.K2 UV24.K1 215.82,103.18 215.98,103.34 215.99,103.34 216.17,103.51 v2(216.35,103.51) ; UV26.U14 v2(236.92,89.84) ; UV25.P10 v2(247.32,58.5) ; UT4.L1 20.87,61.44 v2(20.28,62.02) ; UV18.B31 221.26,83.07 221.85,83.07 222.32,82.6 222.36,82.6 222.38,82.58 v2(222.42,82.58) ; v2(148.45,68.52) 148.77,68.2 UH1.AY14 ; JEDP1.5 69.55,31.74 v2(69.53,31.72) ; v2(248.93,56.95) 249.28,57.3 UV25.U12 ; v2(136.84,84.25) 136.86,84.23 UH1.BT35 ; JEDP1.34 55.05,31.89 55.21,31.73 v2(55.69,31.73) 55.69,32.11 55.55,32.25 JEDP1.33 ; UV26.A14 248.62,90.93 v2(248.62,90.93) ; v2(237.59,110.75) 237.96,110.38 UV23.U14 ; UV26.D10 246.57,87.39 v2(246.57,87.39) ; UV26.L10 v2(240.92,86.63) UV26.M10 ; UV25.C14 v2(237.72,56.1) ; RT209.1 25.39,48.43 v2(25.33,48.49) ; v2(245.71,89.06) 245.71,89.04 UV26.E12 ; UV18.AA13 204.43,66.89 v2(204.43,66.77) 204.31,66.77 UV18.AB12 ; v2(199.1,63.41) 199.51,63 UV18.AH7 ; UV24.R1 v2(214.75,99.58) ; UV25.U14 249.32,55.71 v2(248.94,56.1) ; UV24.C11 v2(206.75,108.38) UV24.C12 ; UV26.K2 v2(242.52,80.23) UV26.K1 ; UV24.U14 v2(205.15,97.98) ; UV26.N14 v2(240.12,89.84) ; UV18.AL32 UV18.AL33 197.06,84.7 v2(196.66,85.1) ; UV26.G10 v2(244.12,86.63) ; UV23.U1 v2(227.07,110.38) ; UV23.R3 229.52,109.09 v2(229.62,109.09) 229.7,109.09 UV23.R4 ; UV18.B22 221.39,75.55 221.43,75.51 222.67,75.51 v2(222.76,75.6) ; UV26.K14 v2(241.72,89.84) UV26.K13 ; UV24.C4 v2(213.15,108.38) UV24.C3 ; UV25.D10 v2(238.52,58.5) ; UV23.M5 v2(231.4,106.38) ; v2(320.05,35.48) 320.05,35.19 319.91,35.04 UI3.10 ; UV18.T7 209.57,63 209.18,62.6 v2(209.18,62.57) ; UV18.AA17 204.84,71.4 204.41,71.83 ; v2(216.08,109.98) 215.55,109.98 UV24.A1 ; UV25.H2 v2(241.72,65.71) UV25.H1 ; UV26.A12 249.41,88.64 v2(249.78,88.26) ; UV25.M5 v2(244.92,62.5) UV25.L5 ; CT106.2 15.2,31.2 UT3.5 ; UV24.E3 v2(213.15,106.78) ; JEDP1.27 58.55,32.09 v2(58.17,31.71) 58.05,31.83 JEDP1.28 ; UV26.C4 247.79,82.23 248.12,81.9 v2(248.12,81.84) 248.12,81.79 247.76,81.43 UV26.C3 ; UV25.R11 v2(248.12,57.7) UV25.R12 ; UV25.T10 v2(248.12,59.3) ; UV25.A1 v2(236.92,66.51) ; UV24.M10 v2(208.35,101.98) UV24.L10 ; UV24.K13 v2(205.15,102.78) UV24.K14 ; UV24.E14 204.47,107.18 v2(204.27,106.97) ; JEDP1.2 71.05,31.83 71.2,31.68 ; v2(220.85,67.64) 220.44,68.05 UV18.C13 220.44,68.07 v2(220.04,68.47) ; UV18.AC13 202.52,66.98 v2(202.52,66.82) ; UV23.U3 228.76,110.83 v2(228.64,110.83) ; UV18.U23 UV18.V23 207.52,77.62 v2(207.52,77.8) ; UV23.C11 v2(236.01,99.58) UV23.C12 ; UV25.H13 v2(241.72,56.1) UV25.H14 ; JEDP1.1 71.55,32.04 71.2,31.68 ; v2(204.18,63.41) UV18.AB7 UV18.AB5 204.59,61.27 v2(205,60.86) ; UV26.R3 v2(238.52,81.83) UV26.R4 ; JEDP1.17 63.55,31.75 63.55,31.75 v2(63.55,31.7) ; JEDP1.14 65.05,31.73 v2(65.04,31.72) ; D124.2 328.57,69.58 v2(328.68,69.48) ; UV25.R4 v2(248.12,64.11) UV25.R3 ; JKB.15 156.27,9.73 v2(156.53,9.47) 156.77,9.71 JKB.14 ; UV26.F10 v2(245.32,86.51) ; v2(41.99,27.41) 42.33,27.75 CT47.2 ; UV24.R12 v2(206.75,99.58) UV24.R11 ; v2(209.19,83.51) 209.58,83.9 UV18.T32 209.59,83.93 v2(210,84.34) ; v2(247.27,79.45) 247.66,79.83 UV26.C1 ; UV23.E3 v2(229.61,101.18) ; v2(236.03,97.25) 236.09,97.25 236.41,97.58 UV23.A12 ; UV26.E3 v2(245.72,81.83) ; UV23.N12 236.71,107.47 236.71,107.51 v2(236.76,107.57) ; UV26.N1 v2(240.12,80.23) ; UV25.C12 238.51,57.7 238.51,57.71 ; UV24.E12 v2(205.95,107.58) ; v2(121.46,28.39) 122.37,27.47 JDIMM1.61 ; UV23.E12 v2(236.81,100.38) ; v2(249.68,79.38) 249.68,79.47 UV26.A1 ; v2(99.57,25.85) 100.09,26.37 v2(100.8,26.37) 100.8,25.87 101,25.66 101.74,25.66 101.97,25.89 101.97,27 101.63,27.34 v2(101.23,27.34) 99.21,27.34 98.49,26.62 97.47,26.62 97.35,26.49 ; UV23.G10 v2(235.21,101.98) UV23.F10 ; UV18.P15 211.83,69.3 v2(211.39,69.73) 211.33,69.8 211.33,69.81 UV18.R16 ; v2(54.47,31.72) 54.55,31.8 JEDP1.35 ; UV25.C11 238.51,57.71 ; 238.51,57.71 v2(238.51,57.74) ; v2(340.16,43.82) 340.17,43.82 340.44,43.56 341.11,43.56 341.33,43.77 UZ5.5 ; UV24.B5 v2(212.35,109.18) ; UI2.14 332.04,64.01 v2(332.36,64.33) ; UV25.R1 v2(247.32,66.51) ; UV18.T17 209.85,71.3 v2(210.38,71.83) 209.91,72.3 UV18.T18 ; UV23.L10 234.47,105.23 v2(234.47,105.17) ; UV23.H14 v2(237.61,102.78) UV23.H13 ; v2(196.64,79.28) 197.02,78.9 UV18.AL26 ; CT44.2 26.48,31.18 26.29,30.99 ; v2(245.25,83.68) 245.25,83.56 245.32,83.5 UV26.F5 ; v2(249.75,64.97) 249.75,64.93 UV25.U3 ; v2(195.84,65.92) 195.46,65.55 UV18.AN10 ; UV24.U1 v2(214.75,97.98) ; UV18.AB32 v2(205,84.31) ; UV23.B10 235.24,97.95 v2(235.24,97.91) ; UV24.H1 214.83,105.1 v2(214.76,105.1) 214.68,105.1 UV24.H2 ; v2(240.86,62.49) 240.9,62.49 UV25.G5 ; UV24.R3 v2(213.15,99.58) UV24.R4 ; UV24.D10 v2(207.55,107.58) ; UV24.F5 211.54,106.38 v2(211.4,106.24) ; DT26.2 v2(10.98,61.86) ; UV24.A14 204.22,109.85 v2(204.22,109.63) ; v2(29.18,58.94) RT186.2 ; UV18.B1 221.35,58.1 221.67,58.42 221.67,58.49 v2(221.68,58.5) ; UV26.U3 v2(236.12,81.83) ; v2(247.79,55.12) 247.72,55.19 UV25.R14 ; v2(245.32,59.43) 245.32,59.36 UV25.M10 ; UV23.C4 v2(229.61,98.78) UV23.C3 ; UV25.E3 v2(240.12,64.11) ; UV26.R11 v2(238.52,88.24) UV26.R12 ; UV24.C14 204.04,108.78 v2(203.78,108.52) ; 204.41,71.83 204.84,72.26 UV18.AA18 ; 204.41,71.83 v2(204.37,71.83) ; v2(234.57,9.41) 234.36,9.62 JHDD.7 ; 71.2,31.68 v2(71.2,31.72) ; UV23.G5 v2(230.41,101.98) UV23.F5 ; v2(243.3,66.52) UV25.K1 UV25.K2 ; v2(237.01,62.46) 237.01,62.6 UV25.B5 ; UV18.U19 208.8,73.3 208.41,72.91 v2(208.34,72.91) 208.28,72.91 207.89,73.3 UV18.V19 ; UV24.N12 v2(206.75,101.18) ; UV18.AG11 200.56,66.4 v2(200.89,66.08) ; v2(212.35,98.82) 212.35,98.77 UV24.T5 ; v2(220.04,73.48) 220.04,73.45 UV18.C19 220.85,73.47 v2(220.85,73.48) ; JDIMM2.61 198.67,27.15 197.64,28.19 v2(197.47,28.19) ; UV24.A3 v2(213.15,109.98) ; UV25.J10 v2(243.32,58.5) ; UV24.C1 v2(215.56,108.38) ; v2(231.17,105.17) 231.17,105.22 UV23.L5 ; UV24.H13 v2(205.15,105.18) UV24.H14 ; UV23.N1 227.1,107.18 v2(227.09,107.19) ; UV18.AH16 199.13,70.14 v2(199.05,70.14) ; UV25.B10 v2(236.92,58.5) ; 21.28,32.85 21.57,33.13 21.57,34.46 21.7,34.59 21.7,34.9 21.31,35.29 v2(21.05,35.29) ; UV26.C14 v2(248.12,89.84) ; v2(246.13,66.68) 246.13,66.56 246.12,66.55 UV25.N1 ; UV23.C1 v2(228.02,98.77) ; v2(238.13,96.92) 238.01,97.03 UV23.A14 ; UV24.A12 v2(205.95,109.98) ; UV25.G10 240.97,58.56 v2(240.97,58.5) 240.94,58.53 240.89,58.53 UV25.F10 ; UH1.D38 176.36,86.74 v2(176.36,86.94) ; UV23.R12 v2(236.01,108.38) UV23.R11 ; UV26.R1 v2(238.52,80.23) ; UV25.F5 v2(240.92,63.3) ; UV25.E1 v2(239.32,65.71) ; UV23.B5 v2(230.43,97.99) ; v2(211.03,105.59) 211.04,105.58 UV24.G5 ; v2(212.06,81.45) 212.15,81.54 212.15,82.23 UV18.N30 ; UV18.W28 207.08,80.6 207.08,80.6 206.73,80.24 v2(206.67,80.24) ; UV25.K13 v2(243.32,56.1) UV25.K14 ; v2(227.59,96.61) 227.59,97.55 UV23.A1 ; JAPS.8 175.12,7.83 174.66,8.29 v2(174.66,8.29) ; UV23.N3 v2(229.61,106.78) ; UV25.C1 v2(238.52,66.51) ; v2(245.95,55.18) 245.95,55.54 UV25.N14 ; UV24.R14 v2(205.15,99.58) ; UV25.A12 236.12,56.91 v2(236.12,56.9) ; v2(66.54,31.71) 66.54,31.72 66.55,32.2 JEDP1.11 ; UV24.E1 v2(214.75,107.58) ; UV26.U1 v2(236.92,80.23) ; UI3.21 319.91,29.84 v2(319.68,29.6) ; DT20.2 v2(9.4,71.56) ; v2(237.77,82.64) 237.71,82.64 UV26.T5 ; UV26.G5 v2(244.12,83.43) ; v2(214.37,71.83) 213.91,72.3 UV18.M18 ; UV25.A14 236.09,56.14 v2(235.36,56.14) ; UV26.T10 v2(237.72,86.63) ; v2(234.29,106.38) 234.36,106.38 234.36,106.38 UV23.M10 ; v2(172.2,6.55) 172.12,6.63 JAPS.14 ; UV26.B10 v2(248.12,87.43) ; UV24.P10 v2(207.55,100.38) ; UV25.E14 v2(240.12,56.1) ; JEDP1.8 68.05,31.72 v2(68.04,31.71) ; UV25.N12 v2(245.72,56.9) ; 81.47,10.49 81.47,10.5 ; 81.47,10.49 v2(81.47,10.42) ; UV26.U12 236.88,88.27 v2(236.88,88.25) ; UV23.K13 237.54,105.1 v2(237.62,105.1) 237.69,105.1 UV23.K14 ; D123.2 v2(326.68,69.48) ; UV18.AE28 202.36,80.6 202.77,81 203.91,81 204.16,80.75 v2(204.16,80.2) ; UV23.K1 v2(228.01,104.38) UV23.K2 ; UV23.H1 v2(228.01,102.78) UV23.H2 ; UV26.N3 v2(239.32,81.03) ; UV23.E14 v2(237.61,101.18) ; UV25.L10 v2(244.12,59.3) ; v2(203.36,71.86) 202.92,72.3 UV18.AC18 ; UV26.P10 v2(239.32,87.43) ; UV18.W17 206.5,71.63 v2(206.5,71.83) 206.5,71.95 206.84,72.29 UV18.W18 ; UV25.C4 v2(237.72,64.11) UV25.C3 ; UV18.U21 208.83,75.3 v2(208.34,74.81) 207.86,75.3 UV18.V21 ; UV25.A3 v2(236.92,64.91) ; UV18.V14 207.84,68.43 v2(208.34,68.93) 208.84,68.44 UV18.U14 ; UV26.C11 v2(248.12,88.24) UV26.C12 ; JHDD.4 232.86,9.34 v2(233.06,9.14) ; UV24.N14 v2(205.15,101.18) ; UV18.U16 208.84,70.32 v2(208.34,70.81) 207.84,70.3 UV18.V16 ; UV25.U1 249.32,66.42 v2(249.12,66.62) ; UV24.L5 v2(212.35,101.98) UV24.M5 ; DT21.2 v2(9.4,69.04) ; v2(227.01,108.76) 227.6,108.76 UV23.R1 ; UV25.T5 v2(248.12,62.5) ; UV26.N12 v2(240.12,88.24) ; UV26.E1 246.12,79.68 246.09,79.66 246.09,79.28 246.49,78.88 v2(246.57,78.88) ; UV23.T5 v2(231.21,109.18) ; UV24.B10 v2(207.55,109.18) ; UV26.A3 v2(248.92,81.83) ; UV24.F10 v2(208.56,106.38) ; UV24.N3 v2(213.95,100.38) ; UV24.G10 v2(208.35,105.18) ; UV23.T10 v2(234.41,109.18) ; v2(219.73,8.64) 219.35,8.26 D2.2 ; UV23.E1 v2(228.02,101.18) ; UV23.U12 v2(236.01,109.98) ; UV23.P10 v2(235.21,108.38) ; UV23.D10 v2(235.21,99.58) ; JEDP1.30 v2(57.05,31.71) ; JKB.13 v2(157.27,9.47) ; UV24.J10 v2(207.55,103.58) ; JHDD.10 v2(235.86,9.41) ; UV24.U12 v2(206.75,97.98) ; UV24.N1 v2(214.75,101.18) ; UV23.C14 v2(237.61,99.58) ; UV24.U3 v2(213.12,97.14)
  BOTTOM w0.279: UV18.AN25 UV18.AM25 196.28,78.05 196.67,77.66 v2(196.67,77.61) 196.72,77.61 197.04,77.29 UV18.AL24 UV18.AL23 ; v2(199.11,77.62) UV18.AH24
  BOTTOM w0.3: 217.14,68.05 217.14,68.02 ; v2(214.98,81.93) 214.98,81.92 214.89,81.92 214.59,82.22 UV18.K30
  BOTTOM w0.305: 160.2,16.85 160.34,16.85 160.63,17.14 JDIMM1.206 ; 160.2,16.85 160.01,16.85 159.63,17.23 JDIMM1.202 ; 160.2,16.85 v2(160.2,16.86) ; JNGFF1.21 335.55,84.71 336,85.15 v2(336.55,85.15) JNGFF1.25 ; JKB.17 164.15,6.67 v2(164.4,6.42) ; v2(123.39,27.73) 123.37,27.71 JDIMM1.65 ; v2(204.17,27.83) 204.02,27.83 203.67,27.48 JDIMM2.81 ; v2(193.12,28.64) 194.18,27.59 JDIMM2.43 ; v2(134.29,28.71) 134.05,28.71 132.88,27.53 JDIMM1.103 ; v2(200.26,16.86) 200.43,17.02 JDIMM2.68 ; UV18.P20 v2(211.33,73.79) UV18.R19 ; v2(111.68,28.2) 111.55,28.2 110.88,27.52 JDIMM1.15 ; JDIMM2.210 237.94,18.15 237.94,17.22 v2(238.29,16.87) 238.74,16.87 238.93,17.05 JDIMM2.214 ; v2(152.17,28.33) 151.98,28.33 151.63,27.97 151.63,27.44 151.87,27.19 JDIMM1.171 ; JDIMM2.202 235.93,17.3 236.37,16.86 236.49,16.86 v2(236.49,16.86) 236.5,16.86 236.57,16.86 236.94,17.23 236.94,17.27 JDIMM2.206 ; UV18.T15 v2(210.43,68.71) UV18.R14 ; JNGFF1.15 334.05,84.82 v2(334.56,85.33) ; v2(150.53,28.34) 150.62,28.34 151,27.96 151,27.44 150.87,27.31 JDIMM1.167 ; JNGFF2.51 259.5,10.04 259.29,9.83 259.29,8.93 259.68,8.54 JNGFF2.57 263.46,8.54 263.82,8.91 v2(263.82,9.06) ; JDIMM2.26 189.92,17.26 189.85,17.19 189.52,16.86 189.5,16.86 v2(189.5,16.86) 189.5,16.86 189.3,16.86 188.92,17.23 JDIMM2.22 ; JDIMM1.85 128.37,27.89 v2(127.81,28.45) ; 153.81,20.07 154.12,19.76 JDIMM1.180 ; 153.81,20.07 153.12,19.39 JDIMM1.176 ; 153.81,20.07 153.81,20.63 153.38,21.06 v2(153.29,21.06) ; UV18.Y19 v2(205.35,73.79) UV18.AA20 ; v2(114.89,28.79) 115.3,28.79 115.88,28.22 JDIMM1.35 ; v2(191.14,28.86) 191.51,28.86 192.18,28.2 JDIMM2.35 ; JDIMM2.73 201.67,27.27 201.47,27.47 201.47,28.18 201.63,28.34 v2(201.94,28.34) 202.14,28.34 202.67,27.8 JDIMM2.77 ; JDIMM1.47 118.88,27.76 119.34,28.22 v2(119.47,28.22) ; v2(197.47,27.61) 197.67,27.4 JDIMM2.57 ; v2(121.46,27.69) 121.37,27.61 JDIMM1.57 ; JNGFF1.31 338.05,84.74 337.9,84.9 337.9,85.63 338.15,85.89 338.67,85.89 v2(338.7,85.86) ; JNGFF1.10 v2(332.8,92.84) ; JDIMM1.184 155.12,17.1 155.33,16.9 v2(155.75,16.9) 156.12,17.27 JDIMM1.188 ; JAPS.12 173.12,8.03 173.36,8.26 v2(173.93,8.26) 174.12,8.07 JAPS.10 ; JDIMM2.86 204.92,19.04 205.27,19.38 205.27,20.61 204.89,20.99 v2(204.68,20.99) ; v2(199.26,27.58) 199.29,27.58 199.67,27.19 JDIMM2.65 ; v2(198.95,72.7) 199.19,72.7 UV18.AH19 ; JDIMM2.51 196.18,27.43 v2(195.73,27.88) ; JDIMM2.89 205.67,27.68 205.69,27.69 v2(205.82,27.83) ; JDIMM2.52 196.43,17.3 195.98,16.86 195.92,16.86 v2(195.92,16.86) 195.92,16.86 195.7,16.86 195.43,17.14 JDIMM2.48 ; v2(219.97,80.97) 220.03,80.97 220.44,80.57 UV18.C28 UV18.B28 ; UV18.AE33 202.01,84.78 202.01,86 v2(202.06,86.05) ; JDIMM1.226 165.63,17.28 165.2,16.86 v2(164.86,16.86) 164.63,17.1 JDIMM1.222 ; JDIMM2.227 242.18,27.33 v2(241.78,27.78) 241.67,27.78 241.18,27.28 JDIMM2.223 ; v2(337.29,89.3) 337.15,89.44 337.15,90.33 337.3,90.49 JNGFF1.28 ; UV18.N7 211.96,62.88 v2(211.96,61.92) ; v2(241.21,16.86) 240.93,17.15 240.93,18.15 JDIMM2.222 ; JDIMM2.238 244.93,17.18 v2(245.23,16.87) ; v2(218.41,65.15) 218.81,65.55 UV18.E10 ; UV18.AN30 195.44,82.22 v2(195.04,82.62) ; v2(239.66,16.87) 239.66,17.03 239.93,17.3 JDIMM2.218 ; UV18.C7 220.44,63.01 v2(220.04,62.61) ; 217.14,68.02 v2(216.74,67.62) ; v2(230.44,16.86) 230.44,16.87 230.44,18.15 JDIMM2.180 ; JDIMM2.60 198.43,17.21 198.77,16.86 v2(198.93,16.86) 199.13,16.86 199.43,17.16 JDIMM2.64 ; JDIMM1.44 118.12,16.91 v2(117.89,16.68) 117.64,16.68 117.12,17.2 JDIMM1.40 ; JDIMM2.56 197.43,17.12 v2(197.67,16.87) ; JDIMM2.188 232.42,16.98 232.3,16.86 ; JDIMM1.82 127.62,17.1 v2(128.04,16.69) 128.62,17.28 JDIMM1.86 ; JDIMM2.1 183.68,28.69 v2(184.25,29.26) 184.68,28.84 JDIMM2.5 ; JDIMM2.93 206.67,27.75 205.86,28.56 v2(205.81,28.56) ; UV18.B25 221.43,78.24 222.85,78.24 223.17,78.56 223.17,79.19 v2(223.16,79.19) ; v2(209.39,57.51) 209.39,58.7 UV18.T2 ; UV18.N28 212.06,80.6 v2(211.66,80.2) ; v2(195.01,86.31) 195.44,85.88 UV18.AN34 ; v2(214.71,86.12) 214.69,86.11 214.69,86.05 214.65,86.01 214.65,84.76 UV18.K33 214.63,84.65 214.63,83.94 UV18.K32 ; JDIMM2.102 208.94,18.15 208.94,17.06 209.14,16.86 209.39,16.86 v2(209.39,16.86) 209.39,16.86 209.47,16.86 209.94,17.33 JDIMM2.106 ; JNGFF1.43 341.05,84.9 341,84.95 v2(341,85.28) ; UV18.N23 212.84,77.27 v2(212.35,76.78) 212.28,76.78 211.84,76.34 UV18.P22 ; v2(199.84,86.18) 199.74,86.08 199.74,84.85 UV18.AH33 ; JDIMM2.230 242.93,17.32 243.25,17 243.42,17 v2(243.55,16.86) 243.93,17.23 JDIMM2.234 ; v2(108.88,28.08) 108.01,28.08 107.37,27.44 JDIMM1.1 ; v2(108.88,28.08) 108.37,27.57 JDIMM1.5 ; v2(108.88,28.08) 109.37,28.08 109.8,27.65 ; v2(199.29,58.44) 199.59,58.73 UV18.AH2 ; UV18.K28 214.74,80.75 214.74,81.24 v2(214.67,81.32) ; v2(295.63,31.71) 295.99,32.06 296.42,32.06 296.7,31.78 JLPDE1.9 ; v2(197.44,80.97) 197.04,80.57 UV18.AL28 ; v2(187.98,28.2) 187.85,28.2 187.18,27.52 JDIMM2.15 ; JDIMM1.72 125.12,17.19 125.64,16.67 v2(126.18,16.67) 126.62,17.12 JDIMM1.78 ; JDIMM1.239 168.87,27.5 168.63,27.75 168.06,27.75 v2(168.05,27.76) 167.87,27.59 JDIMM1.235 ; JDIMM1.214 162.63,17.31 162.21,16.9 v2(161.97,16.9) 161.63,17.24 JDIMM1.210 ; JDIMM1.248 171.12,17.21 171.34,16.99 v2(171.34,16.87) ; v2(194.94,86.89) 194.89,86.89 194.41,86.4 194.41,84.93 UV18.AP33 ; JDIMM1.175 152.87,27.35 152.56,27.66 v2(152.18,27.66) ; JDIMM1.251 171.89,26.35 171.89,27.68 171.83,27.74 v2(170.56,27.74) 170.62,27.67 170.89,27.67 JDIMM1.247 ; JNGFF1.1 v2(328.55,85.15) ; UV18.A2 222.44,58.49 222.44,58.45 v2(222.46,58.43) ; UZ9.5 186.13,84.49 CZ82.2 ; JDIMM2.251 248.18,27.83 v2(248.1,27.9) ; v2(153.43,27.68) 154.11,27.68 154.37,27.41 JDIMM1.181 ; UV18.AH11 199.54,66.37 v2(199.95,65.95) 199.55,65.55 UV18.AH10 ; v2(203.36,71.86) 202.84,71.34 UV18.AC17 ; JDIMM1.213 162.37,27.46 162.01,27.82 161.38,27.82 v2(161.15,27.59) 161.37,27.37 JDIMM1.209 ; UV18.N16 212.84,70.24 v2(213.39,69.69) 213.39,69.7 213.79,69.3 UV18.M15 214.07,69.3 v2(214.38,69.6) ; v2(214.17,63.37) 214.22,63.37 UV18.K7 ; JDIMM1.27 113.88,27.78 113.48,28.17 v2(112.88,28.17) ; v2(208.03,27.59) 208.18,27.45 JDIMM2.99 ; v2(187.98,27.56) 188.18,27.37 JDIMM2.19 ; 191.67,16.85 191.39,16.85 190.92,17.32 JDIMM2.30 ; 191.67,16.85 191.96,16.85 192.43,17.32 JDIMM2.36 ; 191.67,16.85 v2(191.67,16.86) ; JDIMM2.171 228.18,27.63 v2(228.16,27.65) ; UV18.AE30 201.99,82.3 v2(201.58,82.71) ; v2(119.27,21.91) 119.38,21.81 119.38,20.08 119.73,19.73 120.49,19.73 121.12,19.09 JDIMM1.56 ; v2(247.99,28.57) 247.18,27.75 JDIMM2.247 ; JDIMM2.184 231.42,17.15 231.72,16.85 232.3,16.85 232.3,16.86 ; JDIMM1.196 158.12,17.18 v2(157.84,16.9) 157.37,16.9 157.12,17.14 JDIMM1.192 ; JDIMM2.168 227.43,18.16 227.43,19.84 v2(227.44,19.85) ; UV18.A33 222.12,84.7 v2(222.47,84.35) ; v2(211.69,60.92) 212.06,61.3 UV18.N5 ; JDIMM2.98 207.92,17.07 v2(208.13,16.86) ; JDIMM2.27 190.18,27.76 189.63,28.39 v2(189.3,28.39) ; UV18.G25 217.14,78.05 217.14,78.04 v2(217.56,77.62) ; UV18.G30 217.11,82.3 v2(217.51,82.7) ; UV18.AE5 v2(202.51,61.72) ; JDIMM1.193 157.39,27.33 157.09,27.63 v2(157.04,27.63) ; UV18.AN22 UV18.AM22 196.29,75.55 v2(196.66,75.18) 197.04,74.8 UV18.AL21 UV18.AL20 ; UV18.E5 v2(219.24,60.9) ; JDIMM1.68 124.12,16.84 124.25,16.71 v2(124.27,16.71) ; JDIMM1.106 133.62,17.11 133.41,16.9 v2(133.14,16.9) 132.83,16.9 132.62,17.1 JDIMM1.102 ; JDIMM2.205 236.67,27.28 236.25,27.7 v2(236.14,27.7) 235.67,27.24 JDIMM2.201 ; JDIMM2.82 203.92,17.15 v2(204.22,16.86) ; JDIMM2.231 243.18,27.39 v2(243.53,27.75) 243.8,27.75 244.18,27.38 JDIMM2.235 ; UV18.Y21 v2(206.38,74.75) UV18.W20 ; v2(219.97,77.62) 220.01,77.62 UV18.C25 ; UV18.AC20 202.84,74.3 v2(203.42,73.72) 203.83,73.3 UV18.AB19 ; UV18.G28 217.14,80.6 v2(217.56,81.02) 217.99,80.6 UV18.F28 ; v2(199.16,67.6) 199.16,67.62 199.54,67.99 UV18.AH13 ; v2(169.8,16.86) 170.12,17.19 JDIMM1.244 ; UV18.F7 v2(218.44,62.6) 218.84,63 UV18.E7 ; JNGFF2.39 261.37,13.04 261.63,12.79 v2(261.63,12.26) 261.63,11.91 261.27,11.54 JNGFF2.45 ; JDIMM2.14 186.92,17.32 187.35,16.89 187.56,16.89 ; UV18.D2 219.23,58.54 219.23,57.81 v2(219.12,57.7) ; v2(259.02,4.63) 259.6,4.04 JNGFF2.67 ; JDIMM2.23 189.18,27.57 189.19,27.59 189.19,27.64 v2(189.27,27.72) ; UV18.N12 212.76,66.3 v2(212.3,66.76) 212.3,66.71 212.24,66.77 212.24,66.9 UV18.P13 ; v2(228.16,28.23) 228.7,28.23 229.18,27.76 JDIMM2.175 ; JDIMM1.64 123.12,17.18 v2(122.66,16.72) 122.12,17.26 JDIMM1.60 ; JDIMM1.9 109.37,27.22 109.8,27.65 ; UV18.AM13 197.04,68.85 UV18.AL14 UV18.AL15 ; UV18.AM13 UV18.AN13 ; UV18.AM13 196.24,67.95 v2(196.57,67.61) 196.99,67.2 UV18.AL12 ; JDIMM2.185 231.67,27.37 231.99,27.69 v2(232.24,27.69) 232.49,27.69 232.67,27.51 JDIMM2.189 ; UV18.U12 208.81,66.3 v2(208.34,66.77) 207.86,66.3 UV18.V12 ; v2(220.04,75.99) 220.44,75.59 UV18.C22 ; v2(216.74,65.97) 217.14,65.57 UV18.G10 ; v2(201.68,83.44) 201.68,83.45 202.09,83.85 UV18.AE32 ; JDIMM1.243 169.87,25.28 170.35,24.8 170.35,24.27 169.68,23.6 v2(169.47,23.6) ; JDIMM2.239 245.18,25.37 245.72,24.82 245.72,24.83 v2(245.72,24.83) 246.18,25.28 JDIMM2.243 ; v2(245.68,64.14) 245.68,64.14 245.76,64.14 UV25.N3 ; UV18.M20 213.83,74.3 213.57,74.03 v2(213.57,73.8) 213.34,73.8 UV18.N19 ; UV18.AP2 UV18.AN1 194.96,57.62 v2(194.9,57.62) ; JDIMM2.244 246.42,17.21 v2(246.08,16.86) ; JDIMM1.197 158.39,26.35 158.39,27.19 157.21,28.37 v2(156.97,28.37) ; v2(202.65,20.67) 201.43,19.44 JDIMM2.72 ; JDIMM1.36 116.12,17.19 115.61,16.67 v2(115.37,16.67) 115.24,16.67 114.62,17.29 JDIMM1.30 ; RT207.1 RT45.1 RT44.1 RT208.1 19.65,42.97 19.9,42.72 21.02,42.72 v2(21.09,42.8) ; v2(233.56,27.7) 233.67,27.58 JDIMM2.193 ; JDIMM1.107 133.88,27.68 v2(134.28,28.08) ; v2(194.88,60.71) 194.95,60.71 195.11,60.55 UV18.AN4 ; UV18.AB14 UV18.AC13 ; v2(129.64,28.64) 129.69,28.64 130.37,27.96 JDIMM1.93 ; v2(261.61,15.06) 261.61,14.73 261.42,14.54 JNGFF2.33 ; JKB.16 155.38,8.2 v2(155.51,8.33) ; JNGFF1.67 347.05,83.23 v2(347.47,82.81) ; v2(119.47,27.6) 119.61,27.6 119.88,27.33 JDIMM1.51 ; v2(202.63,16.86) 202.94,17.17 202.94,18.15 JDIMM2.78 ; JDIMM2.192 233.42,17.31 233.88,16.86 234.04,16.86 v2(234.05,16.86) 234.05,16.86 234.42,17.23 JDIMM2.196 ; JDIMM2.248 247.42,17.15 247.71,16.86 v2(247.92,16.86) 248.03,16.86 248.42,17.25 JDIMM2.252 ; v2(210.65,27.99) 210.18,27.51 JDIMM2.107 ; JDIMM1.218 163.63,18.99 164.63,20 164.63,20.56 164.13,21.06 v2(164.01,21.06) ; JDIMM1.90 129.62,17.24 129.97,16.9 v2(130.32,16.9) 130.35,16.9 130.62,17.17 JDIMM1.94 ; 187.56,16.89 187.92,17.26 JDIMM2.18 ; 187.56,16.89 v2(187.56,16.87) ; 109.8,27.65 v2(109.83,27.67) ; UV18.T28 209.61,80.6 v2(210.01,80.2) ; v2(114.89,27.63) 114.88,27.61 JDIMM1.31 ; UV18.AC22 203.41,75.73 v2(203.41,75.7) 203.43,75.7 UV18.AB21 ; JNGFF1.7 v2(330.05,85.15) ; v2(219.22,75.12) 219.22,75.16 UV18.E22 ; JDIMM1.201 159.37,27.25 159.82,27.7 v2(160.03,27.7) 160.14,27.7 160.37,27.47 JDIMM1.205 ; v2(131.73,27.89) 131.88,27.74 JDIMM1.99 ; UV18.AB28 204.56,80.6 v2(204.16,80.2) ; UV18.G2 217.09,58.9 v2(216.67,59.32) 216.67,59.29 217.08,59.7 UV18.G3 ; v2(226.72,28.32) 226.82,28.32 227.3,27.84 227.3,27.44 227.18,27.31 JDIMM2.167 ; JNGFF2.3 259.5,22.04 259.3,22.25 v2(258.81,22.25) 259.11,22.54 JNGFF2.1 ; UV18.Y14 v2(206.33,68.8) UV18.W15 ; v2(184.16,20.39) 184.33,20.39 184.92,19.8 JDIMM2.6 184.92,17.2 184.72,17 184.25,17 183.92,17.32 JDIMM2.2 ; JDIMM1.23 112.88,27.57 v2(112.89,27.58) ; UV18.R12 210.8,66.3 v2(210.33,66.77) 210.33,66.81 UV18.T13 ; UV18.T5 209.43,61.45 209.43,62.32 v2(209.18,62.57) ; v2(20.91,52.8) 20.83,52.89 CT152.2 ; JDIMM2.176 229.44,17.27 v2(229.04,16.86) 228.85,16.86 228.44,17.28 228.44,18.15 JDIMM2.172 ; UV18.AC15 202.84,69.37 v2(203.36,69.89) 203.77,70.3 UV18.AB16 ; UV18.N21 UV18.M22 213.84,76.22 214.22,75.84 v2(214.18,75.84) ; UV18.G19 217.14,73.07 v2(216.74,73.47) ; JNGFF1.16 v2(334.3,92.85) ; v2(217.5,61.72) 217.5,61.71 UV18.G5 ; v2(167.06,23.6) 167.17,23.6 167.57,24 167.57,24.83 166.87,25.52 JDIMM1.231 ; v2(111.68,27.56) 111.88,27.37 JDIMM1.19 ; v2(199.2,82.71) 199.59,82.32 UV18.AH30 ; JDIMM1.69 124.37,27.48 v2(123.36,28.49) ; JDIMM1.185 155.37,27.37 155.63,27.63 v2(155.98,27.63) 156.19,27.63 156.39,27.43 156.39,26.35 JDIMM1.189 ; JFP.7 v2(223.58,2.93) ; JDIMM2.181 230.67,27.36 v2(230.43,27.6) ; JDIMM1.98 131.62,17.15 131.83,16.95 v2(131.83,16.9) ; JDIMM1.52 120.12,17.11 119.69,16.68 v2(119.58,16.68) 119.46,16.68 119.12,17.02 JDIMM1.48 ; JNGFF1.37 339.55,85.03 v2(339.6,85.07) ; JDIMM2.103 209.18,27.53 210.24,28.59 v2(210.59,28.59) ; UV18.W32 207.11,83.9 207.52,84.31 v2(207.52,84.33) ; UV18.D31 219.74,83.1 220.05,83.41 v2(220.06,83.41) ; v2(216.66,84.38) 216.66,84.39 216.97,84.7 UV18.G33 217.27,84.51 217.27,84.08 UV18.G32 ; UV18.G7 216.71,62.57 v2(216.66,62.57) ; UV18.AK10 198.2,65.19 v2(198.28,65.19) ; v2(335.67,92.83) 335.8,92.7 JNGFF1.22 ; v2(206.58,16.86) 206.92,17.21 JDIMM2.94 ; JDIMM2.39 193.18,27.74 193.19,27.75 v2(193.19,27.75) ; JDIMM2.44 194.43,17.21 194.08,16.86 193.95,16.86 v2(193.95,16.86) 193.95,16.86 193.84,16.86 193.43,17.27 JDIMM2.40 ; UV18.AN16 UV18.AM16 196.24,70.62 v2(196.62,71.01) 197.02,71.4 UV18.AL17 UV18.AL18 196.24,73 UV18.AM19 UV18.AN19 ; v2(218.4,78.39) 218.5,78.39 UV18.E25 ; RA68.2 14.63,35.99 v2(14.63,35.5) ; JDIMM2.69 200.67,27.31 199.8,28.19 v2(198.9,28.19) ; UV18.AH29 199.59,81.43 v2(199.13,80.97) 199.49,80.6 UV18.AH28 ; v2(202.5,63.37) 202.46,63.37 UV18.AE7 ; v2(220.81,70.11) 220.81,70.13 220.44,70.5 UV18.C16 ; v2(127.76,27.67) 127.37,27.28 JDIMM1.81 ; JDIMM2.209 237.67,27.51 v2(237.97,27.8) 238.29,27.8 238.67,27.42 JDIMM2.213 ; v2(196.64,82.65) 197.04,82.25 UV18.AL30 ; v2(129.64,27.91) 129.39,27.63 129.37,27.61 JDIMM1.89 ; v2(191.19,27.63) 191.18,27.61 JDIMM2.31 ; v2(204.11,28.45) 204.3,28.45 204.78,27.97 204.78,27.43 204.67,27.33 JDIMM2.85 ; JDIMM1.39 116.88,27.57 116.89,27.58 v2(116.89,27.59) ; JDIMM1.77 126.37,27.78 v2(125.71,28.44) 125.19,27.91 125.19,27.46 125.37,27.27 JDIMM1.73 ; JDIMM1.227 165.87,27.39 165.54,27.76 v2(165.39,27.76) 165.17,27.76 164.89,27.48 164.89,27.3 JDIMM1.223 ; v2(243.48,21.05) 243.22,21.05 241.93,19.75 JDIMM2.226 ; v2(223.2,63.28) 223.2,63.14 222.9,62.83 221.45,62.83 UV18.B7 ; v2(222.82,85.54) 222.42,85.14 221.54,85.14 221.24,85.45 UV18.B34 ; JNGFF1.61 345.55,84.67 345.18,85.04 344.12,85.04 v2(344.05,85.1) JNGFF1.55 ; v2(167.06,21.06) 167.24,21.06 167.63,20.67 167.63,20.03 166.63,19.02 166.63,18.15 ; UV18.AN7 195.39,63.05 v2(195.02,62.68) ; JDIMM1.217 163.37,27.4 v2(163.74,27.76) ; JNGFF2.65 261.74,4.54 v2(261.82,4.63) 261.41,5.04 JNGFF2.63 ; JDIMM1.43 117.88,27.55 117.23,28.19 v2(116.9,28.19) ; JDEG1.10 306.61,30.99 306.3,30.68 305.52,30.68 v2(305.36,30.84) ; UV18.R23 v2(210.32,76.78) UV18.T22 ; UV18.Y23 v2(206.37,76.77) UV18.W22 ; 232.3,16.86 v2(232.3,16.86) ; v2(195.48,28.43) 195.18,28.13 JDIMM2.47 ; JDIMM2.197 234.67,27.71 234.11,28.28 v2(233.51,28.28) ; v2(204.11,81.86) 204.55,82.3 UV18.AB30 ; v2(114.44,16.66) 114.11,16.66 113.62,17.14 JDIMM1.26 ; UV18.M13 v2(213.38,67.75) UV18.N14 ; JDIMM1.172 152.12,17.11 152.35,16.89 v2(152.43,16.89) ; UV18.Y16 v2(205.35,69.81) UV18.AA15 ; v2(150.48,19.37) 150.93,19.37 151.12,19.18 JDIMM1.168 ; JDIMM2.9 185.68,27.91 v2(186.03,28.26) ; v2(220.23,86.7) 220.31,86.63 220.31,85.98 220.01,85.68 220.01,85.12 UV18.D33 ; JNGFF2.15 261.8,19.04 262.23,19.48 v2(262.23,19.91) ; JNGFF1.49 342.55,84.94 v2(342.71,85.1) ; UV18.Y12 205.96,66.3 206.35,66.68 206.48,66.68 v2(206.54,66.74) ; JDIMM1.234 167.63,17.13 167.4,16.9 v2(167.37,16.9) ; JDIMM1.238 168.63,17.13 v2(168.88,16.87) ; UV18.M17 v2(214.37,71.83) ; JDIMM2.217 239.67,27.43 v2(239.29,27.82) ; UV18.AA22 v2(204.41,76.72) UV18.AB23 ; v2(204.68,22.26) 205.11,22.26 205.92,21.44 JDIMM2.90 ; UV18.N2 212.09,58.4 v2(212.14,58.35) ; JDIMM2.10 v2(185.92,20.01) ; UV18.K5 v2(215,61.71) ; UV18.AB2 v2(204.2,59.29) ; v2(216.79,75.97) 216.81,75.95 216.81,75.94 217.14,75.62 UV18.G22 ; v2(261.64,19.91) 261.64,20.25 261.34,20.54 JNGFF2.9 ; UV18.G16 217.14,70.57 v2(216.74,70.97) ; JFP.2 v2(221.65,5.06) ; JFP.8 v2(218.19,2.93) ; UV18.G13 217.14,68.05 ; UV18.N32 UV18.N33 ; UV18.T20 210.24,74.71 v2(210.37,74.71) 210.37,74.74 210.84,75.21 UV18.R21 ; v2(172.64,21.06) 172.86,21.06 173.17,20.76 173.17,20.23 172.12,19.19 JDIMM1.252
  BOTTOM w0.33: v2(20.51,96.63) 20.51,96.63 D125.2 ; D126.2 v2(20.68,98.59)
  BOTTOM w0.356: v2(108.66,21.91) 108.66,21.39 109.62,20.42 109.62,19.5 ; CA37.2 4.69,28.57 CA23.2 ; CA35.2 v2(14.16,34.22) 13.59,34.22 CA36.2 ; RT188.1 20.49,64.16 v2(20.85,64.52) 21.12,64.25 RT187.1 ; 109.62,19.5 109.64,19.49 110.31,19.49 110.62,19.18 JDIMM1.14 ; 109.62,19.5 JDIMM1.10 ; CA8.2 15.72,37.38 CA9.2 ; RT4.1 RT42.1 35.44,43.53 35.44,44.24 35.46,44.27 35.46,44.36 35.47,44.37 35.47,44.78 35.63,44.94 v2(35.63,45.02) ; v2(12.97,38.68) 13.2,38.45 CA10.2 ; v2(110.18,20.96) 110.32,20.96 110.76,20.53 110.76,20.17 111.62,19.3 JDIMM1.18 ; RT37.1 31.31,48.24 31.05,48.5 31.05,48.78 v2(30.61,49.22) ; CT157.2 28.61,59.6 RT186.2 ; v2(112.42,21.09) 112.19,21.09 111.81,20.71 111.81,20.1 112.62,19.29 JDIMM1.22 ; JDIMM1.6 108.62,20 107.92,20.71 v2(107.65,20.71) 107.39,20.71 107.11,20.43 107.11,19.85 107.62,19.34 JDIMM1.2
  BOTTOM w0.381: v2(34.48,46.52) 34.29,46.33 34.29,46.05 34.13,45.88 RT41.1 ; v2(8.47,33.79) CA32.2 8.43,33.21 CA78.2 ; CA121.2 6.57,10.3 6.19,9.91 v2(5.97,9.91) ; CH50.1 104.49,3.95 104.96,3.48 v2(104.96,2.83) ; v2(4.57,31.62) 4.2,31.98 CA120.1 CA33.2 4.2,33.52 CA34.2 ; UD2.3 258.7,4.95 v2(259.02,4.63) ; CZ29.2 339.34,46.36 339.34,45.82 v2(339.22,45.7) 339.65,45.27 CZ31.2 ; CT123.2 8.13,67.83 v2(8.85,68.56) ; v2(171.11,54.78) 171.58,55.25 RH150.1 ; CA122.2 7.16,16.65 v2(7.09,16.72) ; v2(27.94,100.59) 27.85,100.5 CT170.2 ; CA23.2 5.25,28.51 v2(5.67,28.1) ; v2(10.64,32.58) 10.61,32.61 RA16.1 ; CE73.2 153.47,9.36 154.01,9.9 CE74.2 155.02,9.9 155.45,9.47 v2(156.53,9.47) ; RH148.1 RH149.1 173.79,56.99 173.77,57.01 173.77,57.43 173.79,57.45 173.79,57.53 v2(173.84,57.58) ; v2(25.46,30.81) 26.1,30.81 26.29,30.99 ; RH568.2 v2(60.39,4.14) ; CT173.2 25.27,95.39 25.78,94.88 v2(25.85,94.88) ; CLRP1.2 107,1.94 v2(107.44,1.5) ; RT39.1 24.36,100.82 v2(24.45,100.91) 24.54,100.82 CT172.2 ; v2(13.27,21.3) 13.27,21.19 14.81,19.65 PU202.4
  BOTTOM w0.457: v2(1.33,45.09) 1.68,44.75 DA3.2 ; v2(8.45,25.28) 8.88,24.85 PQ228.3 ; v2(217.77,8.43) 218.19,8.43 C2974.2 ; v2(16.25,62.71) 16.68,62.71 17.35,62.04 PQ218.3 ; v2(1.34,30.92) 1.34,30.93 1.59,31.17 RA94.1
  BOTTOM w0.508: CR17.2 348.93,48.88 v2(349.1,49.04) ; v2(219.05,105.42) 218.42,104.8 RV613.2 ; v2(175.01,115.01) PC1522.2 ; v2(287.57,24.57) 287.65,24.57 287.66,24.58 287.81,24.58 287.88,24.65 288.2,24.65 288.26,24.58 289.21,24.58 289.91,25.28 PC610.2 ; v2(103.63,69.89) 103.63,69.92 103.82,70.11 PC1336.1 ; PR702.1 v2(190.56,119.58) ; v2(101.42,19.16) 101.94,18.64 CH178.2 ; v2(12.68,23.91) 12.68,23.53 13.32,22.88 PR265.1 ; v2(17.27,35.73) 17.27,35.33 CT105.2 ; v2(345.79,38.87) 345.76,38.84 345.76,38.11 344.88,38.11 CR11.2 ; v2(14.63,35.5) 15.18,35.5 15.6,35.09 15.62,35.09 CT162.2 ; DV12.2 v2(59.12,26.53) ; JTP.9 184.38,6.37 v2(184.85,6.37) ; RH589.2 65.77,14.82 65.34,15.25 65.34,16 v2(65.57,16.23) ; PC1370.2 124.3,90.5 v2(124.69,90.1) ; v2(169.86,119.4) 169.48,119.02 PC1005.2 ; PC1367.2 PC1368.2 PC1369.2 120.65,92.89 v2(120.97,92.57) ; v2(24.56,66.02) 24.56,66.3 24.88,66.62 UT5.4 25.91,66.62 26.35,67.06 CT153.2 ; CH175.2 121.81,94.55 CH3.2 121.71,94.65 v2(120.96,94.65) ; v2(344.8,40.47) 344.68,40.6 CR16.2 ; PR512.2 133.44,2.05 v2(133.95,1.55) ; PC701.1 v2(188.47,119.52) ; v2(333.44,33.47) 334.91,32 CR5.2 336.74,32 RR6.1 ; CV868.1 CV867.2 CV861.2 199.84,101.8 198.63,103.01 v2(198.31,103.01) ; v2(112.1,3.76) 112.1,4.33 v3(111.68,4.75) 111.21,5.22 v2(110.76,5.22) 110.33,5.22 110.12,5.02 CH199.2 110.12,4.78 109.41,4.07 CH198.2 ; v2(51.03,10.8) 50.61,11.22 PC306.2 ; v2(158.23,90.39) 158.23,90.28 158.22,90.27 RH472.2 RH466.2 ; v2(349.19,46.49) 348.62,47.06 CR18.2 ; JHDD.21 228.06,7.63 v2(227.97,7.63) ; v2(165.99,10.23) 166.07,10.16 CE82.2 CE81.2 ; v2(313.37,29.6) 313.22,29.44 JDEG1.12 ; JEDP1.42 75.03,30.7 75.68,31.36 v2(75.68,31.69) ; v2(102.02,51.48) 102.02,51.48 JUART.5 ; QV12.3 53.1,25.15 CV169.2 52.59,25.66 v2(52.59,26.44) ; CD47.2 254.27,5.33 253.91,5.69 v3(253.91,7.67) v2(254.43,8.19) ; v2(152.78,7.18) 152.15,6.55 152.15,6.36 ; RT190.2 17.83,58.92 CT144.2 ; v2(330.04,58.49) 330.14,58.49 330.46,58.81 CI2.2 ; v2(132.86,74.04) v3(132.16,74.04) 131.79,74.4 RH57.1 ; v2(116.1,97.11) 115.63,97.58 PC1134.1 ; PH1104.1 147.96,100.71 147.54,100.29 145.35,100.29 v2(144.95,100.69) ; v2(112.5,101.37) 112.5,101.51 PC1119.2 ; PR1106.1 108.59,107.2 108.14,106.75 v2(108.01,106.75) 108.52,106.24 PC1105.1 ; CZ82.2 186.84,84.54 186.91,84.48 187.5,84.48 v2(187.52,84.46) ; v2(261.44,26.03) 261.44,25.07 261.26,24.88 JNGFF2.68 ; v2(224.04,104.47) 224.03,104.47 224.36,104.8 RV614.2 ; RV567.2 213.74,53.85 v2(213.95,53.64) ; v2(242.42,109.94) 242.42,110.38 PR910.2 PR907.2 ; DE4.1 199.6,12.35 v2(200.26,11.7) ; PC609.2 286.64,32.65 v2(286.45,32.84) ; v2(12.55,71.22) 12.87,70.9 13.37,70.39 DT10.1 ; v2(189.44,62.52) 189.44,63.78 190.07,64.41 RV593.2 ; PC1049.2 203.26,54.36 v2(202.63,55) ; PC1395.2 180.18,92.4 PC1384.2 180.87,91.92 v2(181.29,92.34) ; v2(24.56,34.81) 25.25,34.12 YT1.2 v2(24.14,33.47) v2(24.14,32.84) v2(24.14,32.2) 23.71,31.77 YT1.4 ; v2(220.5,11.85) 219.1,13.24 C2973.2 ; PC1018.2 v2(163.34,119.63) ; CZ47.2 CZ88.2 179.6,83.12 v2(178.79,83.93) ; v2(183.07,117.74) 183.07,117.55 183.5,117.12 PC1520.2 ; v2(73.69,11.7) 73.5,11.88 RH538.2 ; v2(10.65,62.74) 10.65,62.84 9.48,64.02 8.18,64.02 CT122.2 ; CI4.2 314.55,29.73 v2(314.26,30.02) ; v2(179.85,3.95) 180.29,4.39 JAPS.19 ; PC1050.2 203.33,55.7 v2(203.96,56.33) ; v2(175.65,116.09) 175.78,115.96 PC1517.2 176.29,115.99 PR1511.2 ; v2(183.26,29.27) 183.25,29.28 JDIMM2.261 ; H52.1 v2(219.14,113.1) ; CT106.2 14.94,31.17 14.34,31.77 v2(14.21,31.77) ; v2(55.47,26.48) 56.1,27.1 JEDP1.43 ; CE80.2 CE79.2 188.25,13.82 189,13.07 v2(189,11.88) JTP.5 ; v2(96.6,37.3) 96.6,37.6 97.2,38.2 JFAN1.4 ; JEDP1.41 49.55,31.21 51.14,32.8 v2(51.14,33.11) ; v2(347.18,46.06) 346.71,46.06 RZ39.2 ; RI25.2 317.5,27.3 v2(317.29,27.09) ; v2(5.36,8.84) 5.36,9.38 CA137.1 ; JUART.4 104.31,51.35 v2(104.45,51.48) ; v2(246.25,112.09) 246.2,112.14 PC912.2 ; CV182.1 CV181.1 15.69,90.36 RV123.2 16.57,90.28 16.57,89.86 v2(16.77,89.67) ; v2(324.91,34.02) 324.52,34.02 CI3.2 ; CV934.2 201.99,97.47 v2(201.74,97.22) ; v2(110.36,108.72) 110.68,109.04 PR1104.1 ; v2(338.09,51.13) 338.09,51.13 JTS.8 ; JTS.6 332.79,50.97 v2(333.44,51.62) ; RH109.2 102.78,15.24 CH177.2 101.53,15.72 v2(101.15,15.35) ; RH469.2 177.01,89.57 178.41,88.17 v2(178.79,88.17) ; v2(316.74,37.22) 317.44,37.22 317.62,37.04 RI23.2 ; v2(104.29,66.05) 104.86,65.48 PC813.2 ; CR6.2 v2(330.77,38.17) ; CR4.2 v2(330.71,36.97) ; PC502.2 135.19,6.53 v2(134.62,5.96) ; PC800.2 109.03,65.73 v2(109.41,66.11) ; RV589.2 190.18,62.4 v2(190.76,62.97) 191.03,62.69 RV592.2 ; CR2.2 335.43,38.17 v2(335.56,38.3) ; UA3.2 v2(4.89,12.73) ; v2(127.94,84.35) 128.42,83.88 RH475.2 ; v2(228.22,60.25) 228.2,60.25 CV862.2 CV871.2 ; v2(7.64,18.87) 7.64,18.7 PQ230.3 ; JFAN2.6 v2(323.79,43.5) ; JTS.7 332.15,52.55 332.72,53.12 v2(333.42,53.12) ; v2(129.55,82.46) 130.09,81.92 RH497.1 ; CR3.2 336.95,41.72 v2(336.86,41.63) ; v2(20.87,91) 21.27,90.6 PC114.2 PC115.2 ; v2(103.01,21.84) 102.76,21.59 CH179.2 ; PR704.1 v2(194.31,119.58) ; DA2.2 9.24,59.65 RA73.1 7.15,59.65 v2(6.55,60.25) ; RZ43.1 313.69,34.16 v2(313.24,34.61) ; R1054.2 224.82,8.7 224.97,8.7 225.03,8.64 v2(225.17,8.64) ; RA80.2 v2(3.1,15.31) ; JNGFF2.69 v2(263.65,2.94) ; PC1302.1 v2(104.51,78.8) ; CV180.1 v2(15.63,91.97) ; v2(179.33,118.12) 179.27,118.18 PR1519.2 ; v2(136.63,107.92) 136.16,107.46 PC1200.1 ; v2(169.17,109.93) 169.17,110.41 PC1030.2 ; JTS.3 335.19,51.22 v2(334.83,51.58) ; v2(304.51,29.61) 304.52,29.61 JDEG1.11 ; PR1405.2 244.03,106.18 v2(243.17,105.32) ; v2(8.76,21.32) 8.76,20.82 9.18,20.41 PC216.2 PC214.1 ; PR273.2 19.13,20.07 19.24,20.19 v2(19.24,20.2) 19.24,20.96 PC215.1 PC217.2 ; PR1011.2 PR1022.2 173.32,114.64 v2(173.88,114.64) ; v2(11.79,69.39) 11.82,69.42 DT174.2 ; v2(236.18,14.06) 236.73,13.51 CS12.2 CS14.2 CS13.2 v2(238.51,14.04) ; v2(120.98,91.1) 121.58,90.5 PC1366.2 ; v2(239.91,109.91) 240.48,110.47 PC900.2 ; v2(200.9,11.68) 200.99,11.68 202.73,13.42 203.71,13.42 ; JFAN1.6 v2(94.6,36.2) ; PH1100.1 v2(104.52,84.91) ; PC1234.2 150.56,116.91 v2(151.37,116.91) ; v2(230.38,7.17) 230.97,6.58 JHDD.23 ; CV933.2 202.38,101.42 202.19,101.61 v2(202.09,101.61) ; CR8.2 333.74,40.83 333.25,40.33 v2(333.19,40.33) ; PC512.2 v2(137.03,3.31) ; v2(24.26,52.46) 24.07,52.27 RT1092.1 ; CR1.2 v2(335.52,36.79) ; PR1104.1 PR1100.1 ; PR1104.1 PC1139.1 ; PC903.2 v2(243.08,114.18) ; v2(253.31,32.11) 253.31,33.75 252.8,34.25 251.39,34.25 JDIMM2.262 249.21,34.25 248.7,34.76 v2(248.7,36.24) ; v2(326.01,37.47) 326.01,38.24 326.5,38.73 JFAN2.4 ; v2(167.11,3.51) 167.99,4.39 JAPS.20 ; JEDP1.44 67.49,30.13 68.04,30.68 v2(68.04,31.71) ; PC513.2 137.29,5.22 v2(137.86,5.22) ; JLPDE1.11 294.1,29.44 v2(294.26,29.6) ; PR607.2 v2(293.54,32.1) ; PR327.2 59.11,9.71 59.69,10.3 59.69,10.68 ; CZ86.2 181.23,85.04 v2(182.5,86.31) ; v2(214.33,9.32) 215.7,10.69 JSPI1.22 ; H58.1 125.08,113.5 v2(125.41,113.17) ; PC607.1 v2(286.58,25.41) ; RH166.1 132.49,79.38 v2(132.95,79.84) ; JFAN2.5 v2(326.85,43.5) ; v2(34.67,30.59) 34.67,30.82 34.29,31.2 33.78,31.2 33.71,31.12 UT2.4 ; DI3.1 v2(335.09,46.11) ; v2(239.33,70.11) 240.03,70.81 CV987.2 ; JNGFF1.69 v2(348.15,82.83) ; CA11.2 v2(14.25,37.91) ; RI11.2 RI12.2 338.21,60.79 v2(338.01,60.59) ; RH556.1 70.09,9.26 69.5,9.85 v2(69.5,10) ; CA9.2 16.45,37.09 v2(16.69,37.33) ; JFAN1.5 v2(93.33,39.5) ; RV135.2 54.23,23.76 v2(53.85,24.14) ; v2(194.24,6.36) 195.63,7.75 JTP.10 ; PC1117.2 v2(124.27,104.34) ; H25.1 v2(108.47,54.55) ; PC1406.2 244.84,100.96 244.34,101.46 244.34,102.5 PR1404.2 243.61,102.75 v2(243.15,103.21) ; v2(154.18,118.63) 154.06,118.51 PC1249.1 ; RV1077.2 v2(219.52,54.59) ; RV578.1 191.2,87.17 v2(191.9,87.87) ; JHDD.24 237.74,6.58 v2(237.57,6.75) ; JHDD.22 244.15,8.53 244.86,7.82 v2(244.86,6.77) ; v2(133.64,78.01) 133.26,78.39 132.27,78.39 131.79,77.91 RH58.1 RH59.2 ; CT54.2 CT53.2 20.51,41.06 v2(21.09,41.64) ; PC614.2 v2(293.43,30.23) ; JLPDE1.12 302.8,29.37 v2(303,29.56) ; v2(104.9,63.06) 104.33,62.49 PC812.2 ; v2(328.55,85.15) 327.91,85.15 JNGFF1.68 ; CZ26.2 v2(344.89,46.58) ; PR701.1 v2(191.52,119.58) ; JUART.6 v2(102.02,48.88) ; v2(222.7,8.61) 222.37,8.28 DI13.1 ; PC913.2 v2(246.25,113.36) ; PC611.2 v2(262.05,26.04) ; CV990.2 v2(236.54,75.13) ; PR703.1 v2(189.61,119.58) ; PC1227.1 v2(136.63,112.51)
  vias: v2(0.43,15.45) v2(1.33,93.88) v2(1.33,74) v2(1.33,42.27) v2(1.33,41.69) v2(1.33,39.7) v2(1.33,30.27) v2(1.33,22.91) v2(1.33,7.93) v2(1.37,47.7) v2(1.91,15.82) v2(1.92,4.44) v2(2.1,0.43) v2(2.64,5.61) v2(3.83,112.57) v2(3.87,42.55) v2(3.93,6.12) v2(4.46,42.55) v2(5.27,67.04) v2(5.26,64.56) v2(5.63,95.72) v2(5.56,5.48) v2(5.78,92.21) v2(5.8,75.65) v2(6,110.68) v2(6.12,4.04) v2(6.61,39.98) v2(6.61,38.45) v2(6.73,36.42) v2(8.64,39.98) v2(8.64,38.32) v2(8.64,36.42) v2(8.84,61.15) v2(9.49,6.55) v2(9.72,12.8) v2(9.72,0.43) v2(9.9,12.24) v2(9.98,90.29) v2(9.98,77.59) v2(10.01,13.33) v2(10.23,73.65) v2(10.23,71.9) v2(10.19,71.2) v2(10.19,69.41) v2(10.59,61.15) v2(10.67,39.98) v2(10.67,38.32) v2(10.67,36.42) v2(11.94,8.07) v2(11.98,8.77) v2(12.24,73.95) v2(12.31,74.92) v2(12.49,18.47) v2(12.5,9.09) v2(12.5,8.43) v2(12.5,7.79) v2(12.5,7.16) v2(12.83,10.04) v2(12.9,18.88) v2(12.96,9.47) v2(13.13,108.42) v2(13.13,101.56) v2(13.07,95.78) v2(13.32,89.45) v2(13.55,74.99) v2(13.53,10.74) v2(13.46,10.11) v2(14.16,10.74) v2(16.07,65.66) v2(16.08,63.89) v2(16.53,112.57) v2(16.69,38.08) v2(17.28,38.08) v2(17.27,37.46) v2(17.27,10.61) v2(17.34,0.43) v2(17.53,31.95) v2(18.66,37.64) v2(18.66,35.87) v2(19.18,96.95) v2(19.55,110.61) v2(19.62,95.4) v2(20,106.69) v2(20.19,110.61) v2(20.7,24.2) v2(20.88,110.63) v2(21.11,46.12) v2(21.25,85.33) v2(21.2,83.56) v2(21.21,81.42) v2(21.33,87.1) v2(21.27,46.74) v2(21.53,45.71) v2(21.93,111.08) v2(21.92,95.41) v2(22.07,58.02) v2(22.73,64.71) v2(22.82,39.04) v2(22.84,37.74) v2(23.19,96.22) v2(23.42,84.35) v2(23.46,41.64) v2(23.46,40.34) v2(23.46,39.69) v2(23.46,39.04) v2(23.76,104.29) v2(23.75,97.86) v2(24,84.35) v2(24.15,112.57) v2(24.11,41.64) v2(24.11,37.74) v2(24.11,37.09) v2(24.22,102.41) v2(24.56,60.38) v2(24.65,50.98) v2(24.84,58.62) v2(24.75,57.4) v2(24.87,58.01) v2(24.96,0.43) v2(25.17,65.85) v2(25.39,90.71) v2(25.4,52.37) v2(25.41,40.34) v2(25.91,94.05) v2(26.06,43.61) v2(26.06,37.09) v2(26.33,50.74) v2(26.36,49.14) v2(26.54,105.55) v2(26.49,94.05) v2(26.82,79.76) v2(27.31,106.94) v2(27.31,104.02) v2(27.36,81.48) v2(27.42,79.76) v2(27.43,49.16) v2(27.36,40.99) v2(27.8,75.61) v2(27.94,81.47) v2(27.97,80.86) v2(27.95,80.26) v2(27.97,79.55) v2(28.01,42.29) v2(28.07,73.48) v2(28.27,75.99) v2(28.45,77.99) v2(28.48,81.73) v2(28.48,81.14) v2(28.48,80.56) v2(28.47,79.94) v2(28.46,79.22) v2(28.9,49.47) v2(29.13,17.01) v2(29.31,42.29) v2(29.34,16.2) v2(29.37,66.11) v2(29.44,63.57) v2(29.57,109.53) v2(29.57,103.31) v2(29.57,95.85) v2(29.57,88.23) v2(29.57,80.61) v2(29.71,61.05) v2(29.72,17.01) v2(29.94,40.34) v2(29.92,16.2) v2(29.98,49.21) v2(30.18,58.55) v2(30.29,54.49) v2(30.3,17.01) v2(30.51,16.2) v2(30.86,56.1) v2(31.29,21.33) v2(31.72,53.72) v2(31.88,21.33) v2(32.58,0.43) v2(32.78,51.41) v2(34.02,49.19) v2(35.43,47.07) v2(35.46,18.94) v2(35.46,18.36) v2(35.46,17.77) v2(35.45,17.19) v2(37.01,45.09) v2(37.12,42.22) v2(38.37,40.09) v2(38.73,43.22) v2(40.2,0.43) v2(40.59,41.49) v2(41.16,39.04) v2(42.59,39.92) v2(42.61,21.03) v2(43.19,21.03) v2(44.2,21.03) v2(44.4,38.14) v2(44.78,21.03) v2(45.65,35.93) v2(47.7,27.07) v2(47.82,0.43) v2(48.16,36.32) v2(48.2,34.07) v2(48.9,4.1) v2(48.9,3.51) v2(49,5.66) v2(49.51,34.25) v2(49.48,4.1) v2(49.48,3.51) v2(49.58,5.66) v2(49.94,1.82) v2(50.06,4.1) v2(50.06,3.51) v2(50.17,5.66) v2(50.24,2.94) v2(50.18,2.36) v2(50.52,1.82) v2(50.63,35.73) v2(50.65,4.1) v2(50.65,3.51) v2(50.75,5.66) v2(50.83,2.94) v2(50.76,2.36) v2(51.11,1.82) v2(51.23,4.1) v2(51.23,3.51) v2(51.33,5.66) v2(51.35,2.36) v2(51.41,2.94) v2(51.69,1.82) v2(51.82,4.1) v2(51.82,3.51) v2(51.93,2.36) v2(51.99,2.94) v2(53.01,19.49) v2(53.06,34.99) v2(55.44,0.43) v2(55.54,34.44) v2(56.33,4.01) v2(58.06,34.11) v2(59.28,11.5) v2(60.59,33.97) v2(61.8,20.57) v2(62.83,1.48) v2(63.13,33.97) v2(63.31,16.3) v2(63.7,20.86) v2(64.58,14.59) v2(65.67,33.97) v2(66.51,21.4) v2(68.21,33.97) v2(68.84,4.45) v2(69.05,21.4) v2(70.34,0.43) v2(70.75,33.97) v2(70.93,21.38) v2(73.29,34.05) v2(74.04,22.6) v2(75.81,34.34) v2(76.29,31.82) v2(76.85,26.08) v2(76.88,31.82) v2(77.45,26.12) v2(77.47,31.84) v2(77.85,3.34) v2(77.96,0.43) v2(78.31,34.83) v2(78.73,20.63) v2(79.41,21.62) v2(79.62,20.67) v2(79.88,24.77) v2(80.27,23.16) v2(80.75,35.52) v2(80.9,16.14) v2(81.1,7.22) v2(81.15,22.23) v2(81.46,17.16) v2(81.46,12.7) v2(81.56,19.43) v2(81.56,18.58) v2(81.79,22.46) v2(82.22,13.74) v2(82.22,11.28) v2(82.28,8.34) v2(82.84,24.73) v2(82.94,23.34) v2(83,20.71) v2(83.03,9.42) v2(83.13,36.4) v2(83.22,19.5) v2(83.36,35.19) v2(83.75,17.16) v2(83.75,13.74) v2(83.75,12.66) v2(83.85,35.52) v2(83.87,19.5) v2(84.39,14.8) v2(84.56,12.63) v2(84.86,24.66) v2(85.03,19.44) v2(85.05,22.03) v2(85.43,37.48) v2(85.58,0.43) v2(85.81,16.09) v2(85.81,15.32) v2(85.81,14.54) v2(85.81,12.22) v2(86.29,21.99) v2(86.29,10.16) v2(86.58,16.09) v2(86.58,12.22) v2(87.33,24.72) v2(87.33,21.99) v2(87.29,10.96) v2(87.29,10.18) v2(87.36,16.87) v2(87.36,12.22) v2(87.64,38.73) v2(88.13,16.87) v2(88.27,19.63) v2(88.71,6.17) v2(88.91,16.87) v2(88.91,16.09) v2(88.91,15.32) v2(88.91,14.54) v2(89.74,40.17) v2(89.74,24.7) v2(89.71,19.7) v2(89.68,16.87) v2(89.68,16.09) v2(89.68,15.32) v2(89.68,14.54) v2(90.46,12.22) v2(90.75,21.99) v2(90.75,19.7) v2(90.81,10.93) v2(91.23,17.64) v2(91.72,41.76) v2(91.83,24.7) v2(91.95,26.76) v2(92.03,18.83) v2(92.07,21.9) v2(92.3,11.18) v2(93.12,20.32) v2(93.07,11.18) v2(93.09,10.43) v2(93.16,18.47) v2(93.2,0.43) v2(93.42,27.03) v2(93.56,43.51) v2(93.66,9.52) v2(93.94,10.44) v2(93.96,26.72) v2(93.96,11.18) v2(94.05,12.64) v2(94.21,24.72) v2(94.75,21.45) v2(94.75,20.61) v2(94.69,11.17) v2(94.77,19.43) v2(94.83,18.63) v2(94.83,16.14) v2(95.02,27.15) v2(95.39,23.54) v2(95.58,18.61) v2(95.89,21.66) v2(96.1,22.53) v2(96.34,16.12) v2(96.69,23.25) v2(96.79,47.43) v2(96.9,20.56) v2(97.05,22.56) v2(97.04,8.09) v2(97.09,21.54) v2(97.18,24.75) v2(97.4,27.26) v2(98.15,49.57) v2(98.25,18.6) v2(98.32,24.76) v2(98.28,20.64) v2(98.31,13.79) v2(98.87,24.2) v2(99.34,51.81) v2(99.54,31.97) v2(100,5.32) v2(100.35,54.14) v2(100.59,5.38) v2(100.81,24.79) v2(100.82,0.43) v2(101.16,56.55) v2(101.78,59.02) v2(102.05,33.4) v2(102.25,32.39) v2(102.43,94.53) v2(102.43,91.99) v2(102.44,66.57) v2(102.44,64.92) v2(102.51,91.15) v2(102.48,79.28) v2(102.49,76.74) v2(102.49,74.21) v2(102.49,71.67) v2(102.48,69.15) v2(102.55,81.23) v2(102.56,56.41) v2(103.02,97) v2(103.67,33.14) v2(103.93,119.69) v2(103.93,117.15) v2(103.93,114.61) v2(103.93,112.07) v2(103.93,109.53) v2(103.93,106.99) v2(103.93,104.45) v2(103.93,101.91) v2(103.93,99.37) v2(104.65,93.04) v2(105.64,117.52) v2(105.88,121.32) v2(106.36,36.92) v2(106.76,71.12) v2(107.05,119.82) v2(107.02,36.92) v2(107.06,75.28) v2(107.06,73.36) v2(107.07,72.72) v2(107.34,24.46) v2(107.61,76.65) v2(107.61,75.95) v2(107.61,36.92) v2(107.68,72.72) v2(107.83,82.9) v2(107.83,80.98) v2(107.79,80.35) v2(107.82,78.66) v2(107.82,71.01) v2(107.82,70.43) v2(107.95,57.41) v2(107.95,56.02) v2(108.09,59.38) v2(108.42,121.32) v2(108.42,80.32) v2(108.44,0.43) v2(108.5,78.71) v2(108.48,75.28) v2(108.48,73.36) v2(108.46,71.01) v2(108.46,70.43) v2(108.66,23.82) v2(109.03,117.99) v2(109.03,59.66) v2(109.13,78.67) v2(109.14,78.08) v2(109.07,71.01) v2(109.07,70.43) v2(109.24,82.9) v2(109.24,80.98) v2(109.17,77.48) v2(109.17,76.87) v2(109.17,76.23) v2(109.17,75.6) v2(109.27,85.82) v2(109.31,85.16) v2(109.34,84.24) v2(109.3,83.57) v2(109.54,59.32) v2(109.54,56.33) v2(109.6,57.73) v2(109.67,71.01) v2(109.67,70.43) v2(109.82,96.38) v2(109.82,95.77) v2(109.82,95.11) v2(109.77,78.67) v2(109.78,78.08) v2(109.81,77.48) v2(109.81,76.87) v2(109.81,76.23) v2(109.81,75.6) v2(109.86,85.8) v2(109.92,85.18) v2(109.86,84.53) v2(109.86,83.89) v2(109.86,83.26) v2(110.02,59.67) v2(110.24,57.73) v2(110.24,56.33) v2(110.18,23.5) v2(110.18,22.23) v2(110.46,96.14) v2(110.46,95.53) v2(110.46,94.87) v2(110.49,85.8) v2(110.49,84.53) v2(110.49,83.89) v2(110.49,83.26) v2(110.45,59.25) v2(110.61,120.02) v2(110.59,94.23) v2(110.59,93.6) v2(110.59,92.96) v2(110.55,85.18) v2(111.1,96.14) v2(111.1,95.53) v2(111.1,94.87) v2(111.13,85.8) v2(111.13,84.58) v2(111.19,85.2) v2(111.29,94.23) v2(111.29,93.6) v2(111.29,92.96) v2(111.73,96.14) v2(111.73,95.53) v2(111.7,94.78) v2(111.76,85.8) v2(111.82,85.2) v2(111.76,84.58) v2(111.92,94.23) v2(111.92,93.6) v2(112.07,117.94) v2(112.17,95.13) v2(112.42,23.63) v2(112.42,22.36) v2(113.35,79.07) v2(113.35,78.43) v2(113.35,77.8) v2(113.35,77.16) v2(113.35,76.53) v2(113.35,75.89) v2(113.35,75.26) v2(113.95,79.07) v2(113.95,78.43) v2(113.95,77.8) v2(113.95,77.16) v2(113.95,76.53) v2(113.95,75.89) v2(113.95,75.26) v2(114.37,22.67) v2(114.37,20.77) v2(114.58,117.57) v2(114.56,79.07) v2(114.56,78.43) v2(114.56,77.8) v2(114.56,77.16) v2(114.56,76.53) v2(114.56,75.89) v2(114.56,75.26) v2(114.62,56.46) v2(115.06,56.84) v2(115.23,107.85) v2(115.23,105.89) v2(115.23,103.92) v2(115.19,59.79) v2(115.19,59.2) v2(115.19,58.62) v2(115.19,58.02) v2(115.19,57.41) v2(115.64,23.63) v2(115.64,22.36) v2(115.64,21.09) v2(115.83,59.79) v2(115.83,58.07) v2(115.83,57.49) v2(115.98,85.7) v2(115.98,85.11) v2(116.06,0.43) v2(116.27,92.08) v2(116.52,93.54) v2(116.61,85.7) v2(116.61,85.11) v2(116.9,92.08) v2(117,118.35) v2(117.15,116.58) v2(117.2,107.85) v2(117.2,105.89) v2(117.2,103.92) v2(117.16,93.54) v2(117.25,85.7) v2(117.25,85.11) v2(117.54,92.08) v2(117.88,85.7) v2(117.88,85.11) v2(118.03,54.54) v2(118,23.5) v2(118,22.23) v2(118,20.96) v2(118.17,92.08) v2(118.4,120.47) v2(119.08,118.7) v2(119.17,107.85) v2(119.17,105.89) v2(119.17,103.92) v2(119.27,23.82) v2(119.89,120.02) v2(119.89,116.98) v2(120.21,68.27) v2(120.21,67.64) v2(120.21,67) v2(120.75,23.5) v2(120.75,22.23) v2(120.75,20.96) v2(120.7,3.18) v2(120.68,2.6) v2(120.84,68.91) v2(120.84,68.27) v2(120.94,116.59) v2(121.03,120.35) v2(121.1,3.78) v2(121.29,3.18) v2(121.29,2.6) v2(121.73,3.78) v2(121.83,4.4) v2(121.91,3.18) v2(121.91,2.6) v2(122.12,116.98) v2(122.18,120.02) v2(122.42,4.39) v2(122.37,3.78) v2(122.42,2.89) v2(123.16,23.5) v2(123.16,22.23) v2(123.16,20.96) v2(123.34,121.32) v2(123.68,0.43) v2(124.43,22.55) v2(124.43,20.64) v2(125.88,121.32) v2(126.41,23.5) v2(126.41,22.23) v2(126.41,20.96) v2(126.67,62.3) v2(126.8,57.69) v2(127.73,62.54) v2(127.8,57.5) v2(128.42,121.32) v2(128.59,116.09) v2(128.82,57.74) v2(128.84,9.85) v2(128.91,62.26) v2(129.22,116.09) v2(129.43,9.85) v2(129.86,116.09) v2(130.01,9.85) v2(130.49,116.09) v2(130.6,9.85) v2(130.84,7.76) v2(131.13,116.09) v2(131.19,9.85) v2(131.3,0.43) v2(131.43,7.76) v2(131.73,28.61) v2(131.79,9.85) v2(132.03,7.76) v2(132.39,9.85) v2(132.5,67.45) v2(133.03,116.09) v2(133,9.85) v2(133.63,9.85) v2(133.67,116.09) v2(133.93,23.75) v2(133.93,22.43) v2(133.93,21.14) v2(133.93,19.9) v2(134.3,116.09) v2(134.75,71.66) v2(134.77,79.39) v2(134.77,75.64) v2(134.94,116.09) v2(135.28,65.59) v2(135.41,78) v2(135.38,74.04) v2(135.37,60.46) v2(135.57,116.09) v2(135.63,59.45) v2(135.57,54.82) v2(135.57,54.18) v2(135.57,53.55) v2(135.57,52.91) v2(135.57,52.3) v2(135.78,23.4) v2(135.78,22.11) v2(135.78,20.74) v2(136.02,64.31) v2(136.68,79.39) v2(136.68,75.64) v2(136.87,56.38) v2(137.68,105.28) v2(137.76,100.86) v2(137.84,23.54) v2(137.82,22.16) v2(137.86,20.94) v2(138.09,57.65) v2(138.41,55.12) v2(138.41,54.37) v2(138.41,53.73) v2(138.41,53.1) v2(138.41,52.46) v2(138.41,51.88) v2(138.58,121.32) v2(138.91,105.61) v2(138.92,0.43) v2(139.06,100.58) v2(139.48,58.77) v2(139.82,56.31) v2(140.13,105.3) v2(140.08,23.59) v2(140.08,22.32) v2(140.08,21.08) v2(140.28,100.97) v2(141.12,121.32) v2(141.17,57.66) v2(141.32,111.61) v2(141.32,109.68) v2(141.38,117.22) v2(141.38,115.29) v2(141.35,108.97) v2(141.92,119.19) v2(141.92,117.99) v2(141.99,118.6) v2(142.18,112.44) v2(142.19,55.96) v2(142.3,24.16) v2(142.3,22.25) v2(142.43,112.98) v2(142.56,119.19) v2(142.62,118.6) v2(142.62,117.99) v2(142.73,111.61) v2(142.73,109.68) v2(142.67,6.38) v2(142.79,117.22) v2(142.79,115.29) v2(142.81,112.44) v2(142.77,2.63) v2(142.86,54.34) v2(142.86,53.71) v2(142.86,53.07) v2(142.86,52.44) v2(143.13,112.98) v2(143.19,119.19) v2(143.26,118.6) v2(143.27,117.93) v2(143.32,111.83) v2(143.47,112.5) v2(143.49,57.24) v2(143.66,121.32) v2(143.74,55.79) v2(143.71,6.66) v2(143.83,112.98) v2(143.82,2.4) v2(143.89,119.19) v2(143.89,118.56) v2(143.89,117.94) v2(143.92,117.34) v2(143.89,113.8) v2(143.89,111.58) v2(144.02,112.15) v2(144.4,113.29) v2(144.4,112.66) v2(144.4,81.48) v2(144.53,119.19) v2(144.53,118.56) v2(144.46,111.39) v2(144.59,111.96) v2(144.8,22.61) v2(144.8,21.34) v2(144.76,6.36) v2(144.81,2.63) v2(145.16,119.19) v2(145.16,118.56) v2(145.16,81.49) v2(145.8,119.19) v2(145.8,118.56) v2(146.2,121.32) v2(146.43,119.19) v2(146.43,118.56) v2(146.54,53.67) v2(146.47,22.61) v2(146.47,21.34) v2(146.54,0.43) v2(146.74,81.49) v2(147.07,119.19) v2(147.07,118.56) v2(147.36,54.49) v2(147.5,81.5) v2(147.7,119.19) v2(147.7,118.56) v2(148.34,119.19) v2(148.34,118.56) v2(148.45,65.34) v2(148.45,64.7) v2(148.74,121.32) v2(148.91,117.99) v2(148.97,119.19) v2(149.04,118.56) v2(149.07,81.49) v2(149.18,22.61) v2(149.18,21.34) v2(149.52,117.99) v2(149.53,55.51) v2(149.61,119.19) v2(149.67,118.56) v2(149.89,81.49) v2(150.11,117.99) v2(150.05,58.56) v2(150.31,119.19) v2(150.31,118.56) v2(150.31,99.01) v2(150.31,98.37) v2(150.31,97.67) v2(150.31,97.04) v2(150.42,88.4) v2(150.75,117.99) v2(150.74,23.85) v2(150.74,22.58) v2(150.74,21.31) v2(150.94,119.19) v2(150.94,118.56) v2(151.28,121.32) v2(151.26,53.64) v2(151.29,51.71) v2(151.38,117.99) v2(151.5,81.49) v2(151.58,119.19) v2(151.58,118.56) v2(152.02,117.99) v2(152.21,119.19) v2(152.21,118.56) v2(152.23,81.5) v2(152.39,56.37) v2(152.39,54.4) v2(152.85,5.85) v2(153.02,66.56) v2(153.29,23.6) v2(153.29,22.33) v2(153.82,121.32) v2(153.82,81.49) v2(153.93,1.48) v2(154.18,114.88) v2(154.18,7.18) v2(154.59,81.48) v2(154.69,115.64) v2(154.76,114.88) v2(154.76,114.25) v2(155.07,23.92) v2(155.07,22.01) v2(155.25,52.5) v2(155.25,51.91) v2(155.25,51.33) v2(155.25,50.75) v2(155.58,5.85) v2(156.14,56.68) v2(156.19,81.49) v2(156.16,58.57) v2(156.3,53.87) v2(156.31,52.07) v2(156.4,115.01) v2(156.4,114.37) v2(156.46,23.6) v2(156.46,22.33) v2(156.46,21.06) v2(156.94,81.49) v2(157.06,114.98) v2(157.06,113.56) v2(157.39,57.84) v2(157.39,56.01) v2(157.5,54.12) v2(158.88,23.6) v2(158.88,22.33) v2(158.88,21.06) v2(158.98,114.98) v2(158.98,113.56) v2(159.07,112.98) v2(159.51,112.53) v2(159.58,114.75) v2(159.58,113.99) v2(159.56,113.37) v2(159.92,56.01) v2(159.94,53.8) v2(160.08,114.28) v2(160.08,113.7) v2(160.15,113.12) v2(160.11,112.53) v2(160.32,22.65) v2(160.32,20.74) v2(160.4,114.79) v2(160.59,99.45) v2(160.59,98.81) v2(160.59,98.18) v2(160.59,97.54) v2(160.59,96.85) v2(160.72,114.28) v2(160.72,113.7) v2(160.72,112.53) v2(160.78,113.12) v2(161.04,114.79) v2(161.01,53.4) v2(161.35,114.28) v2(161.35,113.7) v2(161.42,113.12) v2(161.35,112.53) v2(161.55,115.26) v2(161.55,1.48) v2(161.67,98.18) v2(161.67,97.54) v2(161.67,96.85) v2(161.69,81.48) v2(161.67,23.6) v2(161.67,22.33) v2(161.67,21.06) v2(161.93,115.77) v2(161.93,114.82) v2(161.93,114.12) v2(161.93,113.42) v2(162.43,57.49) v2(162.5,116.28) v2(162.5,115.64) v2(162.5,115.01) v2(162.5,114.37) v2(162.5,113.74) v2(163.13,115.01) v2(163.13,114.37) v2(163.13,113.74) v2(163.32,101.99) v2(163.28,81.49) v2(163.3,55.69) v2(163.64,101.35) v2(163.98,121.32) v2(163.96,101.99) v2(164.01,23.6) v2(164.01,22.33) v2(164.06,81.49) v2(164.24,54.22) v2(164.28,101.35) v2(164.66,101.99) v2(164.97,101.35) v2(164.96,57.09) v2(165.29,101.99) v2(165.53,23.92) v2(165.53,22.01) v2(165.61,101.35) v2(165.62,81.49) v2(165.74,109.36) v2(165.86,76.34) v2(165.86,75.7) v2(165.86,75.07) v2(165.86,74.43) v2(165.99,92.86) v2(165.99,92.27) v2(166.24,109.67) v2(166.24,108.85) v2(166.24,107.26) v2(166.31,55.74) v2(166.37,120.47) v2(166.43,81.5) v2(166.7,65.27) v2(166.76,95.39) v2(167.06,22.33) v2(167.34,95.39) v2(167.59,114.44) v2(167.6,54.44) v2(167.77,109.48) v2(167.77,108.85) v2(167.93,95.39) v2(168.03,81.5) v2(168.21,115.06) v2(168.21,113.81) v2(168.37,57.43) v2(168.51,95.39) v2(168.83,114.44) v2(168.91,120.47) v2(168.87,92.87) v2(168.87,92.29) v2(169.17,1.48) v2(169.36,102.75) v2(169.36,102.05) v2(169.36,101.35) v2(169.36,100.66) v2(169.36,99.96) v2(169.36,99.26) v2(169.38,95.39) v2(169.47,22.33) v2(169.47,21.06) v2(169.65,56.18) v2(170.12,108.53) v2(170.12,107.83) v2(170.12,107.13) v2(170.12,106.43) v2(170.12,105.74) v2(170.12,105.04) v2(170.12,98.41) v2(170.05,95.39) v2(170.18,102.75) v2(170.18,102.05) v2(170.18,101.35) v2(170.18,100.66) v2(170.18,99.96) v2(170.18,99.26) v2(170.69,95.39) v2(170.84,109.36) v2(170.75,98.41) v2(170.94,108.53) v2(170.94,107.83) v2(170.94,107.13) v2(170.94,106.43) v2(170.94,105.74) v2(170.94,105.04) v2(171.01,102.75) v2(171.01,102.05) v2(171.01,101.35) v2(171.01,100.66) v2(171.01,99.96) v2(171.01,99.26) v2(171,48.9) v2(171,48.26) v2(171.01,47.57) v2(171.25,22.65) v2(171.25,20.74) v2(171.26,109.8) v2(171.32,97.99) v2(171.32,97.35) v2(171.32,96.72) v2(171.32,95.39) v2(171.33,57.61) v2(171.45,120.47) v2(171.64,109.36) v2(171.59,48.4) v2(171.59,47.82) v2(171.6,47.21) v2(171.71,94.75) v2(171.77,108.53) v2(171.77,107.83) v2(171.77,107.13) v2(171.77,106.43) v2(171.77,105.74) v2(171.77,105.04) v2(171.83,102.75) v2(171.83,102.05) v2(171.83,101.35) v2(171.83,100.66) v2(171.83,99.96) v2(171.83,99.26) v2(171.96,97.99) v2(171.96,97.35) v2(171.96,96.72) v2(171.96,95.39) v2(172.15,109.74) v2(172.34,94.75) v2(172.59,108.53) v2(172.59,107.83) v2(172.59,107.13) v2(172.59,106.43) v2(172.59,105.74) v2(172.59,105.04) v2(172.59,97.99) v2(172.59,97.35) v2(172.59,96.72) v2(172.59,95.39) v2(172.64,23.6) v2(172.64,22.33) v2(172.68,56.26) v2(173.84,121.32) v2(175.98,27.76) v2(176.29,27.25) v2(176.38,121.32) v2(176.59,27.76) v2(176.85,30.18) v2(176.79,1.48) v2(178.92,121.32) v2(179.13,109.99) v2(179.13,109.36) v2(179.13,108.72) v2(179.13,108.09) v2(179.13,107.45) v2(179.13,106.82) v2(179.13,106.18) v2(179.13,105.55) v2(179.13,104.91) v2(179.13,104.28) v2(179.13,103.64) v2(179.13,103.01) v2(179.2,102.31) v2(179.2,101.67) v2(179.2,101.04) v2(179.2,100.4) v2(179.2,99.64) v2(179.2,99.01) v2(179.2,98.37) v2(179.2,97.74) v2(179.2,97.1) v2(179.2,96.47) v2(179.2,95.83) v2(179.2,95.2) v2(179.44,12.32) v2(180.19,12.34) v2(180.3,115.4) v2(180.92,116.02) v2(180.92,114.78) v2(181,12.33) v2(181.55,115.4) v2(181.8,53.41) v2(181.84,12.34) v2(182.61,12.35) v2(182.69,60.27) v2(183.21,12.35) v2(183.28,24.17) v2(183.81,12.35) v2(184.09,72.62) v2(184.37,58.4) v2(184.41,1.48) v2(184.53,54.15) v2(184.62,92.01) v2(184.63,87.53) v2(185.17,106.94) v2(185.17,106.33) v2(185.17,105.72) v2(185.17,105.11) v2(185.18,74.86) v2(185.23,23.84) v2(185.23,21.94) v2(185.52,101.09) v2(185.5,100.49) v2(185.59,67.26) v2(185.76,106.94) v2(185.76,106.33) v2(185.76,105.72) v2(185.76,105.11) v2(185.84,92.29) v2(185.78,87.25) v2(185.78,53.81) v2(185.9,58.85) v2(186.25,112.02) v2(186.24,82.75) v2(186.16,63.52) v2(186.4,106.94) v2(186.4,106.33) v2(186.4,105.72) v2(186.4,105.11) v2(186.54,100.47) v2(186.75,72.47) v2(186.75,69.03) v2(186.88,112.02) v2(187.03,107.7) v2(187.03,107.1) v2(186.98,87.55) v2(187.01,23.53) v2(187.01,22.26) v2(187.01,20.99) v2(187.07,105.42) v2(187.15,101.06) v2(187.14,100.47) v2(187.12,91.91) v2(187.12,54.19) v2(187.25,67.84) v2(187.26,78.43) v2(187.31,58.34) v2(187.52,112.02) v2(187.58,100.02) v2(187.58,99.44) v2(187.61,98) v2(187.64,77.19) v2(187.68,101.35) v2(187.68,100.72) v2(187.9,108.4) v2(187.9,107.58) v2(187.9,106.75) v2(187.9,105.93) v2(187.9,79.75) v2(188.09,65.73) v2(188.15,112.02) v2(188.22,63.76) v2(188.6,108.4) v2(188.6,107.58) v2(188.6,106.75) v2(188.6,105.93) v2(189.08,121.32) v2(189.17,83.38) v2(189.29,108.4) v2(189.29,107.58) v2(189.29,106.75) v2(189.29,105.93) v2(189.42,86.18) v2(189.42,23.53) v2(189.42,22.26) v2(189.42,20.99) v2(189.99,108.4) v2(189.99,107.58) v2(189.99,106.75) v2(189.99,105.93) v2(190.69,108.4) v2(190.69,107.58) v2(190.69,106.75) v2(190.69,105.93) v2(190.89,22.57) v2(190.89,20.67) v2(190.96,53.37) v2(191.39,108.4) v2(191.39,107.58) v2(191.39,106.75) v2(191.39,105.93) v2(191.52,116.4) v2(191.52,115.71) v2(191.52,115.01) v2(191.52,114.31) v2(191.52,113.61) v2(191.52,112.91) v2(191.52,112.21) v2(191.52,111.51) v2(191.62,121.32) v2(191.64,117.36) v2(191.9,88.48) v2(192.03,1.48) v2(192.22,117.04) v2(192.28,116.4) v2(192.28,115.71) v2(192.28,115.01) v2(192.28,114.31) v2(192.28,113.61) v2(192.28,112.91) v2(192.28,112.21) v2(192.28,111.51) v2(192.57,23.53) v2(192.57,22.26) v2(192.57,20.99) v2(192.72,110.82) v2(192.85,117.04) v2(192.91,94.31) v2(193.1,116.4) v2(193.1,115.71) v2(193.1,115.01) v2(193.1,114.31) v2(193.1,113.61) v2(193.1,112.91) v2(193.1,112.21) v2(193.1,111.51) v2(193.08,107.21) v2(193.36,110.82) v2(193.49,117.23) v2(193.87,116.4) v2(193.87,115.71) v2(193.87,115.01) v2(193.87,114.31) v2(193.87,113.61) v2(193.87,112.91) v2(193.87,112.21) v2(193.87,111.51) v2(194.16,121.32) v2(194.18,117.23) v2(194.31,110.82) v2(194.69,109.86) v2(194.69,109.23) v2(194.69,108.53) v2(194.69,107.9) v2(194.69,107.2) v2(194.69,106.56) v2(194.69,105.86) v2(194.69,105.23) v2(194.69,104.59) v2(194.89,89.4) v2(194.93,23.53) v2(194.93,22.26) v2(194.93,20.99) v2(196.61,23.84) v2(196.61,21.94) v2(196.7,121.32) v2(197.91,11.9) v2(198.07,121.31) v2(198.48,90.27) v2(198.61,23.53) v2(198.61,22.26) v2(198.61,20.99) v2(199.24,121.32) v2(199.59,0.94) v2(200.03,80.22) v2(200.61,121.31) v2(201.04,110.05) v2(201.04,109.42) v2(201,23.53) v2(201,22.26) v2(201,20.99) v2(201.78,121.32) v2(201.87,88.72) v2(202.65,23.21) v2(202.65,22.57) v2(203.84,87.13) v2(204.68,23.53) v2(206.06,114.63) v2(206.93,6.21) v2(206.95,88.43) v2(207.06,2.75) v2(207.16,0.43) v2(207.32,114.63) v2(207.91,114.63) v2(208.03,28.19) v2(208.26,6.64) v2(208.43,2.42) v2(208.52,114.63) v2(208.54,86.8) v2(209.13,114.63) v2(209.11,65.02) v2(209.49,49.6) v2(209.66,121.32) v2(209.74,114.63) v2(209.65,6.18) v2(209.65,2.83) v2(210.23,23.48) v2(210.23,22.19) v2(210.23,20.82) v2(210.2,16.86) v2(210.38,114.63) v2(210.38,65.79) v2(211.01,114.63) v2(211.65,114.63) v2(211.94,121.32) v2(212.08,23.4) v2(212.22,113.93) v2(212.22,113.34) v2(212.22,112.76) v2(212.85,113.93) v2(212.85,113.34) v2(212.85,112.76) v2(212.98,115.71) v2(212.98,115.1) v2(212.98,114.5) v2(213.27,64.52) v2(214.14,23.54) v2(214.12,22.16) v2(214.16,20.89) v2(214.3,93.06) v2(214.31,73.81) v2(214.48,121.32) v2(214.58,1.43) v2(216.38,23.59) v2(216.38,22.32) v2(216.38,21.08) v2(217.02,121.32) v2(217.74,68.14) v2(218.15,24.16) v2(218.15,22.25) v2(218.63,100.91) v2(219.56,121.32) v2(220.16,101.49) v2(220.32,107.57) v2(220.75,23.38) v2(220.72,21.84) v2(220.83,79.32) v2(220.85,75.99) v2(222.1,121.32) v2(222.12,107.64) v2(222.15,1.93) v2(222.65,20.75) v2(222.65,23.58) v2(222.65,22.21) v2(223.2,61.6) v2(223.33,76.46) v2(223.65,58.68) v2(223.88,106.69) v2(224.41,70.11) v2(224.64,121.32) v2(225.02,20.75) v2(225.55,65.91) v2(225.95,89.58) v2(226.26,24.08) v2(226.26,22.55) v2(226.33,11.88) v2(226.81,118.8) v2(227.18,121.32) v2(227.42,118.8) v2(227.81,16.87) v2(228.05,118.8) v2(228.49,11.88) v2(228.69,118.8) v2(228.83,23.57) v2(228.83,22.3) v2(228.83,21.03) v2(229.32,118.8) v2(229.49,0.43) v2(229.61,120.58) v2(229.96,118.8) v2(230.59,118.8) v2(230.6,23.89) v2(230.6,21.98) v2(231.23,118.8) v2(232.15,120.47) v2(232.37,23.59) v2(232.37,22.32) v2(232.37,21.05) v2(232.44,14.07) v2(234.36,119.22) v2(234.35,14.04) v2(234.66,23.59) v2(234.66,22.32) v2(234.66,21.05) v2(236.35,117.64) v2(236.44,22.63) v2(236.44,20.73) v2(236.7,72.65) v2(237.11,0.43) v2(237.81,116.59) v2(237.89,23.59) v2(237.89,22.32) v2(237.89,21.05) v2(238.44,116.59) v2(238.45,72.65) v2(238.62,84.59) v2(238.89,117.59) v2(238.93,46.48) v2(239.08,116.59) v2(239.71,116.59) v2(239.79,9.44) v2(240.18,23.59) v2(240.18,22.32) v2(240.18,21.05) v2(240.38,116.72) v2(240.37,9.44) v2(240.53,105.66) v2(240.51,104.97) v2(240.51,104.34) v2(240.52,103.47) v2(240.73,4.52) v2(240.83,117.17) v2(241.01,118.99) v2(241,9.44) v2(241.27,117.62) v2(241.58,9.44) v2(241.7,23.9) v2(241.7,22) v2(242.03,121.32) v2(242.19,119.2) v2(242.16,9.44) v2(242.44,4.52) v2(242.51,88.97) v2(242.7,119.52) v2(242.7,118.88) v2(242.76,54.62) v2(243.52,100.66) v2(243.52,54.62) v2(243.48,23.59) v2(243.48,22.32) v2(244.41,54.62) v2(244.57,121.32) v2(244.58,0.44) v2(245.17,54.59) v2(245.77,23.59) v2(245.77,22.32) v2(245.77,21.05) v2(245.92,106.12) v2(245.94,102.56) v2(245.94,101.93) v2(246,101.23) v2(246.13,92.4) v2(246.23,1.34) v2(246.48,2.61) v2(246.91,84.08) v2(247.02,120.63) v2(247.32,61.92) v2(247.29,22.63) v2(247.29,20.73) v2(247.56,107.46) v2(247.56,106.83) v2(248.2,107.46) v2(248.2,106.83) v2(248.6,107.96) v2(248.81,23.59) v2(248.81,22.32) v2(248.81,21.05) v2(248.81,19.81) v2(250.45,2.55) v2(250.57,1.53) v2(251.07,120.38) v2(251.07,118.52) v2(251.07,115.72) v2(251.07,113.18) v2(251.07,110.64) v2(251.07,108.1) v2(251.07,105.56) v2(251.07,103.02) v2(251.07,100.48) v2(251.25,97.95) v2(252.3,27.54) v2(252.32,26.9) v2(252.32,26.26) v2(252.57,95.78) v2(252.57,93.24) v2(252.57,90.7) v2(252.57,88.16) v2(252.57,85.62) v2(252.57,83.08) v2(252.57,80.54) v2(252.57,78) v2(252.57,75.46) v2(252.57,72.92) v2(252.57,70.38) v2(252.57,67.84) v2(252.57,65.3) v2(252.68,62.76) v2(252.99,60.24) v2(254.73,16.29) v2(254.82,1.73) v2(255.14,52.95) v2(256.08,36.51) v2(256.49,36.03) v2(256.72,12.2) v2(257.05,35.77) v2(257.26,18.11) v2(257.94,36.2) v2(258.04,42.33) v2(257.95,12.21) v2(258.17,15.16) v2(258.28,21.31) v2(258.45,18.68) v2(258.97,46.38) v2(259.46,35.82) v2(260.15,33.69) v2(260.17,34.88) v2(260.17,34.27) v2(260.81,34.88) v2(260.81,34.3) v2(261.39,36.36) v2(262.03,16.64) v2(262.44,1.73) v2(262.67,16.65) v2(263.58,15.06) v2(264.27,40.93) v2(264.5,15.28) v2(264.69,22.86) v2(265.78,15.32) v2(270.06,1.73) v2(270.73,36.91) v2(273.62,28.86) v2(274.26,28.84) v2(274.26,28.2) v2(274.26,27.57) v2(274.89,28.03) v2(274.89,27.44) v2(275.53,28.03) v2(275.53,27.44) v2(276.16,28.03) v2(276.16,27.44) v2(277.68,1.73) v2(277.96,34.55) v2(281.43,32.46) v2(281.43,31.86) v2(285.3,1.73) v2(285.54,33.97) v2(287.21,26.74) v2(287.66,27.12) v2(287.82,30.08) v2(287.82,29.19) v2(288.29,29.6) v2(288.71,30.08) v2(288.71,29.19) v2(292.92,1.73) v2(293.16,33.97) v2(293.66,5.77) v2(297.24,17.15) v2(297.24,15.38) v2(297.24,13.6) v2(299.02,17.15) v2(299.02,15.38) v2(299.02,13.6) v2(300.54,1.73) v2(300.73,34.69) v2(300.8,17.15) v2(300.8,15.38) v2(300.8,13.6) v2(307.9,37.21) v2(307.9,4.66) v2(308.16,1.73) v2(313.4,25.45) v2(314.27,41.37) v2(314.4,22.75) v2(314.61,24.85) v2(315.78,1.73) v2(318.45,35.78) v2(318.77,33.41) v2(318.77,31.38) v2(319.44,46.94) v2(319.66,32.39) v2(319.91,38.24) v2(320.61,31.38) v2(320.68,33.41) v2(321.04,46.95) v2(321.31,38.36) v2(322.52,20.33) v2(323.13,53.59) v2(323.15,20.33) v2(323.4,1.73) v2(323.79,20.33) v2(324.42,20.33) v2(325.06,20.33) v2(325.39,117.53) v2(325.39,109.91) v2(325.39,102.29) v2(325.39,94.67) v2(325.39,87.05) v2(325.39,79.43) v2(325.39,74.3) v2(325.38,9.69) v2(325.38,9.03) v2(325.38,8.42) v2(325.52,66.68) v2(325.69,20.33) v2(325.82,33.47) v2(326.01,9.69) v2(326.01,9.03) v2(326.01,8.42) v2(326.14,32.08) v2(326.78,59.57) v2(327.45,71.62) v2(327.63,79.9) v2(327.75,29.78) v2(328.17,80.78) v2(328.85,71.01) v2(328.87,68.04) v2(328.87,67.46) v2(328.87,66.87) v2(328.98,58.52) v2(329.55,29.83) v2(329.76,63.25) v2(331.02,1.73) v2(331.34,77.36) v2(331.34,75.61) v2(331.5,120.67) v2(331.6,65.6) v2(332.8,80.41) v2(332.8,78.66) v2(334.02,81.58) v2(333.96,64.33) v2(334.2,17.47) v2(334.2,16.84) v2(334.37,117.56) v2(334.72,115.96) v2(335.03,17.41) v2(335.34,114.82) v2(335.41,16.84) v2(335.66,17.41) v2(336.3,17.41) v2(336.61,16.86) v2(336.87,101.67) v2(336.93,17.41) v2(337.57,17.41) v2(337.67,16.83) v2(337.92,114.05) v2(337.92,15.69) v2(338.01,16.29) v2(338.2,17.41) v2(338.25,16.82) v2(338.44,0.43) v2(338.46,15.44) v2(338.84,17.47) v2(338.84,16.86) v2(338.87,77.33) v2(338.87,69.71) v2(339.12,120.67) v2(339.07,15.44) v2(339.24,86.98) v2(339.15,37.92) v2(339.15,36.2) v2(339.47,17.47) v2(339.47,16.84) v2(339.66,15.44) v2(339.92,114.65) v2(339.85,16.26) v2(340.04,36.97) v2(340.11,17.47) v2(340.11,16.84) v2(340.17,15.74) v2(340.25,86.86) v2(340.55,16.23) v2(340.74,17.47) v2(340.74,16.84) v2(340.87,37.92) v2(340.87,36.2) v2(341.1,116.1) v2(342.9,44.52) v2(343.29,65.47) v2(343.78,20.3) v2(343.89,80.43) v2(344.4,20.93) v2(344.4,20.3) v2(344.4,19.68) v2(344.94,64.19) v2(345.02,20.3) v2(346.06,0.43) v2(346.51,122.37) v2(346.79,4.61) v2(346.84,1.41) v2(347.41,39.33) v2(348.03,5.04) v2(348.11,1.15) v2(349.28,4.61) v2(349.43,1.43) v2(349.51,88.13) v2(350.23,107.9) v2(350.4,97.3) v2(350.67,117.87) v2(350.65,89.94) v2(350.67,82.32) v2(350.67,64.38) v2(350.67,27.31) v2(350.67,19.69) v2(350.67,12.07) v2(350.67,4.7) v2(352.2,102.7) v2(352.23,91.93) v2(352.27,57.22) v2(352.27,49.6) v2(352.27,41.98) v2(352.27,34.36) v3(31.37,15.95) v3(48.83,1.72) v3(78.49,32.19) v3(85.44,34.02) v3(100.9,41.79) v3(117.29,56.9) v3(118.26,57.48) v3(119.2,3.15) v3(122.18,4.9) v3(129.44,8.78) v3(129.59,10.74) v3(131.87,8.94) v3(132.79,10.75) v3(144.02,108.43) v3(156.03,112.91) v3(171.84,45.53) v3(171.9,50.02) v3(230.38,117.99) v3(243.8,12.39) v3(244.35,52.52) v3(248.79,107.32) v3(264.16,38.93) v3(277.05,27.5) v4(22.84,40.99) v4(25.41,44.9) v4(25.4,36.46) v4(26.06,44.85) v4(26.7,36.48) v4(27.35,36.48) v4(28.01,44.85) v4(28.64,36.44) v4(28.65,44.88) v4(29.96,36.47) v4(31.24,43.6) v4(31.24,39.05) v4(31.21,37.09)
