# Allegro board Dell XPS 9560 LA-E331P R10.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3V_PCH_AZIO: length 25.8
  TOP w0.14: v2(114.44,10.62) 114.94,11.12 v1(114.94,11.12)
  TOP w0.508: v2(92.06,6.82) 92.5,6.82 CH200.1 ; v2(114.44,10.62) 113.92,10.1 LH1.2
  IN5 w0.508: v2(114.44,10.62) 114.36,10.62 114.36,10.55 114.23,10.42 108.02,10.42 107.31,11.12 106.11,11.12 105.59,10.6 102.21,10.6 101.99,10.38 97.59,10.38 97.24,10.73 95.73,10.73 94.68,9.68 94.68,8.33
  BOTTOM w0.203: v2(92.06,6.82) 92.06,6.78 92.14,6.7 92.18,6.7 92.62,6.26 UH2.BA15
+3V_PCH_DSW: length 249.9
  TOP w0.508: v2(111.41,3.76) 111.41,3.86 110.9,4.37 110.18,4.37 110.14,4.33 RH453.2 ; v2(87.49,5.17) 87.49,4.58 86.98,4.07 84.96,4.07 RH137.2 ; v2(92.48,16.14) 92.76,16.43 CH82.1
  IN2 w0.508: v2(115.32,14.04) 114.68,14.04 113.98,13.34 109.26,13.34 109.16,13.45 104.17,13.45 102.79,12.06 98.67,12.06 98.58,12.16 97.41,12.16 96.9,12.67 96.66,12.67 96.14,13.18 96.14,13.96 95.77,14.33 93.81,14.33 92.48,15.67 v2(92.48,16.14)
  IN3 w0.508: v2(134.74,95.44) 144.25,95.44 144.81,96 172.89,96 173.74,95.14 173.74,94.24 174.67,93.31 175.46,93.31 176.99,91.78 178.78,91.78 179.41,91.14 179.41,87.37 180.44,86.34 180.44,85.02 182.06,83.4 182.84,83.4 183.83,82.42 183.83,74.68 182.8,73.66 182.8,70.49 183.2,70.1 183.2,65.06 190.76,57.5 190.76,55.44 v2(191.29,54.9)
  BOTTOM w0.127: UH2.BA24 87.75,5.89 87.75,5.43 v2(87.49,5.17)
  BOTTOM w0.203: UH2.W15 92.33,16.3 v2(92.48,16.14)
  BOTTOM w0.508: RH2.1 133.86,94.56 v2(134.74,95.44) ; v2(191.29,54.9) 191.83,54.36 191.83,51.84 178.03,38.03 178.03,26.59 176.79,25.35 176.79,24.46 177.64,23.6 177.64,18.03 175.33,15.72 172.45,15.72 172.1,16.06 149.61,16.06 149.38,16.29 145.97,16.29 145.74,16.06 116.89,16.06 115.32,14.49 v2(115.32,14.04) 115.32,12.07 115.95,11.44 115.95,7.76 115.3,7.11 114.53,7.11 113.87,6.45 RH545.2 113.87,3.83 112.4,2.36 v2(110.68,2.36)
+3V_PCH_SPI: length 0.6
  TOP w0.089: v2(78.74,2.74) 78.74,2.69 78.42,2.37 v1(78.33,2.37)
  vias: v2(78.74,3.37)
+3V_PS8723: length 9
  TOP w0.127: v2(315.63,28.93) v3(316.14,28.43)
  BOTTOM w0.254: CI4.1 315.93,29.8 317.27,31.14 UI3.1
  BOTTOM w0.508: v2(324.87,33.35) RI24.2 RI16.2 ; v2(324.99,32.08) 324.99,31.95 324.61,31.57 RI19.2 RI15.2 RI20.2 ; v2(315.63,28.93) 315.93,29.22 CI4.1 ; RI22.2 v2(314.91,36.66)
  vias: v2(314.31,31.7) v2(322.38,35.05) v2(322.71,35.53)
+3V_ROM: length 223.7
  TOP w0.381: RH78.1 73.2,1.74 v2(73.47,1.47) 74.94,1.47 75.03,1.56 75.39,1.56
  TOP w0.508: v2(183.64,16.86) 183.64,16.52 184.53,15.63 201.53,15.63 203.15,14 v2(203.15,9.19) ; RH585.1 60.23,7.31 59.65,7.89 v2(59.65,7.93) ; 75.39,1.56 79.78,1.56 v1(79.88,1.66) 79.88,2.42 RH75.1
  IN2 w0.508: v2(118.68,16.71) 118.68,16.4 118.24,15.97 105.51,15.97 105.14,15.6 102.08,15.6 101.76,15.92 99.23,15.92 98.44,16.71 94.11,16.71 92.59,18.23 92.59,18.7 92.65,18.76 92.65,19.82 91.31,21.15 88.44,21.15 85.97,18.68 84.01,18.68 83.19,17.85 81.22,17.85 79.95,19.12 79,19.12 77.66,20.46 76.59,20.46 v2(76.58,20.45)
  IN4 w0.508: v2(183.64,16.86) 183.64,17.67 183.26,18.04 178.04,18.04 177.43,18.66 154.63,18.66 154.04,18.06 132.7,18.06 132.23,18.53 119.55,18.53 118.68,17.66 v2(118.68,16.71)
  IN5 w0.508: v2(76.58,20.45) 76.51,20.45 75.59,19.53 72.37,19.53 71.68,20.21 67.48,20.21 67.13,20.56 65.15,20.56 64.71,21 64.71,21.54 64.61,21.64 64.61,21.64 64.25,22 64.24,22 64.2,22.04 61.09,22.04 60.78,22.35 58.54,22.35 57.43,21.24 57.43,19.85 57.16,19.58 57.16,15.64 56.51,14.99 54.99,14.99 54.45,14.45 54.45,10.32 54.23,10.11 54.23,9.53 55.03,8.73 55.03,7.34 55.63,6.73 55.63,5.32 56.15,4.8 v2(57.95,4.8) 58.48,4.26 59.31,4.26 61.1,2.47 64.34,2.47 64.47,2.6
  IN6 w0.508: v2(59.65,7.93) 59.73,7.85 59.73,7.22 59.37,6.87 58.87,6.87 58.72,7.01 57.39,7.01 56.9,6.52 56.9,5.36 57.47,4.8 v2(57.95,4.8)
  BOTTOM w0.305: JSPI1.6 206.79,12.64 206.73,12.58 206.73,12.52 206.67,12.52 206.29,12.89 JSPI1.5
  BOTTOM w0.508: v2(59.65,7.93) 59.65,8.67 60.14,9.15 UH8.8 62.16,9.15 64.07,11.06 RH74.1 ; v2(203.15,9.19) 203.15,9.99 204.41,11.25 206.43,11.25 206.73,11.55 206.73,12.52
+3V_TBT: length 27.4
  TOP w0.305: RT202.1 v3(24.02,50.5) 23.98,50.45 v2(22.15,50.45)
  IN5 w0.508: 20.3,45.45 20.3,46.21 20.62,46.54 20.62,48.92 v2(22.15,50.45)
  IN6 w0.508: 24.34,42.22 21.09,42.22 v2(21.08,42.23) ; 31.27,47.63 29.85,47.63 29.35,47.14 27.75,47.14 27.49,47.39 24.02,47.39 23.69,47.06 23.69,46.86 22.3,45.47
  BOTTOM w0.254: RT34.1 RT33.1 ; UT1.H9 v2(24.76,41.64)
  BOTTOM w0.356: v2(34.84,46.01) 34.76,45.93 34.76,45.85 34.67,45.76 34.67,44.36 RT434.1 ; v2(32.44,48.68) 32.67,48.68 33.02,48.32 RT34.1
  BOTTOM w0.381: CT53.1 20.59,42.23 v2(21.08,42.23)
  vias: v2(21.06,45.38) v2(21.52,45)
+3V_TBT_PWR: length 2.2
  BOTTOM w0.102: CT162.1 13.89,33.63 v3(13.58,33.31)
+3V_TBT_S0: length 29.5
  TOP w0.254: v2(28.66,39.69) 28.66,39.97 CT163.1
  TOP w0.508: CT165.1 31.79,34.31 CT164.1 30.47,34.87 v2(30.04,34.44)
  IN5 w0.381: v2(27.57,34.77) 28.22,35.42 29.06,35.42 v2(30.04,34.44) 31.75,36.15 31.75,38.01 31.36,38.4 30.45,38.4 29.17,39.69 v2(28.66,39.69)
  IN6 w0.381: v2(27.57,34.77) 26.86,35.48 23.02,35.48 21.56,36.95 21.56,39.41 21.02,39.95 19.75,39.95 v2(19.29,40.42)
  BOTTOM w0.14: LT14.1 17.15,40.76 v1(17.1,40.81)
  BOTTOM w0.254: v2(28.66,39.69) 28.66,39.69 UT1.R13
  BOTTOM w0.381: LT14.1 18.63,40.42 v2(19.29,40.42)
+3V_TBT_SPI: length 90.4
  TOP w0.381: v2(30.61,37.07) 30.61,36.99 31,36.6 31.68,36.6 RT242.2
  TOP w0.508: RT243.2 v2(19.56,70.3)
  IN2 w0.508: v2(18.57,30.71) 19.22,31.35 19.81,31.35 21.63,29.54 25.27,29.54 26.43,30.69 26.43,31.89 27.93,33.38 33.46,33.38 33.78,33.06 33.78,32.39 33.34,31.95 32.23,31.95 v2(32.13,32.05)
  IN4 w0.508: v2(43.12,30.29) 43.12,32.85 41.86,34.11 34.4,34.11 ; v2(32.13,32.05) 32.13,32.05 32.18,32.01 33.18,32.01 34.4,33.22 34.4,34.11 ; v2(30.61,37.07) 30.61,35.23 31.73,34.11 34.4,34.11
  IN5 w0.508: v2(19.56,70.3) 19.55,70.3 18.94,69.7 18.94,68.16 18.33,67.55 18.33,60.71 17.99,60.38 17.99,32.37 18.57,31.79 v2(18.57,30.71)
  BOTTOM w0.254: RT16.1 30.35,30.56 30.04,30.87 30.04,31.7 30.3,31.96 RT17.1 30.79,31.96 31.29,31.45 RT18.1 31.46,31.45 32.05,32.04 32.13,32.04 32.13,32.05 v2(32.13,32.05)
  vias: v3(42.98,26.73)
+3V_VC: length 476.1
  TOP w0.14: v1(13.22,4.77) 13.13,4.68 v2(13.13,4.01)
  TOP w0.381: PC225.1 13.01,3.36 12.4,2.75 PU204.5
  TOP w0.457: PR252.2 10.52,22.72 v2(10.99,23.19)
  TOP w0.508: v2(34.04,30.59) 34.04,30.93 34.28,31.17 PR275.1 PC223.1 ; v2(277.42,4.07) 277.43,4.09 RZ1135.1 ; v2(13.13,4.01) 13.13,3.5 PC225.1 ; v2(306.45,24.9) 306.64,25.09 RZ1137.1 ; PQ221.3 35.36,27.47 34.86,27.96 33.84,27.96 v2(33.83,27.97) ; v2(10.99,23.19) 11.18,23.38 11.18,24.08 11.76,24.66 PR281.2 13.36,24.66 PQ224.3 ; RZ1139.1 165.37,4.58 v2(164.28,3.49) ; CT161.1 20.97,55.32 20.35,55.32 v2(20.17,55.5) ; v2(138.67,5.93) 138.67,8.01 138.23,8.46 138.23,11.25 134.92,14.56 123.92,14.56 121.87,16.61 v2(121.87,16.72) ; v2(19.86,10.8) 19.86,11.63 PQ233.2 18.62,11.89 PR278.1 ; PR252.2 10.12,22.98 10.12,23.13 9.46,23.79 PR257.2
  IN1 w0.508: v2(306.45,24.9) 306.66,24.9 308.12,26.36 308.12,27.44 308.81,28.14 v2(309.74,28.14)
  IN2 w0.508: v2(121.87,16.72) 121.87,16.59 120.88,15.6 120.14,15.6 119.9,15.36 106.37,15.36 105.75,14.74 99.19,14.74 98.41,15.53 97.7,15.53 v2(97.12,16.11)
  IN3 w0.508: v2(16.27,23.71) 16.07,23.92 16.07,25.41 16.89,26.23 16.89,28.77 17.96,29.85 17.96,31.52 18.14,31.7 18.14,32.2 15.63,34.71 15.63,42.32 16.39,43.08 16.85,43.08 17.19,43.42 17.19,44.64 18.09,45.54 18.09,53.93 19.66,55.5 v2(20.17,55.5) ; v2(97.12,16.11) 97.12,16.33 96.58,16.86 93.03,16.86 91.38,18.51 91.38,20.35 v2(89.71,22.02) ; v2(10.99,23.19) 13.86,23.19 14.37,22.68 14.37,21.74 15.29,20.82 17.07,20.82 18.43,22.18 19.76,22.18 20.01,22.43 23.29,22.43 24.61,23.76 28.38,23.76 29.21,24.59 34.62,24.59 35.18,25.15 35.18,27.52 34.75,27.95 33.85,27.95 v2(33.83,27.97) ; v2(314.86,5.48) 317.51,8.14 317.51,10.83 315.34,12.99 315.34,22.44 315.58,22.67 315.58,25.37 312.81,28.14 v2(309.74,28.14)
  IN5 w0.508: v2(138.67,5.93) 138.67,3.54 140.61,1.6 149.7,1.6 150.86,2.76 163.63,2.76 164.28,3.41 v2(164.28,3.49) 165.24,2.52 180.42,2.52 180.8,2.91 201.83,2.91 205.8,6.88 206.31,6.88 206.95,7.52 209.84,7.52 210.93,6.43 219.48,6.43 219.69,6.64 225.59,6.64 226.93,5.3 267.47,5.3 269.38,3.39 276.52,3.39 277.2,4.07 v2(277.42,4.07) 278.35,4.07 279.18,3.24 292.82,3.24 293.24,2.82 297.16,2.82 297.18,2.79 297.69,2.79 297.71,2.82 309.34,2.82 312.7,6.18 314.16,6.18 v2(314.86,5.48) ; v2(62.47,20.49) 63.04,19.92 64.62,19.92 64.79,19.75 66.79,19.75 67.14,19.4 71.12,19.4 72.42,18.11 77.98,18.11 78.25,17.84 79.95,17.84 80.07,17.95 83.62,17.95 84.5,18.84 86.22,18.84 89.4,22.02 v2(89.71,22.02) ; v2(33.83,27.97) 33.74,27.97 33.53,28.17 33.53,29.3 34.04,29.8 v2(34.04,30.59) ; v2(10.99,23.19) 11.24,23.19 11.72,22.7 11.72,21.26 13.7,19.28 13.7,18.52 19.86,12.36 v2(19.86,10.8) 19.86,7.4 17.24,4.77 13.59,4.77 13.13,4.31 v2(13.13,4.01)
  IN6 w0.508: v2(33.83,27.97) 34.91,27.97 35.39,27.48 38.06,27.48 38.41,27.83 38.41,27.84 38.68,28.11 45.26,28.11 46.93,26.44 47.53,26.44 48.44,25.53 55.18,25.53 57.39,23.31 61.01,23.31 62.79,21.53 62.79,20.81 v2(62.47,20.49)
  BOTTOM w0.14: v2(20.17,55.5) 20.06,55.5 19.36,54.8 RT1094.1
  BOTTOM w0.508: PR255.2 PR254.2 v2(16.27,23.71) 15.46,24.52 12.42,24.52 12.07,24.16 12.07,23 11.69,22.61
+3VA_TBT: length 143
  TOP w0.381: RT25.1 24.58,48.5 v2(24.69,48.61) ; CT143.1 24.19,42.4 24.19,42.86 v2(24.11,42.94)
  TOP w0.508: RT194.1 28.4,57.48 QV89.2 28.59,56.69 28.77,56.51 28.77,55.6 29.43,54.93 29.43,52.58 31.8,50.21 v2(31.8,48.72)
  IN2 w0.508: v2(24.69,48.61) 24.5,48.8 24.5,49.31 24.86,49.67 25.08,49.67 25.66,50.24 25.66,51.13 27.31,52.78 27.31,63.83 ; 24.7,68.21 24.7,68.74 26.07,70.11 26.07,73.63 25.08,74.62 25.08,75.28 22.8,77.57 22.8,82.24 25.58,85.02 25.58,89 27.12,90.54 27.12,95.06 v2(25.97,96.21) 25.53,96.66 25.53,99.72 v2(26.7,100.88) ; 24.7,68.21 v2(21.78,68.21) ; 24.7,68.21 25.88,67.03
  IN4 w0.254: v2(24.11,42.94) 24.56,42.49 25.6,42.49 27.15,44.04 27.15,45.38 25.15,47.38 25.15,47.78
  IN6 w0.508: v2(19.37,34.87) 18.54,34.87 17.97,35.44 17.97,48.02 19.18,49.22 21.02,49.22 21.64,48.6 22.58,48.6
  BOTTOM w0.203: UT1.F8 v2(24.11,42.94)
  BOTTOM w0.254: RT436.1 24.54,95.6 25.12,96.19 CT173.1
  BOTTOM w0.356: v2(30.35,48.57) 30.1,48.32 RT35.1 RT36.1 ; RT167.1 18,57.1 16.45,57.1 16.38,57.16 16.38,58.35 17.34,59.3 17.34,60.52 17.95,61.13 17.95,62.16 16.99,63.12 16.99,65.52 17.46,66 18.94,66 20.39,67.46 21.03,67.46 v2(21.78,68.21)
  BOTTOM w0.381: v2(31.8,48.72) 31.8,48.31 RT22.1 ; QT20.5 25.02,99.58 25.12,99.68 CT172.1 25.12,100.63 25.38,100.88 RT435.1 v2(26.7,100.88) 27.27,100.31 CT170.1 27.27,99.41 27.1,99.24 QT11.2 ; QT20.2 25.02,96.44 CT173.1 25.95,96.19 v2(25.97,96.21) 26.26,95.92 RT433.1
  BOTTOM w0.508: RT46.1 16.19,56.97 16.38,57.16 ; RT114.2 18.63,34.87 v2(19.37,34.87) 20,34.87 20.13,34.74 RT113.1
+3VA_TBT_LC: length 43.3
  TOP w0.356: v2(35.23,45.49) 35.18,45.44 RT7.1 RT8.1 RT9.1 RT6.1 CT50.1
  TOP w0.381: v2(33.17,35.65) 33.17,36.39 RT242.1
  IN2 w0.508: v2(43.02,37.42) 43.02,36.58 42.51,36.08 39.69,36.08 35.96,39.81 35.96,42.81 34.8,43.96 34.8,45.06 v2(35.23,45.49) ; v2(28.66,42.94) 31.38,42.94 31.8,42.52 31.8,41.47 33.17,40.1 v2(33.17,35.65)
  IN4 w0.508: v2(43.02,37.42) 43.02,36.14 42.51,35.64 33.18,35.64 v2(33.17,35.65)
  BOTTOM w0.203: UT1.R6 v2(28.66,42.94)
+3VALW: length 576
  TOP w0.254: UE6.2 192.11,4.59 v2(191.82,4.31) 191.61,4.53 UE6.1
  TOP w0.381: v2(126.27,68.34) 126.27,68.44 126.69,68.86 UZ18.5 ; UZ23.5 108.02,53.36 108.62,52.76 v2(108.88,52.76) ; UZ22.5 121.08,63.87 v2(121.29,64.08) ; CI22.1 324.78,53.48 324.06,52.76 UI5.5 324.06,51.54 v2(323.97,51.45)
  TOP w0.457: UI4.5 26.16,85.4 CI21.1 26.57,86.67 v2(26.8,86.9)
  TOP w0.508: RV103.1 220.27,118.47 v2(220.51,118.23) ; v2(320.23,43) RI30.1 321.31,43.27 RI31.1 ; v2(247.4,113.42) 246.83,113.99 245.78,113.99 245.68,113.89 245.39,113.89 v2(244.86,113.36) 244.86,111.01 244.41,110.56 PR909.1 ; RH513.2 RH508.2 74.95,14.5 74.47,14.98 v2(74.47,15.09) ; RI5.1 28.32,85.77 v2(28.14,85.59) ; v2(34.55,26.12) 34.55,25.7 35.37,24.88 PQ221.1 ; PR112.2 25.37,12.45 25.37,10.27 25.93,9.7 26.24,9.7 27.93,8.01 27.93,6.5 v2(28.7,5.72) ; v2(27.94,92.85) 28.26,92.53 RI4.1 ; v2(134.88,5.11) 136.46,5.11 137.08,4.49 138.75,4.49 139.37,5.11 139.37,8.17 v3(138.84,8.71) 138.84,11.51 135.17,15.17 129.62,15.17 129.03,15.76 v2(129.03,20.33) ; UE2.2 349.35,118.83 348.95,118.43 RE15.1 348.95,117.53 349.51,116.98 CE15.1 349.14,116.73 348.87,116.47 v2(348.74,116.47) ; RA100.1 7.68,32.36 6.61,31.3 v2(6.39,31.3) ; v2(168.17,6.68) 168.17,6.22 167.06,5.1 RZ1138.1 ; RH137.1 83.44,4.81 83.86,5.23 v2(83.86,5.8) ; v2(309.5,12.68) 310.01,12.68 RE56.1 ; PR1800.2 177.37,13.63 177.37,8.58 v2(177.62,8.33) ; PR510.1 132.46,1.8 v2(132.68,1.58) ; v2(252.67,50.35) 252.6,50.42 RV12.1 ; v2(121.97,55.43) 112.27,55.43 v3(112.18,55.52) 111.63,55.52 v2(108.88,52.76) ; RV111.1 v2(253.05,44.59) ; RV1809.1 161.02,119.36 v2(160.83,119.55)
  IN1 w0.508: v2(74.47,15.09) 74.3,14.92 73.53,14.92 73.02,15.43 71.51,15.43 71.05,14.97 68.77,14.97 67.57,13.77 v2(67.57,13.47) ; v2(105.73,62.94) 105.73,63.92 107.08,65.27 107.79,65.27 108.14,65.63 v2(108.14,66.05)
  IN1 w1.016: 310.15,24.11 310.34,24.11 313.2,26.97 315.79,26.97 316.57,27.76 316.57,30.37
  IN2 w0.508: v2(320.23,43) 323.97,46.74 v2(323.97,51.45) ; v2(105.73,62.94) 104.42,61.63 104.42,55.15 105.68,53.89 107.75,53.89 v2(108.88,52.76) ; v2(27.34,46.64) 26.7,47.29 24.86,47.29 23.16,48.99 23.16,53.06 22.13,54.1 v2(19.91,54.1) ; v2(121.97,55.43) 120.14,55.43 119.64,55.94 119.64,57.67 121.29,59.32 v2(121.29,64.08) ; v2(83.86,5.8) 83.86,5.36 83.05,4.55 78.01,4.55 77.73,4.28 75.82,4.28 74.48,5.62 69.88,5.62 68.99,6.51 64.14,6.51 63.92,6.73 59.52,6.73 59.43,6.65 58.66,6.65 v2(58.39,6.37)
  IN3 w0.508: v2(27.4,26.69) 27.4,27.18 25.23,29.35 21.88,29.35 20.97,30.26 20.97,31.33 19.79,32.51 19.79,32.95 v2(19.31,33.43) 20.26,34.39 20.26,38.38 18.23,40.42 18.23,44.27 20.7,46.74 20.7,47.03 21.36,47.7 22.72,47.7 22.97,47.44 25.53,47.44 26.33,46.64 v2(27.34,46.64) ; v2(129.03,20.33) 129.03,23.19 124.52,27.69 124.52,44.98 128.53,48.99 v2(128.57,48.99)
  IN4 w0.508: v2(34.55,26.12) 35.35,26.12 36.35,27.12 39.08,27.12 41.26,29.31 v2(41.26,30.29) ; v2(220.51,118.23) 220.59,118.23 221.64,119.28 223.02,119.28 225.4,116.9 225.4,115.06 228.15,112.31 230.43,112.31 230.92,111.83 236.69,111.83 237.39,112.53 237.39,114.88 237.75,115.24 240.73,115.24 242.61,113.36 v2(244.86,113.36)
  IN4 w1.016: 251.65,50.81 251.33,51.13 249.05,51.13 247.02,53.16 235.84,53.16 233.56,55.44 233.56,91.5 235.79,93.73 242.55,93.73 245.11,96.29 245.11,97.34 249.47,101.7 249.47,110.21 248.1,111.58 ; 253.62,15.31 253.62,17.92 254.03,18.32 254.03,28.81 252.18,30.65 252.18,43.67 ; 252.35,48.9 252.35,48.46 252.18,48.29 252.18,44.87
  IN5 w0.508: v2(27.94,92.85) 26.67,91.58 26.67,87.03 v2(26.8,86.9) 26.99,86.9 28.14,85.75 v2(28.14,85.59) 28.14,84.97 26.35,83.18 26.35,80.74 23.81,78.2 23.81,70.41 27.68,66.53 27.68,56.82 28.28,56.22 28.28,50.77 28.04,50.53 28.04,47.34 v2(27.34,46.64) ; v2(167.93,119.48) 167.93,118.86 168.31,118.47 170.19,118.47 171.5,119.78 174.79,119.78 175.45,120.44 218.3,120.44 219.91,118.83 219.91,118.78 220.46,118.23 v2(220.51,118.23)
  IN6 w0.508: v2(167.93,119.48) 165.71,119.48 164.39,119.48 163.63,120.24 161.52,120.24 v2(160.83,119.55)
  BOTTOM w0.305: JAPS.3 v2(177.62,8.33) ; JAPS.7 175.62,7.86 v2(176.09,8.33)
  BOTTOM w0.508: v2(121.29,64.08) 121.13,64.24 121.13,64.78 122.36,66.02 124.65,66.02 125.29,66.65 125.29,67.76 125.86,68.34 v2(126.27,68.34) ; v2(121.97,55.43) 128.42,48.99 v2(128.57,48.99) ; v2(108.14,66.05) 108.14,65.49 PR811.1 ; RI9.1 RI10.1 v2(328.42,53.74) ; v2(19.91,54.1) 18.52,54.1 18.29,54.33 RT1095.1 ; v2(151.83,3.76) 151.83,4.01 152.15,4.33 RE141.1 ; v2(27.4,26.69) 27.61,26.48 33.76,26.48 34.13,26.12 v2(34.55,26.12)
  vias: v2(10.54,4.77) v2(11.2,5.53) v2(11.22,4.77) v2(42.49,30.29) v2(58.46,5.76) v2(68.17,13.26) v2(242.44,2.21) v2(242.6,2.77) v2(243.04,2.23) v2(243.33,2.77) v2(243.62,2.27) v2(247.46,112.72) v2(253.3,14.3) v2(253.89,14.3) v2(275.62,4.06) v2(276.26,4.07) v2(309.4,25.15) v2(309.4,24.57) v2(316.61,35.99) v2(316.61,35.38) v2(316.68,36.58) v2(321.44,27.03) v2(322.05,27.68) v2(322.05,27.05) v2(322.54,28.11) v2(322.56,28.74) v2(322.63,27.48) v2(322.73,26.89) v2(323.19,29.09) v2(323.2,28.49) v2(323.19,27.9) v2(323.79,28.72) v2(323.79,28.1) v2(338.79,100.86) v2(338.79,100.22) v2(344.43,45.89) v2(344.79,45.43) v3(322.53,29.55)
+3VALW_5085: length 68.1
  TOP w0.254: RP20.5 310.21,27.2 v2(310.44,26.97) 310.71,27.24 RP20.6 ; RP20.8 311.71,27.24 v2(311.47,27) 311.21,27.25 RP20.7
  TOP w0.305: CE18.1 306.36,14.13 UE3.A22 ; UE3.B35 303.02,20.15 304.59,21.71 304.59,22.27 ; UE3.A41 298.77,21.29 298.81,21.32 298.81,23.02 CE27.1 ; CE20.1 291.53,14.63 UE3.A58 ; 300.27,9.06 UE3.A11 ; CE28.1 291.22,17.73 293.07,17.73 293.17,17.63 UE3.A52 ; UE3.A26 304.79,16.13 304.97,15.95 306.19,15.95 CE25.1 ; v2(296.25,11.46) 296.02,11.24 UE3.B3
  TOP w0.508: v2(294.4,25) 294.4,24.89 294.9,24.4 RE22.2 ; CE26.1 293.93,7.69 v2(294.48,8.24) ; RE65.1 RE63.1 309.53,27.28 v2(309.53,27.12) ; RE19.2 301.78,4.4 v2(301.93,4.55) ; RE59.1 298.02,26.91 v2(298.5,27.39) 298.96,26.93 298.96,26.91 299.09,26.78 RE99.2 ; v2(306.77,16.75) 306.38,16.35 CE25.1 ; v2(306.38,12.58) CE19.1 CE18.1 ; RE20.2 RE25.2 294.82,6.22 294.64,6.04 v2(294.64,5.79) RE21.2 ; CE28.1 291.16,17.79 v2(291.67,18.3) ; v2(307.57,18.37) 307.57,18.75 RE66.1 ; RE41.1 v2(308.92,10.98) ; RE60.1 312.99,26.87 v3(312.24,26.12) 312.06,25.94 v2(310.46,25.94) ; 300.27,9.06 300.27,8.23 300.56,7.95 RE67.1 301.42,7.37 CE24.1 301.61,7.57 v2(301.61,8.17) ; v2(289.64,14.94) CE21.1 CE20.1 ; RE142.2 310.66,10.03 311.09,10.46 311.09,11.49 310.63,11.95 v2(310,11.95) ; RE18.1 RE17.1 289.98,16.77 289.64,17.12 v2(289.56,17.12) ; RE95.2 297.42,32.69 298.17,32.69 v2(298.26,32.59) 298.64,32.21 RE94.2 ; RE64.1 v2(307.02,27.07) ; v2(299.4,22.41) 299.4,22.64 299.09,22.96 CE27.1 ; v2(289.39,19.1) 289.32,19.17 289.32,19.77 289.66,20.11 RE23.2
  IN1 w0.508: v2(298.26,32.59) 298.45,32.4 298.45,27.44 v2(298.5,27.39)
  IN2 w0.508: v2(298.5,27.39) 298.17,27.39 296.85,26.07 296.47,26.07 295.4,25 v2(294.4,25)
  IN3 w0.508: v2(301.61,8.17) 301.94,7.84 301.94,6.65 301.93,6.63 v2(301.93,4.55)
  vias: v2(286.89,6.45) v2(287.48,6.45) v2(305.25,23.31) v2(305.25,22.61)
+3VALW_23017: length 21.3
  TOP w0.127: 277.69,8.07 278.7,7.06 v3(278.89,7.06)
  TOP w0.457: UE4.5 278.53,9.32 CE55.1
  TOP w0.508: RE73.1 v2(283.54,13.08) ; v2(271.4,13.15) 271.4,14.24 272.21,15.06 RE72.1 RE71.1 ; v2(283.67,17.64) 283.54,17.51 RE76.1
  IN2 w0.508: v2(283.54,13.08) 282.62,12.16 281.29,12.16 280.67,12.77 271.78,12.77 v2(271.4,13.15)
  vias: v2(277.85,9.22) v2(277.85,8.58)
+3VALWP: length 42.2
  TOP w0.254: PR401.1 v2(348.87,23.57)
  IN6 w0.254: v2(325.95,24.33) 326.01,24.39 326.01,24.46 332.61,31.06 337.88,31.06 339.28,32.46 345.38,32.46 347.73,30.11 347.73,25.92 348.74,24.9 348.74,23.69 v2(348.87,23.57)
  BOTTOM w0.254: PR428.1 345.5,24.41 347.08,25.98 349.25,25.98 349.57,25.66 349.57,24.27 v2(348.87,23.57) 348.88,23.55 PC401.1
  vias: v3(327.89,26.77)
+3VLP: length 175.3
  TOP w0.127: v2(313.27,31.07) 313.27,30.54 v3(313.49,30.32)
  TOP w0.508: v2(345.06,87.02) 345.06,88.34 RH590.2 ; RE43.2 287.26,16.72 v2(286.68,17.31)
  IN1 w0.508: v2(345.06,87.02) 345.67,86.41 345.67,84.27 344.49,83.09 337.44,83.09 334.43,80.08 334.43,67.67 338.96,63.13 342.71,63.13 347.85,57.98 347.85,55.8 348.4,55.25 348.4,42.64 350.14,40.9 350.14,39.25 346.77,35.89 346.77,34.74 348.4,33.12 348.4,27.1 347.22,25.92 347.22,23.25 347.92,22.55 v2(349.57,22.55)
  IN3 w0.508: v2(349.57,22.55) 349.57,23.85 348.18,25.23 348.18,29.86 345.08,32.97 340.16,32.97 339.39,32.2 331.86,32.2 330.66,31 322.77,31 320.71,28.94 316.51,28.94 314.38,31.07 v2(313.27,31.07)
  IN4 w0.508: v2(313.27,31.07) 312.15,31.07 311.33,31.9 305.42,31.9 303.86,30.34 299.7,30.34 297.16,27.81 297.16,25.88 v2(296.3,25.02)
  BOTTOM w0.254: PR400.1 349,21.98 v2(349.57,22.55)
  BOTTOM w0.508: v2(296.3,25.02) 295.55,24.27 294.87,24.27 294.36,23.76 291.34,23.76 290.83,23.25 290.83,22.83 290.45,22.45 290.45,22.43 289.94,21.93 287.46,21.93 286.01,20.48 286.01,17.97 v2(286.68,17.31)
+3VS: length 821.8
  TOP w0.254: v2(113.86,112.72) 113.92,112.66 PR1114.1
  TOP w0.381: v2(63.07,3.3) 63.07,3.09 62.59,2.61 RH572.2 ; UH14.5 110.68,6.47 111.01,6.8 v2(111.01,7.12)
  TOP w0.508: v2(206.06,52.35) 206.07,52.33 RV658.1 ; RE52.1 v2(309.25,13.28) ; v2(17.1,79.44) 17.59,78.94 RV121.1 ; RH85.2 106.39,6.35 v2(106.88,6.84) ; RE83.1 320.05,36.64 v2(319.53,37.16) ; v2(240.79,41.42) 241.67,42.3 RV1133.2 241.67,44.46 RF1.1 ; PR609.1 292.11,27.19 293.43,27.19 294.01,27.76 294.01,28.08 294.9,28.96 294.9,29.92 294.39,30.43 v2(294.32,30.43) ; RH527.2 82.08,18.09 82.08,18.33 v2(82.3,18.55) ; 244.35,14.99 244.35,17.67 245.83,19.16 248.15,19.16 248.51,18.79 RD4.1 ; CZ43.1 39.19,23.17 QZ9.3 40.8,23.6 41.16,23.24 42.53,23.24 v2(42.55,23.25) ; RD3.1 152.99,18.56 154.01,17.53 v2(154.01,16.9) ; v2(76.9,21.57) 75.81,20.48 RH535.2 ; RD5.1 249.77,24.6 v2(250,24.84) ; RF3.1 v2(238.44,45.02) ; v2(94.79,12.64) 94.79,12.23 94.45,11.88 RH518.2 ; v2(98.91,31.96) 98.69,31.96 98.08,32.57 RE100.1 ; PR707.1 196.85,119.26 v2(196.47,119.64) ; RE101.1 v2(319.71,39.24) ; RE81.1 101.7,35.72 v2(102.12,36.14) 103.66,37.68 110.83,37.68 113.65,40.5 113.65,47.24 113.06,47.84 113.06,48.51 113.35,48.8 v2(113.58,48.8) ; RH525.1 121.36,54.23 121.76,53.83 v2(122.04,53.83) ; RV108.1 225.44,46.92 225.72,46.64 v2(225.72,46.36) ; RV1140.1 225.57,42.63 225.3,42.36 v2(225.3,42.15) ; CH188.1 93.71,14.18 93.96,13.94 93.96,13.88 v2(94.08,13.75) ; v2(161.67,11.15) 161.67,11.38 161.17,11.88 159.78,11.88 RE129.1
  TOP w0.762: 326.07,34.49 326.58,33.98 328.74,33.98 329.31,33.41 331.41,33.41 332.27,32.55 342.49,32.55 344.65,34.71 344.65,36.55 345.38,37.28 347.22,37.28 v2(349.51,39.57) v2(349.51,40.39)
  IN1 w0.381: v2(105.67,1.75) 106.39,1.75 106.86,2.22 109.12,2.22 109.42,2.52 109.42,6.18
  IN1 w0.508: v2(309.25,13.28) 309.25,13.66 309.96,14.37 309.96,15.57 310.3,15.91 311.69,15.91 320.16,24.37 320.16,28.1 323.68,31.63 323.68,34.04 325.01,35.37 v2(326.01,35.37) ; v2(124.16,93.91) 123.25,93 123.25,87.21 125.93,84.53 125.93,71.81 122.58,68.46 122.58,67.76 117.03,62.2 117.03,56.89 113.65,53.52 113.65,48.84 113.62,48.8 v2(113.58,48.8) ; v2(42.55,23.25) 43.24,22.55 47.29,22.55 48.69,23.96 49.45,23.96 50.39,23.02 53.59,23.02 54.84,24.27 56.33,24.27 v2(58.87,21.73) 58.37,21.23 58.37,19.77 59.03,19.11 59.82,19.11 60.87,18.06 63.36,18.06 63.97,18.67 66.25,18.67 66.78,18.14 68.81,18.14 v2(69.34,18.68)
  IN1 w1.016: 244.36,108.12 244.36,106.64 244.12,106.4 244.12,101.84 244.41,101.55 244.41,97.29 246.64,95.07 247.91,95.07 ; 240.92,40.37 240.92,36.38 247.36,29.94 248.68,29.94 250.7,27.92 250.7,25.71 251.19,25.22 ; 176.47,114.47 176.79,114.79 176.79,118.94 177.86,120.02 186.12,120.02 187.49,118.65 195.65,118.65 196.29,119.29 196.29,119.46 v2(196.47,119.64) 197.21,120.38 224.18,120.38 225.84,118.71 225.84,115.9 225.45,115.5 225.45,114.37 226.3,114.03 228.02,112.3 229.22,112.3 229.44,112.07 230.39,112.07 230.47,111.97 230.61,111.84 230.76,111.74 230.94,111.67 231.13,111.64 231.2,111.64 235.63,111.64 235.81,111.68 235.99,111.75 239.99,111.75 239.99,111.73 240,111.73 240.18,111.73 240.68,111.22 240.7,111.22 240.79,111.13 244.31,111.13 244.97,110.47
  IN2 w0.508: v2(113.86,112.72) 113.86,103.54 114.97,102.42 114.97,101.66 114.57,101.25 114.57,100.21 115.19,99.59 115.19,96.8 115.72,96.26 117.36,96.26 117.96,95.67 120.02,95.67 120.3,95.94 121.57,95.94 123.6,93.91 v2(124.16,93.91) ; v2(122.04,53.83) 121.07,53.83 116.07,48.83 113.6,48.83 v2(113.58,48.8)
  IN3 w0.508: v2(42.55,23.25) 40.45,25.35 38.23,25.35 36.26,27.32 36.26,28.69 35.74,29.2 33.89,29.2 32.68,27.99 28.78,27.99 28.4,27.62 28.4,26.56 27.56,25.72 26.1,25.72 25.63,26.19 25.63,27.7 24.79,28.55 21.5,28.55 20.17,29.88 20.17,31 18.94,32.22 18.94,32.66 17.97,33.63 17.97,39.44 16.5,40.92 v2(16.5,42.05) ; v2(238.44,45.02) 238.44,43.77 v2(240.79,41.42) ; v2(170.66,16.86) 170.66,18.04 170.35,18.36 170.35,25.34 v2(172.76,27.75) ; v2(225.72,46.36) 226.2,45.88 226.2,44.18 225.3,43.28 v2(225.3,42.15) ; v2(18.8,91.26) 18.8,81.14 v2(17.1,79.44) ; v2(66.99,7.12) 68.64,8.77 68.64,11.24 v2(69.29,11.88)
  IN4 w0.508: v2(18.8,91.26) 19.17,91.26 19.86,91.96 19.86,93.16 21.45,94.75 v2(23.69,94.75) ; v2(154.01,16.9) 154.96,17.85 170.16,17.85 170.66,17.34 v2(170.66,16.86)
  IN4 w1.524: 248.01,94.22 247.33,93.54 244.75,93.54 242.74,91.54 241.05,91.54 240.46,90.95 236.45,90.95 234.93,89.43 234.93,78.58 237.43,76.08 241.87,76.08 244.03,73.92 244.03,71.51 246.03,69.51 248.32,69.51 251.05,66.77 251.05,57.04 251.52,56.57 251.52,55.43 252.65,54.3 252.65,52.6 254,51.25 254,49.69 256.48,47.21 256.48,41.35 254.83,39.7 254.83,35.44 255.4,34.87 255.4,27.83 258.97,24.27 260.29,24.27 ; 260.29,24.27 262.38,24.27 263.21,25.09 276.94,25.09 278.78,23.25 288.04,23.25 291.49,26.7 293.62,26.7 294.27,27.36 294.27,28.03 295.38,29.14 295.38,29.85 296.5,30.97 298.17,30.97 298.83,31.63 298.98,31.63 299.01,31.66 ; 260.29,24.27 260.34,24.22 260.34,17.64 259.41,16.71 257.56,16.71 256.67,15.82 256.67,15.19 254.6,13.12 252.88,13.12 252.03,13.97 252.03,15.49 252.03,15.49 252.03,18.08
  IN5 w0.381: v2(102.12,36.14) 98.91,32.93 v2(98.91,31.96) 96.22,29.27 96.22,26.16 95.31,25.26 91.67,25.26 88.65,22.23 88.65,22.02 86.51,19.88 86.17,19.88 86,20.05 85.26,20.05 85.23,20.02 84.81,20.02 84.78,20.05 84.15,20.05 84.13,20.04 83.71,20.04 83.7,20.05 82.97,20.05 82.3,19.38 v2(82.3,18.55)
  IN5 w0.508: v2(16.48,43.72) 17.38,44.62 17.38,61.2 17.6,61.42 17.6,67.83 18.09,68.31 18.09,69.99 18.56,70.46 18.56,77.97 v2(17.1,79.44) ; v2(103.23,8.32) 103.23,7.85 103.48,7.59 105.51,7.59 106.26,6.84 v2(106.88,6.84) 109,6.84 109.3,6.54 110.43,6.54 v2(111.01,7.12) 111.01,8.21 v2(110.95,8.28)
  IN6 w0.508: v2(238.44,45.02) 238.44,44.79 238.05,44.4 236.87,44.4 234.19,47.08 229.49,47.08 229.13,46.72 226.07,46.72 v2(225.72,46.36) 225.72,46.58 224.85,47.44 221.58,47.44 220.54,48.48 220.54,50.26 219.91,50.89 207.52,50.89 v2(206.06,52.35) ; v2(241.16,109.93) 241.16,110.37 241.5,110.71 245.03,110.71 245.34,110.41
  BOTTOM w0.152: v2(94.08,13.75) 94.07,13.77 94.04,13.77 UH2.AD13
  BOTTOM w0.254: RH587.2 v2(69.29,11.88)
  BOTTOM w0.305: v2(161.67,11.15) 161.77,11.06 JKB.4 ; 249.18,26.35 249.18,25.24 249.58,24.84 v2(250,24.84) ; v2(172.76,27.75) 172.89,27.63 172.89,27.37 JDIMM1.255
  BOTTOM w0.381: QV14.2 18.86,89.46 RV122.2 ; UD2.5 254.89,6.25 CD47.1 ; v2(63.07,3.3) 63.07,3.12 62.66,2.71 62.15,2.71 61.47,3.39 RH569.2 ; RH91.1 v2(105.67,1.75)
  BOTTOM w0.432: v2(23.69,94.75) 21.09,94.75
  BOTTOM w0.508: QE18.5 67.69,20.25 RE136.1 68.46,20.46 69.34,19.57 69.34,19.49 ; v2(71.4,12.49) 71.4,12.6 71.87,13.07 RH510.2 ; PR1019.2 173.7,113.55 173.93,113.32 174.26,113.32 v2(175.52,114.58) ; QE18.2 67.69,16.7 RE137.1 67.74,15.58 68.53,14.79 RH588.2 69.15,14.23 v2(69.28,14.36) 69.47,14.17 RH512.2 ; 301.51,33.16 302.21,32.46 v2(302.21,31.74) ; 69.34,19.49 70.05,20.2 RH511.2 ; 69.34,19.49 v2(69.34,18.68) ; PR906.1 241.16,110.35 v2(241.16,109.93) ; RD10.1 v2(256.27,2.87) ; v2(69.29,11.88) RH551.1 ; v2(18.8,91.26) 18.8,90.54 18.86,90.48 QV14.2 ; DV12.5 59.12,21.98 v2(58.87,21.73) ; CD47.1 254.89,6.55 255.36,7.02 v2(255.36,8.15) ; RH5.1 123.57,94.28 123.95,93.91 v2(124.16,93.91) ; 301.35,33.16 301.3,33.2 298.01,33.2 297.96,33.16 297.4,33.16 297.21,32.97 295.91,32.97 294.98,32.03 294.98,31.02 294.39,30.43 v2(294.32,30.43)
  vias: v2(71.58,1.7) v2(72.26,1.7) v2(72.8,7.22) v2(73.38,7.12) v2(73.47,13.03) v2(103.83,8.33) v2(172.89,9.37) v2(173.2,8.85) v2(173.53,9.37) v2(216.9,11.06) v2(217.54,11.06) v2(218.17,11.06) v2(218.76,11.06) v2(245.45,15.58) v2(245.95,110.46) v2(245.95,109.88) v2(246.04,15.58) v2(246.67,15.58) v2(248.86,96.34) v2(248.88,95.7) v2(248.86,95.07) v2(252.72,23.78) v2(252.69,23.16) v2(302.18,31.05) v2(302.72,31.38) v2(309.5,36.71) v2(309.94,37.16) v2(326.01,36.06) v3(72.52,18.84)
+3VS_AUDIO: length 67.2
  TOP w0.14: v2(5.23,10.61) v3(4.67,10.61)
  TOP w0.508: v2(11.88,33.85) 11.49,33.85 10.81,34.54 9.49,34.54 9.31,34.71 7.2,34.71 RA18.2
  IN1 w0.508: v2(11.88,33.85) 11.54,33.85 10.39,35 5.4,35 4.78,34.38 4.78,33.08 5.18,32.68 5.18,31.28 4.62,30.73 4.62,27.88 v2(4.43,27.69)
  IN5 w0.508: v2(5.23,10.61) 3.78,12.07 3.78,16.1 5.84,18.17 5.84,19.58 7.42,21.15 7.42,21.68 7.87,22.76 7.88,22.81 7.88,24.96 5.14,27.69 v2(4.43,27.69) 4.43,30.59 5.18,31.33 5.18,32.86 4.78,33.26 4.78,35.44 4.93,35.59 4.93,40.38 3.16,42.15 3.16,45.81 3.6,46.24 v2(5.08,46.24)
  BOTTOM w0.356: v2(4.43,27.69) 4.43,27.93 4.04,28.32 RA17.1
  BOTTOM w0.381: RA82.1 4.97,45.03 5.08,45.14 v2(5.08,46.24)
  BOTTOM w0.508: LA4.1 12.13,33.6 v2(11.88,33.85)
  vias: v2(9.77,11.17) v2(9.89,10.56) v2(9.88,9.98) v2(15.58,18.98) v2(15.58,18.39)
+3VS_CAM: length 93.8
  TOP w0.127: v2(92.83,36.28) 93.1,36 93.1,32.36 v3(92.83,32.08)
  TOP w0.508: RZ37.2 45.89,25.9 CZ44.1 47.61,25.9 v2(48.39,26.68)
  IN1 w0.508: v2(92.83,36.28) 92.65,36.1 92.36,36.1 92.36,36.1 87.73,36.1 84.76,33.13 81.76,33.13 79.45,30.81 74.11,30.81 72.78,29.48 71.76,29.48 67.06,24.77 60.01,24.77 57.6,27.19 52.45,27.19 51.69,26.42 51.69,26.26 51.31,25.88 50.78,25.88 50.48,26.17 48.9,26.17 v2(48.39,26.68)
  IN6 w0.508: v2(92.83,36.28) 89.13,32.58 61.47,32.58 60.83,31.95 v2(60.83,31.7)
  BOTTOM w0.254: v2(60.83,31.7) 61.05,31.91 JEDP1.22
+3VS_CR: length 6.1
  BOTTOM w0.203: 343.35,37.54 343.19,37.69 UR1.27 ; 336.74,35.95 336.95,35.95 337.49,36.49 UR1.11
  BOTTOM w0.457: 333.93,36.47 334.27,36.14 335.73,36.14 335.92,35.95 336.74,35.95
  BOTTOM w0.508: CR1.1 333.93,36.47
  vias: v1(345.57,32.94) v2(332.26,37.22) v2(332.26,36.64) v2(346.01,35.89) v2(346.01,35.19)
+3VS_FFS: length 18.4
  TOP w0.305: UF1.1 CF2.1 ; 239.48,47.58 239.13,47.94 UF1.14 ; UF1.8 235.4,47.94 235.19,47.74 235.19,47.24 v2(235.06,47.11) 234.91,47.11 234.6,47.43 v3(234.6,47.58) 234.6,47.89 235.15,48.44 UF1.7
  TOP w0.508: CF2.1 238.06,51.11 v2(237.76,50.81)
  IN1 w0.508: v2(235.06,47.11) 235.06,49.62 235.64,50.2 237.31,50.2 237.76,50.65 v2(237.76,50.81) 237.91,50.66 239.92,50.66 240.89,49.69 240.89,47.44
  vias: v2(239.8,47.43) v2(240.32,47.15)
+3VS_TP: length 138.1
  TOP w0.102: v2(189.61,6.36) 189.68,6.3 v3(189.68,5.41)
  TOP w0.381: QE2.5 196.87,12.22 196.63,11.99 v2(196.63,11.88) 196.63,11.81 196.87,11.58 QE2.2
  TOP w0.508: RE26.1 RE24.1 301.88,24.82 v2(301.87,24.84)
  IN3 w0.508: v2(291.46,22.79) 290.8,22.13 282.01,22.13 279.38,19.51 277.71,19.51 277.39,19.18 273.36,19.18 271.28,17.11 268.64,17.11 265.93,14.4 259.43,14.4 259.27,14.23 255.08,14.23 254.26,15.06 252.85,15.06 250.28,12.49 232.53,12.49 231.77,11.74 230.4,11.74 228.49,9.83 216.45,9.83 213.91,12.38 199.71,12.38 198.34,11.01 197.05,11.01 196.63,11.43 v2(196.63,11.88)
  IN6 w0.508: v2(291.46,22.79) 292.21,23.54 294.3,23.54 294.93,24.17 296.62,24.17 297.41,24.95 297.41,26.22 297.97,26.78 299.38,26.78 300.56,25.6 301.36,25.6 301.84,25.12 301.84,24.86 v2(301.87,24.84)
  BOTTOM w0.508: v2(196.63,11.88) 196.63,11.28 192.53,7.18 190.37,7.18 189.61,6.42 v2(189.61,6.36) 187.9,6.36 186.36,7.89 186.36,9.48 186,9.84 JTP.8
+3VS_TPM: length 23
  TOP w0.254: UE1.22 151.22,6.43 150.79,6 150.14,6 CE12.1 ; v2(153.43,10.78) UE1.14
  TOP w0.508: v2(151.51,9.98) 151.55,9.98 152.1,10.53 152.1,11.11 151.96,11.25 v1(151.96,13.48) 151.96,13.88 152.46,14.39 155.13,14.39 155.53,13.99 RE134.1 156.13,12.2 RE128.1 ; v2(153.43,10.78) 153.43,11.08 153.62,11.27 CE13.1 ; RE121.2 148.97,11.53 RE86.1 149.14,10.55 148.94,10.35 v2(148.94,9.59) ; v2(159.9,7.18) 159.65,6.93 RE14.1 ; CE12.1 149.8,4.83 CE14.1 150.05,3.53 v2(149.75,3.22) ; v2(153.54,3.68) 153.83,3.68 154.23,3.28 RE77.1
+3VS_TPM_VSB: length 10.3
  TOP w0.254: 157.33,5.43 UE1.1
  TOP w0.508: 157.33,5.43 157.85,4.91 CE11.1 158.24,4.41 157.98,4.15 v2(157.88,4.15)
  BOTTOM w0.508: CE83.1 RE141.2 ; RE141.2 153.54,4.71 v1(154.43,3.82) ; RE141.2 156.43,5.09 157.37,4.15 v2(157.88,4.15)
+3VS_TS: length 13.2
  BOTTOM w0.508: 339.35,48.4 v3(339.35,50.43) 339.35,53.54 338.84,54.05 337.3,54.05 336.79,53.54 JTS.1
  BOTTOM w0.762: 339.35,47.39 CZ29.1 ; 339.35,47.39 339.46,47.51 RZ26.2 ; 339.35,47.39 339.35,48.4
+3VS_WLAN: length 1.4
  TOP w0.102: v3(334.14,109.74) 333.62,109.22 CN9.1
  vias: v2(330.84,95.22) v2(330.84,94.56) v3(332.49,108.53) v3(332.49,106.56)
+5V_CHGUSB_1: length 2
  TOP w0.102: v2(331.78,66.3) v3(331.22,66.3)
  BOTTOM w0.254: 331.34,66.11 330.77,66.11 330.57,65.91 UI2.12
  vias: v2(331.79,68.06) v2(331.78,67.47) v2(331.78,66.89)
+5V_CHGUSB_2: length 0.7
  TOP w0.102: 24.51,93.35 24.51,93.99 v3(24.45,94.05)
  vias: v2(19.62,107.32) v2(20.21,107.32) v2(20.84,107.34) v2(20.83,106.75) v2(23.56,93.29) v2(23.56,92.66) v2(24.14,92.43) v2(24.16,93.04)
+5VALW: length 453.4
  TOP w0.203: v2(241.28,2.66) 241.59,2.97 UZ7.4 ; UA4.4 9.49,4.93 v2(9.39,4.83) ; UZ1.4 314.64,34.61 314.72,34.53 315.51,34.53 v2(315.79,34.81)
  TOP w0.254: v2(135.54,68.59) 135.15,68.2 UZ16.4 ; UN3.4 338.6,102.42 v2(338.76,102.59) ; UZ4.4 55.58,6.03 55.88,6.34 CZ11.1 ; UE6.4 193.11,5.59 193.56,6.04 v2(193.56,6.35) ; UZ24.4 v2(208.39,48.27)
  TOP w0.305: CZ97.1 180.59,86.17 180.34,85.92 180.34,85.07 180.27,85 UZ15.3
  TOP w0.356: RP24.10 v2(339.9,101.9) ; RP24.5 v2(343.2,104.5)
  TOP w0.432: LED4.2 v2(348.15,95.39) ; LED3.2 v2(348.17,98.99) ; LED2.2 v2(348.08,102.59) ; LED1.2 v2(348.19,106.19) ; LED5.2 v2(348.19,91.79)
  TOP w0.508: v2(180.59,87.58) CZ97.1 ; v2(56.27,7.18) 56.27,6.88 CZ11.1 ; v2(105.22,51.35) 105.22,49.79 v2(104.37,48.94) ; RV181.1 v2(242.16,98.15) ; PR603.1 288.21,25.23 v2(288.04,25.41) v3(288.04,26.12) 288.04,26.49 v2(288.8,27.25) ; v2(248.33,46.47) 248.33,46.98 RV657.1 ; RE3.1 v2(330.07,107.5) ; PR104.2 40.63,32.71 v2(40.63,33.28)
  IN1 w0.508: v2(135.54,68.59) 135.54,68.85 136.28,69.59 137.75,69.59 138.29,70.14 138.29,73.42 137.85,73.87 137.85,86.04 138.62,86.81 138.62,88.43 139.26,89.06 170.53,89.06 v2(171.22,88.38)
  IN2 w0.508: v2(288.8,27.25) 288.8,27.57 290.29,29.06 290.29,32.27 290.75,32.73 297.39,32.73 297.75,33.09 297.93,33.12 298.01,33.2 298.32,33.2 298.73,33.28 300.08,33.28 300.31,33.05 308.23,33.05 308.93,33.75 314.26,33.75 ; v2(208.39,48.27) 208.24,48.42 208.24,50.58 207.39,51.43 205.68,51.43 205.14,51.97 205.14,52.61 203.37,54.39 202.38,54.39 201.69,55.08 201.69,55.89 199.75,57.83 198.94,57.83 198.17,58.59 198.17,61.05 197.69,61.53 197.04,61.53 195.25,63.32 194.88,63.32 188.88,69.32 188.88,70.13 187.5,71.5 184.35,71.5 183.48,72.37 183.48,79.39 180.47,82.41 180.47,85.49 179.9,86.05 v2(179.87,86.05)
  IN3 w0.508: v2(315.79,34.81) 316.18,34.41 v2(321.59,34.41)
  IN4 w0.508: v2(180.59,87.58) 178.36,87.58 177.85,88.08 177.85,89.3 176.75,90.41 173.06,90.41 171.22,88.56 v2(171.22,88.38) ; 31.31,25.35 32.83,26.87 32.83,28.33 33.97,29.47 34.84,29.47 36.18,30.82 39.83,30.82 40.63,31.62 v2(40.63,33.28)
  IN5 w0.508: 248.61,92.08 247.59,91.07 247.59,90.95 v2(247.52,90.88)
  IN5 w1.016: 249.75,111.36 249.75,94.5 248.61,93.36 248.61,92.08 249.81,92.08 251.32,90.57 251.32,78.29 250.57,77.54 245.94,77.54 244.29,75.89 244.29,71.19 245.75,69.73 250.64,69.73 251.21,69.16 251.21,55.89 252.41,54.68 252.41,51.82 251.08,50.49 251.08,46.87 250.45,46.24 249.3,46.24
  IN6 w0.508: v2(180.59,87.58) 180.59,86.78 v2(179.87,86.05)
  BOTTOM w0.203: PU600.12 288.67,27.38 v2(288.8,27.25)
  BOTTOM w0.229: v2(19.56,30.11) 19.51,30.11 19.18,30.44 19.18,30.45 19.08,30.55 19.08,31.07 18.95,31.2 UT3.4
  BOTTOM w0.254: UZ5.4 344.44,43.77 v2(344.74,44.08)
  BOTTOM w0.305: v2(163.01,8.96) 163.27,9.22 JKB.1 ; CZ86.1 181.62,84.07 181.86,83.84 UZ9.3
  BOTTOM w0.508: v2(135.54,68.59) 132.22,68.59 130.57,66.94 127.57,66.94 125.35,64.72 124.93,64.72 121.1,60.89 121.1,55.07 120.89,54.85 120.89,53.5 120.08,52.69 111.48,52.69 110.15,51.35 v2(105.22,51.35) ; v2(288.04,25.41) PC607.2 ; v2(247.52,90.88) 246.79,91.61 245.81,91.61 244.74,92.68 240.51,92.68 239.02,94.18 239.02,96.34 240.83,98.15 v2(242.16,98.15) ; v2(208.39,48.27) 208.13,48 208.13,45.69 211.2,42.62 218.57,42.62 219.7,43.75 221.11,43.75 221.87,44.51 221.87,46.34 222.82,47.29 226.35,47.29 227.28,46.36 231.07,46.36 235.18,50.47 235.18,50.63 236.12,51.57 238.32,51.57 241.19,48.7 241.19,46.62 243.6,44.2 246.37,44.2 247.35,45.18 248.27,45.18 ; CZ86.1 181.04,84.07 180.53,84.58 180.53,85.54 180.02,86.05 v2(179.87,86.05) ; v2(104.37,48.94) 104.36,48.95 JUART.1
  BOTTOM w1.016: 248.73,44.46 248.73,40.46 250.95,38.24 252.79,38.24 254.19,36.84 254.19,25.54 253.62,24.96 253.62,22.5 254.38,21.74 254.38,18.49 253.18,17.28 253.18,15.69 250.45,12.96 250.45,8.14 249.3,6.99
  vias: v2(7.81,5.66) v2(7.91,4.97) v2(8.44,4.59) v2(23.92,89.38) v2(23.89,88.76) v2(23.89,88.17) v2(23.89,87.55) v2(23.85,7.84) v2(24,7.25) v2(24.21,8.38) v2(24.45,7.69) v2(30.04,53.67) v2(30.1,52.84) v2(30.52,53.29) v2(30.69,52.71) v2(30.83,52.11) v2(31.24,51.7) v2(180.06,9.56) v2(180.67,9.58) v2(181.28,9.58) v2(181.87,9.58) v2(183.22,9.58) v2(239.65,2.29) v2(240.11,2.75) v2(247.87,6.2) v2(248.33,45.86) v2(248.46,6.2) v2(249.75,113.04) v2(249.75,112.34) v2(314.96,33.64) v2(315.55,33.63) v2(316.15,33.63) v2(316.17,5.6) v2(316.17,4.96) v2(316.17,4.33) v2(316.8,5.6) v2(316.8,4.96) v2(316.8,4.33) v2(317.44,5.6) v2(317.44,4.96) v2(317.44,4.33) v2(318.07,5.6) v2(318.07,4.96) v2(318.07,4.33) v2(318.71,5.6) v2(318.71,4.96) v2(318.71,4.33) v2(331.24,61.85) v2(331.24,61.21) v2(331.83,61.85) v2(331.83,61.21) v3(239.29,2.78) v3(316.7,3.74)
+5VALWP: length 67.5
  TOP w0.508: PR402.2 v2(349.56,18.93)
  BOTTOM w0.254: PC402.2 349.56,19.08 v2(349.56,18.93) 348.98,18.36 348.98,16.53 349.7,15.82 349.7,11.44 345.95,7.69 345.95,6.74 341.73,2.53 326.48,2.53 325.88,3.12 321.37,3.12 v2(321.25,3.25)
  BOTTOM w0.508: v2(341.89,19.95) 333.25,19.95 329.44,16.14 329.44,10.3 328.21,9.06 328.21,5.99 v2(328.22,5.98)
  vias: v1(322.38,2.69)
+5VS: length 456.5
  TOP w0.508: v2(164.47,10.59) 164.02,11.04 164.02,11.82 161.1,14.73 v2(161.1,16.86) ; RE105.1 320.8,41.47 321.31,40.97 v2(321.37,40.97) 321.37,40.34 RE84.1 ; RE104.1 97.03,32.37 98.14,31.26 102.31,31.26 103.34,32.29 v2(103.34,32.3) ; v2(136.65,113.43) 136.25,113.83 118.45,113.83 v2(117.55,112.92) ; v2(112.76,94.27) 112.88,94.38 PC1364.2 ; RF2.1 232.93,44.03 v2(232.98,44.07) ; v2(183.76,117.8) 183.76,117.81 184.48,118.53 PR700.1 ; 95.19,36.84 95.19,37.15 97.05,39.01 100.32,39.01 103.06,41.75 103.06,52.23 103.84,53.01 103.84,65.64 103.57,65.91 103.57,68.95 103.96,69.34 104.83,69.34 105.17,69.68 v2(105.17,69.94) ; v2(59.09,20.02) 60.45,21.38 60.45,22.23 58.97,23.72 57.19,23.72 56.25,24.66 QV9.2
  IN1 w0.254: v2(152.78,117.75) 152.78,116.91 152.26,116.39 145.42,116.39 143.82,114.79 142.41,114.79 141.49,113.88 139.45,113.88
  IN1 w0.508: v2(306.11,34.02) 305.3,33.2 298.01,33.2 296.48,31.68 296.48,30.3 293.76,27.58 293.76,27.57 293.41,27.21 293.4,27.21 293.02,26.83 289.24,26.83 288.54,26.13 282.16,26.13 280.02,24 277.87,24 277.42,24.44 268.82,24.44 265.71,21.33 261.94,21.33 251.86,31.41 247.96,31.41 245.68,33.69 245.68,39.87 242.72,42.82 234.3,42.82 233.05,44.07 v2(232.98,44.07) ; 137.03,114.58 137.03,119.38 137.83,120.18 152.53,120.18 153.04,119.67 153.04,118 v2(152.78,117.75) ; v2(117.55,112.92) 115.05,110.43 115.05,108.73 114.59,108.27 114.59,103.49 115.05,103.03 115.05,99.5 113.77,98.22 113.77,94.71 113.32,94.27 v2(112.76,94.27)
  IN2 w0.508: v2(152.78,117.75) 154.2,117.75 155.57,119.12 156.95,119.12 157.23,118.84 162.66,118.84 164.47,117.04 165.42,117.04 166.94,115.52 166.94,113.61 165.48,112.15 v2(165.48,110.18)
  IN3 w0.508: v2(105.17,69.94) 104.65,70.46 104.65,77.48 105.22,78.05 v2(105.22,78.81) 105.27,78.86 105.27,91.14 106.57,92.44 109.83,92.44 110.3,91.97 111.95,91.97 112.82,92.83 112.82,94.22 v2(112.76,94.27)
  IN6 w0.508: v2(152.78,117.75) 154.2,117.75 155.62,119.17 156.47,119.17 156.8,118.84 164.63,118.84 165.54,117.93 169.69,117.93 173.03,114.6 173.03,114.18 174.13,113.08 175.58,113.08 176.43,113.93 180.94,113.93 183.76,116.75 v2(183.76,117.8)
  IN6 w1.016: 28.96,12.77 28.11,13.62 28.11,17.21 29.06,18.16 31.67,18.16 33.41,19.91 40.87,19.91 41.34,19.44 48.01,19.44
  IN6 w1.524: 305.87,33.89 304.9,32.93 300.6,32.93 298.67,31 296.55,31 295.38,29.83 295.38,29.14 294.27,28.03 294.27,27.36 293.62,26.7 293.45,26.7 291.78,25.04 290.05,25.04 289.52,24.51 288.99,23.98 288.99,23.98 288.32,23.31 287.1,23.31 286.43,23.98 281.7,23.98 281.04,23.32 279.96,23.32 279.96,23.31 279.02,23.31 277.77,22.07 271.77,22.07 268.76,25.08 262.62,25.08 261.43,23.89 261.43,21.65
  BOTTOM w0.254: PU1302.6 112.95,94.45 v2(112.76,94.27) ; PC1302.2 105.77,78.49 PU1300.14 ; PC1227.2 137.69,113.66 137.69,113.39 138.31,112.78 138.81,112.78 139.32,113.29 PU1201.14 ; PC1336.2 104.74,70.9 105.01,71.17 PU1301.14 ; PU1202.14 155.03,117.03 154.4,116.4 PC1249.2 ; PU1200.14 139.26,107.65 138.61,107 137.63,107 PC1200.2
  BOTTOM w0.305: v2(164.47,10.59) 163.97,11.08 163.01,11.08 162.77,10.84 JKB.2
  BOTTOM w0.508: v2(165.48,110.18) 166.05,110.75 PR1012.2 ; v2(105.17,69.94) 104.74,70.37 PC1336.2 ; v2(306.11,34.02) 306.11,34.54 307.08,35.51 307.34,35.51 307.9,36.06 312.34,36.06 315.39,39.11 317.45,39.11 319.3,40.97 v2(321.37,40.97) ; PC1227.2 137.13,113.91 v2(136.65,113.43) ; PR1101.1 117.54,112.91 v2(117.55,112.92) ; v2(152.78,117.75) 152.78,117.21 153.59,116.4 PC1249.2 ; v2(105.22,78.81) 105.22,78.34 PC1302.2 ; PR1513.2 183.71,117.85 v2(183.76,117.8) ; PC1200.2 137.56,107.64 v2(137.29,107.91)
  vias: v2(17.4,88.34) v2(17.65,87.7) v2(29.85,12.52) v2(30.48,12.52) v2(49.09,19.69) v2(49.67,19.69) v2(242.05,16.86) v2(242.66,16.86) v2(306.81,34.38) v3(95.47,34.25)
+5VS_AUDIO: length 33.9
  IN3 w0.508: v2(14.35,37.21) 13.56,36.42 12.51,36.42 11.9,37.03 10.42,37.03 10.06,36.67 10.06,35.23 11.15,34.13 11.15,32.91 11.71,32.35 11.71,31.05 11.82,30.93 11.85,30.9 12.97,29.78 12.97,25.89 11.31,24.23 10.27,24.23 9.6,23.56 9.6,20.6 8.25,19.24 8.25,18.62 7.7,18.06 7.7,16.47 7.56,16.33 7.56,11.88 v2(7.56,11.88)
  vias: v2(6.92,11.88) v3(14.85,37.6)
+5VS_HDD: length 1.2
  TOP w0.102: v3(236.35,8.28) CZ45.1
  vias: v2(237.63,9.43) v2(238.23,9.44) v2(238.81,9.44) v3(237.55,10.36) v3(239.44,10.26)
+AVDD1: length 1.1
  BOTTOM w0.14: v1(15.96,41.42) 15.62,41.08 CA7.1
  vias: v2(12.97,40.25)
+AVDD2: length 8.5
  TOP w0.508: RA2.2 3.13,32.42 v2(3.33,32.62)
  IN1 w0.508: v2(4.32,39.13) 3.54,38.36 3.54,37.98 2.41,36.85 2.41,33.54 v2(3.33,32.62)
  vias: v1(4.18,39.72)
+DVDD: length 15.3
  IN2 w0.254: v2(9.06,33.8) 9.06,35.87 10.25,37.07 11.84,37.07 12.36,36.55 13.47,36.55 13.58,36.66 15.57,36.66 v2(16.46,35.78)
  BOTTOM w0.14: v2(11.09,32.08) 11.08,32.07 11.08,31.56 11.29,31.35 v1(11.63,31.35)
  BOTTOM w0.254: RA12.1 15.97,36.27 v2(16.46,35.78)
  BOTTOM w0.305: v2(11.09,32.08) 11.18,32.17 RA15.1
  BOTTOM w0.356: RA15.1 11.46,32.66 11.81,32.31 LA4.2
  BOTTOM w0.381: RA13.1 6.89,32.74 6.42,32.26 v2(6.42,32.18)
+DVDDIO: length 7.2
  TOP w0.254: CA39.1 5.62,32.87 RA18.1 6,33.62 6,34.78 v1(5.44,35.33) 4.79,35.99 4.68,35.99 4.32,36.34 CA40.1 4.1,36.36 3.75,36.71 v2(3.75,37.03)
+VBUS_1: length 63.7
  TOP w0.102: v2(29.91,27.17) v3(29.91,27.82)
  TOP w0.127: v3(26.2,66.68) 26.49,66.4 v2(26.49,66.02) ; v2(27.03,65.69) 27.38,65.69 v3(27.73,65.35)
  TOP w0.508: PD203.2 30.42,26.11 29.91,26.62 v2(29.91,27.17)
  IN3 w0.508: v2(29.91,27.17) 29.91,26.43 28.04,24.56 23.26,24.56 21.93,23.24 19.68,23.24 19.51,23.07 18.18,23.07 16.74,21.62 15.62,21.62 15.17,22.07 15.17,23.01 14.54,23.64 v2(14.54,25.15)
  IN5 w0.508: 16.57,62.05 16.78,61.85 16.78,44.88 15.72,43.83 15.72,32.23 16.38,31.57 16.38,29.76 14.19,27.56 14.19,25.51 v2(14.54,25.15)
  vias: v2(8.84,67.14) v2(8.81,64.63) v2(11.87,65.15) v2(12.45,65.15) v2(12.45,64.56) v2(12.93,67.32) v2(12.98,66.32) v2(13.03,65.73) v2(13.03,65.15) v2(13.03,64.56) v2(26.49,65.44) v2(26.49,64.86) v2(27.03,66.28) v2(27.03,65.11) v2(26.98,64.51)
+VBUS_DC_SS: length 77.4
  TOP w0.102: v3(16.51,31.31) 16.45,31.38 15.81,31.38
  TOP w0.508: v2(53.4,11.59) 53.43,11.59 53.23,11.39 53.23,10.28 54.31,9.2 PD303.2 ; PC289.1 16.38,30.12 16.13,30.37 v2(15.74,30.37) 15.81,30.44 15.81,32.08 15.52,32.37 PC288.1
  IN2 w0.508: v2(53.4,11.59) 54.62,12.8 54.62,13.89 54.67,13.95 54.67,16.68 54.5,16.86 54.5,17.36 54.67,17.53 54.67,19.04 51.69,22.03 49.07,22.03 47.22,20.17 45.83,20.17 45.52,20.48 45.52,21.34 44.56,22.3 40.7,22.3 38.8,24.2 31.93,24.2 31.07,23.34 29.14,23.34 26.28,20.48 22.44,20.48 v2(20.51,18.55)
  IN5 w0.508: v2(20.51,18.55) 18.67,18.55 17.97,17.85 16.83,17.85 16.19,18.49 16.19,20.14 13.29,23.05 13.29,27.52 15.74,29.98 v2(15.74,30.37)
  BOTTOM w0.508: v2(20.51,18.55) 20,19.06 PR260.1
+VCC0V9_CIO: length 4.6
  TOP w0.089: v2(28.01,40.99) 28.4,40.99 v1(28.57,41.16)
  TOP w0.381: CT101.1 31.88,44.2 32.32,43.76 CT103.1 32.32,42.96 CT102.1 32.54,42.93 v2(32.98,42.49)
  IN4 w0.508: v2(28.01,40.99) 28.01,41.49 28.66,42.14 v2(28.66,42.29)
+VCC0V9_DP: length 1.3
  IN2 w0.254: v2(29.31,40.35) 29.31,40.35 v2(29.31,40.99) ; v2(26.72,42.94) v2(27.36,42.94)
  vias: v2(26.71,40.99) v3(27.43,42.33)
+VCC0V9_PCIE: length 2.6
  IN2 w0.254: v2(27.36,37.74) v2(26.71,37.74) v2(26.71,38.39) v2(26.71,39.04) v2(26.71,39.69)
  vias: v1(26.76,37.13)
+VCC0V9_USB: length 2.9
  TOP w0.089: CT93.1 28.64,37.54 29.52,37.54 v1(29.74,37.31)
  TOP w0.381: v2(28.66,39.04) 28.66,38.37 CT94.1 28.55,37.99 CT93.1
+VCC_CORE: length 22.5
  TOP w0.508: v2(168.56,71.81) 168.97,71.81 PC1220.1 ; v2(163.64,69.94) 163.23,69.94 PC1269.1 ; v2(161.16,71.27) 160.75,71.27 PC1276.1 ; v2(161.22,70) 160.82,70 PC1261.1
  BOTTOM w0.152: 172.07,67.89 UH1.L14 UH1.K14 172.42,67.77 v2(172.31,67.66) ; v2(162.12,67.87) 161.8,67.55 UH1.AD13 161.46,67.55 161.38,67.62 ; v2(162.12,67.87) 162.45,68.2 UH1.AC14 ; v2(162.12,67.87) 161.8,68.2 UH1.AD14 161.39,67.89 ; v2(162.12,67.87) 162.16,67.87 162.48,67.55 UH1.AC13 UH1.AC14 ; 161.11,67.6 161.06,67.55 UH1.AE13 UH1.AE14 161.1,68.51 ; 168.69,67.87 v2(168.56,67.87) 168.43,67.87 UH1.R13 168.2,67.46 168.93,67.46 UH1.P13 ; 168.69,67.87 UH1.P14 169.33,68.51 ; 168.69,67.87 UH1.P13 ; UH1.AC14 162.62,68.71 ; UH1.AC14 162.75,68.2 v2(163.08,67.87) 163.4,67.55 UH1.AA13 163.69,67.55 163.91,67.76 ; 165.95,67.66 166.07,67.55 UH1.V13 UH1.V14 165.97,67.89 ; UH1.P13 169.34,67.55 169.36,67.53 ; 172.75,67.95 172.91,67.79 UH1.K13 172.72,67.43 172.54,67.43 ; 165.7,67.67 165.57,67.55 UH1.W13 UH1.W14 165.67,68.51 ; UH1.L13 172.07,67.86 ; UH1.N14 169.62,67.89 ; UH1.N13 170.25,67.86
  BOTTOM w0.508: RH197.1 157.49,94.64
  vias: v2(149.95,110.4) v2(149.95,109.79) v2(149.92,109.18) v2(149.92,108.59) v2(149.92,107.96) v2(149.92,107.32) v2(149.92,106.69) v2(149.92,106.05) v2(150.58,110.4) v2(150.58,109.79) v2(150.56,109.18) v2(150.56,108.59) v2(150.56,107.96) v2(150.56,107.32) v2(150.56,106.69) v2(150.56,106.05) v2(151.22,110.4) v2(151.22,109.79) v2(151.19,109.18) v2(151.19,108.59) v2(151.19,107.96) v2(151.19,107.32) v2(151.7,102.88) v2(151.83,109.18) v2(151.83,108.59) v2(151.83,107.96) v2(151.83,107.32) v2(151.85,110.4) v2(151.85,109.79) v2(152.32,102.82) v2(152.32,102.18) v2(152.49,110.4) v2(152.49,109.79) v2(152.46,109.18) v2(152.46,108.59) v2(152.46,107.96) v2(152.46,107.32) v2(152.96,102.82) v2(152.96,102.18) v2(152.96,101.49) v2(152.96,100.86) v2(153.12,110.4) v2(153.12,109.79) v2(153.1,109.18) v2(153.1,108.59) v2(153.1,107.96) v2(153.1,107.32) v2(153.59,102.82) v2(153.59,102.18) v2(153.56,101.51) v2(153.56,100.87) v2(153.73,109.18) v2(153.73,108.59) v2(153.73,107.96) v2(153.73,107.32) v2(153.76,110.4) v2(153.76,109.79) v2(154.2,104.61) v2(154.23,103.92) v2(154.23,103.29) v2(154.23,102.64) v2(154.19,102.04) v2(154.19,101.41) v2(154.39,110.4) v2(154.39,109.79) v2(154.37,109.18) v2(154.37,108.59) v2(154.37,107.96) v2(154.37,107.32) v2(154.37,106.69) v2(154.36,105.88) v2(154.36,105.24) v2(154.84,104.61) v2(154.84,103.92) v2(154.84,103.29) v2(154.84,102.65) v2(154.83,102.04) v2(154.83,101.41) v2(154.99,105.88) v2(154.99,105.24) v2(155.47,104.61) v2(155.47,103.92) v2(155.47,103.3) v2(155.47,102.66) v2(155.47,102.03) v2(155.47,101.39) v2(155.63,105.86) v2(155.63,105.24) v2(156.11,104.61) v2(156.11,103.92) v2(156.11,103.29) v2(156.11,102.65) v2(156.11,102.02) v2(156.11,101.38) v2(156.22,105.86) v2(156.26,105.24) v2(156.86,98.81) v2(156.86,98.18) v2(156.86,97.54) v2(156.86,96.85) v2(159.98,87.83) v2(160.12,86.04) v2(160.12,84.73) v2(160.12,82.13) v2(160.38,104.49) v2(160.38,103.86) v2(160.38,103.22) v2(160.38,102.59) v2(160.38,101.95) v2(160.38,101.32) v2(160.61,87.83) v2(160.72,78.05) v2(160.91,86.69) v2(160.91,85.38) v2(160.91,84.08) v2(161.01,104.49) v2(161.01,103.86) v2(161.01,103.22) v2(161.01,102.59) v2(161.01,101.95) v2(161.01,101.32) v2(161.25,87.83) v2(161.27,67.86) v2(161.65,104.56) v2(161.65,103.92) v2(161.65,103.22) v2(161.65,102.59) v2(161.65,101.95) v2(161.65,101.32) v2(161.7,86.04) v2(161.7,84.73) v2(161.7,83.43) v2(161.7,82.13) v2(161.88,87.83) v2(162.52,87.83) v2(162.49,84.08) v2(162.49,82.78) v2(162.49,81.49) v2(162.62,78.05) v2(162.82,76.34) v2(162.82,75.7) v2(162.82,75.07) v2(162.82,74.43) v2(163.15,87.83) v2(163.27,86.04) v2(163.27,84.73) v2(163.27,82.13) v2(163.64,71.51) v2(163.79,87.83) v2(164.06,86.69) v2(164.06,85.38) v2(164.06,84.08) v2(164.06,82.78) v2(164.42,87.83) v2(164.47,78.05) v2(164.85,84.73) v2(164.85,82.13) v2(164.83,81.49) v2(164.86,83.42) v2(164.92,68.53) v2(165.06,87.83) v2(165.63,86.69) v2(165.63,85.38) v2(165.63,84.08) v2(165.69,87.83) v2(166.18,71.21) v2(166.33,87.83) v2(166.42,86.69) v2(166.42,86.04) v2(166.42,84.73) v2(166.42,83.43) v2(166.42,82.13) v2(166.37,78.43) v2(166.76,68.53) v2(166.96,87.83) v2(167.21,85.38) v2(167.21,84.08) v2(167.21,82.78) v2(167.21,81.49) v2(167.6,87.83) v2(168,86.69) v2(168,86.04) v2(168,84.73) v2(168,82.13) v2(168.15,78.43) v2(168.78,85.38) v2(168.76,84.75) v2(168.78,84.08) v2(168.78,83.41) v2(168.78,82.78) v2(168.79,82.11) v2(169.46,67.86) v2(169.57,86.7) v2(169.59,85.39) v2(169.57,84.73) v2(169.55,82.79) v2(171.31,68.6) v3(152.91,105.86)
+VCCGT: length 41.5
  TOP w0.508: v2(145.45,75.8) 146.06,75.8 PC1311.1 147.61,76.01 PC1306.1 ; v2(145.15,70.16) 144.65,70.16 PC1378.1 ; v2(149.97,70.16) 149.48,70.16 PC1373.1 ; v2(145.32,71.74) 146,71.74 PC1304.1 146.27,71.95 PC1303.1 ; PC1363.1 154.37,70.1 v2(154.8,70.1) ; v2(147.56,70.16) 147.06,70.16 PC1374.1 ; PC1310.1 147.5,74.18 PC1305.1 146,73.96 v2(145.39,73.96) ; v2(150.17,77.3) 149.77,77.3 PC1377.1 ; v2(155.25,77.24) 154.85,77.24 PC1375.1 154.48,77.61 PC1376.1 ; v2(151.19,74.63) 151.59,74.63 PC1359.1 153.08,74.94 PC1360.1 ; PC1350.1 152.99,71.95 PC1300.1 151.96,71.74 v2(151.36,71.74) ; v2(145.21,77.4) 145.68,77.4 PC1379.1 146.9,77.63 PC1314.1 ; v2(151.19,75.97) 151.59,75.97 PC1348.1 153.07,76.26 PC1354.1 ; v2(151.13,73.24) 151.54,73.24 PC1361.1 153.07,73.55 PC1353.1 ; PC1372.1 151.89,70.16 v2(152.38,70.16)
  BOTTOM w0.152: v2(154.85,67.87) 155.17,68.2 UH1.AM14 ; v2(154.85,67.87) 154.52,67.55 UH1.AN13 154.22,67.55 154.09,67.67 ; v2(154.85,67.87) 154.52,68.2 UH1.AN14 154.08,67.89 ; v2(154.85,67.87) 155.17,67.55 UH1.AM13 ; UH1.AM14 155.3,68.65 155.3,68.65 ; UH1.AM14 UH1.AM13 ; UH1.AM14 155.49,68.02 155.75,68.02 UH1.AL13 ; UH1.AM13 UH1.AL13 ; v2(147.52,67.92) 147.8,68.2 UH1.BA14 ; v2(147.52,67.92) 147.15,67.55 UH1.BB13 146.8,67.55 146.72,67.62 ; v2(147.52,67.92) 147.24,68.2 UH1.BB14 146.76,67.89 ; v2(147.52,67.92) 147.89,67.55 UH1.BA13 UH1.BA14 ; UH1.AU14 150.42,68.51 ; 156.57,67.81 156.3,67.55 UH1.AL13 ; UH1.BA14 147.99,68.63 147.99,68.64 ; UH1.AW14 149.51,67.89 ; UH1.BF13 144.64,67.86 ; 144.9,67.69 145.03,67.55 UH1.BD13 145.38,67.55 v2(145.7,67.87) 145.38,68.2 UH1.BD14 144.93,67.89 ; UH1.AT14 151.33,67.89 ; UH1.BF14 144.02,67.89 ; 153.79,68.51 UH1.AP14 UH1.AP13 153.66,67.55 153.77,67.66
  BOTTOM w0.203: UH1.BF38 144.05,86.36
  BOTTOM w0.508: RH203.1 157.49,87.78
  vias: v2(116.71,81.42) v2(116.84,80.72) v2(116.84,80.08) v2(116.84,79.45) v2(116.84,78.81) v2(116.84,78.22) v2(116.97,74.43) v2(116.97,73.8) v2(116.97,73.19) v2(116.97,72.59) v2(117.34,81.56) v2(117.48,80.78) v2(117.48,80.15) v2(117.48,79.51) v2(117.48,78.88) v2(117.48,78.24) v2(117.6,74.49) v2(117.6,73.86) v2(117.6,73.22) v2(117.6,72.59) v2(118.11,80.15) v2(118.11,79.51) v2(118.11,78.88) v2(118.11,78.24) v2(118.24,74.49) v2(118.24,73.86) v2(118.24,73.22) v2(118.24,72.59) v2(118.75,80.15) v2(118.75,79.51) v2(118.75,78.88) v2(118.75,78.24) v2(118.87,74.49) v2(118.87,73.86) v2(118.87,73.22) v2(118.87,72.63) v2(119.38,80.15) v2(119.38,79.51) v2(119.38,78.88) v2(119.38,78.24) v2(119.51,74.49) v2(119.51,73.86) v2(119.51,73.22) v2(119.51,72.63) v2(119.76,77.67) v2(119.76,77.03) v2(119.76,76.4) v2(119.76,75.76) v2(119.83,72.08) v2(119.83,71.45) v2(119.76,70.81) v2(119.76,70.18) v2(120.02,80.15) v2(120.02,79.51) v2(120.02,78.88) v2(120.02,78.24) v2(119.95,75.19) v2(120.21,74.62) v2(120.21,73.99) v2(120.21,73.35) v2(120.21,72.72) v2(120.4,77.67) v2(120.4,77.03) v2(120.4,76.4) v2(120.4,75.76) v2(120.4,70.81) v2(120.4,70.18) v2(120.46,72.08) v2(120.46,71.45) v2(120.73,75.27) v2(120.84,74.62) v2(120.84,73.99) v2(120.84,73.35) v2(120.84,72.72) v2(120.93,76.07) v2(120.96,76.7) v2(121.03,70.14) v2(121.11,72.09) v2(121.06,70.77) v2(121.18,71.38) v2(138.92,84.89) v2(139.77,87.78) v2(140.41,87.78) v2(141.04,87.78) v2(141.68,87.78) v2(142.01,86.71) v2(142.31,87.78) v2(142.8,86.04) v2(142.8,84.73) v2(142.8,84.08) v2(142.8,82.13) v2(142.95,87.78) v2(143.58,87.78) v2(143.59,84.08) v2(143.59,82.78) v2(143.59,81.49) v2(143.59,80.07) v2(144.22,87.78) v2(144.38,86.04) v2(144.38,84.73) v2(144.38,82.13) v2(144.79,68.52) v2(144.85,87.78) v2(145.16,86.69) v2(145.16,85.38) v2(145.16,84.08) v2(145.16,82.78) v2(145.49,87.78) v2(145.95,84.73) v2(145.95,83.43) v2(145.95,82.13) v2(145.95,81.49) v2(146.12,87.77) v2(146.62,68.51) v2(146.74,86.69) v2(146.74,85.38) v2(146.78,87.75) v2(147.43,87.75) v2(147.52,86.04) v2(147.52,84.73) v2(147.52,83.43) v2(147.52,82.13) v2(148.07,87.75) v2(148.31,84.08) v2(148.31,82.78) v2(148.31,81.49) v2(149.1,86.04) v2(149.1,84.73) v2(149.1,82.13) v2(149.89,86.69) v2(149.89,85.38) v2(149.89,84.08) v2(149.89,82.78) v2(150.27,68.52) v2(150.67,84.73) v2(150.67,83.43) v2(150.67,82.13) v2(150.68,81.5) v2(151.46,86.69) v2(151.46,85.38) v2(152.25,86.04) v2(152.25,84.73) v2(152.25,83.43) v2(152.25,82.13) v2(153.04,84.08) v2(153.04,82.78) v2(153.04,81.49) v2(153.82,86.04) v2(153.82,84.73) v2(153.82,82.13) v2(153.93,67.87) v2(154.61,86.69) v2(154.61,85.38) v2(154.61,84.08) v2(154.61,82.78) v2(154.59,82.15) v2(155.39,86.69) v2(155.4,84.73) v2(155.4,82.13) v2(156.19,86.04) v2(156.19,85.38) v2(156.19,84.08) v2(156.19,82.78) v2(156.31,75.52) v2(156.35,72.87) v2(156.97,84.73) v2(156.97,83.43) v2(156.97,82.13) v2(157.76,84.08) v2(157.76,82.78) v2(157.76,81.49) v3(117.92,76.26)
