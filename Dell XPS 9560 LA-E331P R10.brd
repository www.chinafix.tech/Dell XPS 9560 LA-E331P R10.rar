# Allegro board Dell XPS 9560 LA-E331P R10.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on IN6 (solid shape): 152.46,119.26 152.46,118.44 152.27,118.25 152.27,117.93 152.15,117.8 150.86,117.8 150.85,117.79 148.67,117.79 148.49,117.97 148.49,118.12 148.24,118.37 144.37,118.37 144.17,118.17 144.17,117.31 143.84,116.98 143.16,116.98 142.9,116.72 142.9,114.08 142.98,114 144.48,114 144.63,113.85 144.63,110.73 144.35,110.45 143,110.45 142.87,110.31 142.87,107.71 142.95,107.63 143.69,107.63 144.45,106.87 144.45,105.19 144.25,104.99 143.59,104.99 143.41,105.16 143.41,106.56 142.93,107.04 141.72,107.04 141.52,107.11 141.31,107.04 140.53,107.04 140.47,107.1 140.47,107.86 141.02,108.41 141.02,113.01 141.23,113.22 141.23,117.36 140.62,117.97 140.62,119.26 140.77,119.41 152.31,119.41
GND on IN6 (solid shape): outline of 98 points within 8.76,68.78 10.67,72.27
GND on IN6 (solid shape): 10.21,77.68 10.67,77.22 12.38,77.22 12.51,77.1 12.51,76.53 12.19,76.21 11.02,76.21 10.69,75.89 9.8,74.95 8.6,75.42 5.72,75.42 4.92,74.62 3.18,74.62 2.38,75.42 1.9,75.42 1.66,75.32 1.56,75.08 1.56,72.91 1.1,72.91 1.1,75.08 1.34,75.64 1.9,75.88 8.88,75.88 10.05,75.58 9.75,76.75 9.75,78.44 10.21,78.44
GND on IN6 (solid shape): outline of 281 points within 0.2,0 352.5,109.23
GND on IN6 (solid shape): outline of 432 points within 1.1,33.74 351.6,122.8
GND on GND3 (solid shape): 1.89,47.51 1.56,47.51 1.56,31.28 1.1,31.28 1.1,47.67 1.19,47.88 1.4,47.97 1.89,47.97
GND on GND3 (solid shape): 325.62,77.76 326.32,77.76 328.14,75.95 326.33,74.14 326.33,74.13 325.62,74.13 325.62,74.04 325.16,74.04 325.16,74.13 324.96,74.13 324.96,74.3 325.11,74.65 325.46,74.8 326.33,74.8 326.42,74.8 326.51,74.81 327.09,75.09 327.43,75.64 327.42,76.31 327.03,76.86 326.9,76.95 326.75,77.02 326.56,77.08 326.37,77.1 326.32,77.1 325.46,77.1 325.11,77.25 324.96,77.6 324.96,77.69 325.16,77.69 325.16,77.78 325.62,77.78
GND on GND3 (solid shape): 30,107.31 30,107.15 29.85,106.8 29.5,106.65 29,106.65 28.56,106.56 28.18,106.31 28.11,106.23 28.04,106.14 27.98,106.03 27.95,105.98 27.86,105.33 28.14,104.74 28.27,104.61 28.43,104.5 28.49,104.47 28.57,104.43 28.78,104.37 29,104.35 29.5,104.35 29.85,104.2 30,103.85 30,103.69 29.8,103.69 29.8,103.69 29,103.69 27.19,105.5 29,107.31 29.17,107.31
GND on GND3 (solid shape): 246.59,1.6 248.4,3.41 250.21,1.6 250.21,0.66 250.28,0.66 250.28,0.2 250.24,0.2 250.24,0 250.05,0 249.98,0.01 249.91,0.02 249.88,0.03 249.82,0.06 249.76,0.09 249.61,0.27 249.55,0.5 249.55,1.6 249.55,1.67 249.54,1.74 249.36,2.23 248.98,2.59 248.52,2.74 248.04,2.69 247.67,2.49 247.39,2.16 247.36,2.1 247.34,2.04 247.29,1.89 247.26,1.74 247.25,1.69 247.25,1.6 247.25,0.5 247.12,0.16 246.79,0 246.75,0 246.6,0 246.6,0.2 246.43,0.2 246.43,0.66 246.59,0.66
GND on GND3 (solid shape): 345.33,122.6 345.36,122.6 345.36,122.14 345.35,122.14 345.11,122.04 345.01,121.8 345.01,120 343.07,118.19 341.41,120.25 341.41,120.44 341.28,120.44 341.28,120.9 341.49,120.9 341.49,121.1 341.57,121.1 341.92,120.95 342.07,120.6 342.07,120.2 342.05,119.95 342.15,119.53 342.23,119.38 342.35,119.22 342.49,119.09 342.69,118.97 342.91,118.89 343.31,118.86 343.7,118.96 343.98,119.16 344.2,119.42 344.3,119.66 344.35,119.91 344.35,120 344.35,121.8 344.44,122.21 344.69,122.55 344.99,122.73 345.33,122.8
GND on GND1: 341.16,118.31 341.16,121.1 341.57,121.1 341.92,120.95 342.07,120.6 342.07,120.2 343.1,118.85 344.35,120 344.35,121.8 344.64,122.51 345.35,122.8 345.49,122.8 345.49,118.31
GND on GND1: 27.23,103.64 27.23,107.35 30,107.35 30,107.15 29.85,106.8 29.5,106.65 29,106.65 27.85,105.5 29,104.35 29.5,104.35 29.85,104.2 30,103.85 30,103.64
GND on GND1: 246.75,117.55 246.75,121.75 246.95,121.75 247.3,121.6 247.45,121.25 247.45,119.4 248.7,118.15 249.95,119.4 249.95,121.25 250.1,121.6 250.45,121.75 250.5,121.75 250.5,117.55
GND on GND1: 324.96,73.75 324.96,74.3 325.11,74.65 325.46,74.8 326.32,74.8 327.48,75.95 326.32,77.1 325.46,77.1 325.11,77.25 324.96,77.6 324.96,77.86 328.19,77.86 328.19,73.75
GND on GND1: 245.91,0 245.91,3.37 250.13,3.37 250.13,0 250.05,0 249.7,0.15 249.55,0.5 249.55,1.6 248.4,2.75 247.25,1.6 247.25,0.5 247.1,0.15 246.75,0
GND on GND1: outline of 554 points within 0.2,0.2 352.5,122.6
GND on GND2: 27.18,103.81 27.18,107.33 30,107.33 30,107.15 29.85,106.8 29.5,106.65 29,106.65 27.85,105.5 29,104.35 29.5,104.35 29.85,104.2 30,103.85 30,103.81
GND on GND2: 246.69,117.62 246.69,121.75 246.95,121.75 247.3,121.6 247.45,121.25 247.45,119.4 248.7,118.15 249.95,119.4 249.95,121.25 250.1,121.6 250.45,121.75 250.52,121.75 250.52,117.62
GND on GND2: outline of 938 points within 0.2,0.2 352.5,122.6
GND on VCC: 1.4,0.2 1.19,0.29 1.1,0.5 1.1,12.39 1.05,12.66 0.9,12.89 0.29,13.5 0.23,13.59 0.2,13.71 0.2,20.69 0.23,20.81 0.29,20.9 0.9,21.51 1.05,21.74 1.1,22.01 1.1,25.66 5.16,25.66 5.23,25.66 6.73,24.16 6.73,22.51 9.53,19.72 9.53,13.87 11.83,11.57 31.26,11.57 41.38,1.45 41.39,1.45 41.99,0.85 41.99,0.2
GND on VCC: outline of 104 points within 325.16,70.87 352.5,122.6
GND on VCC: 336.3,0.2 336.09,0.29 336,0.5 336,0.8 336,0.88 336.8,1.67 339.73,4.6 339.73,36.35 341.23,37.85 344.15,37.85 346.08,39.78 346.08,58.15 344.78,59.44 332.47,59.44 330.96,60.95 330.96,64.8 331.24,64.52 334.24,64.52 336.78,67.06 337.6,67.06 337.6,67.07 339.1,67.07 339.1,65.9 339.7,65.2 340.47,65.7 350.1,65.7 350.16,65.69 350.21,65.69 350.7,65.42 350.9,64.9 350.9,63.6 351.19,62.89 351.9,62.6 352.31,62.43 352.5,62.03 352.5,62 352.5,34.2 352.32,33.78 351.19,33.31 350.9,32.6 350.9,2 350.37,0.73 349.1,0.2
GND on VCC: outline of 137 points within 43.43,19.31 188.98,121.55
GND on GND3: 246.76,117.76 246.76,121.75 246.95,121.75 247.3,121.6 247.45,121.25 247.45,119.4 248.7,118.15 249.95,119.4 249.95,121.25 250.1,121.6 250.45,121.75 250.5,121.75 250.5,117.76
GND on GND3: outline of 573 points within 0.2,0.2 352.5,122.6
GNDA_CHG on BOTTOM (solid shape): 54.84,18.73 55.27,18.73 55.27,19.26 55.87,19.26 56.39,18.74 56.96,18.74 57.18,18.53 57.18,17.94 57.34,17.77 57.34,15.35 57.56,15.13 57.94,15.13 58.21,14.85 58.28,14.85 58.61,14.53 58.61,12.52 58.42,12.33 57.9,12.33 57.74,12.5 57.74,14.01 57.41,14.33 56.83,14.33 56.11,15.06 53.02,15.06 52.95,15.13 52.95,17.84 54.37,19.26 54.84,19.26
VBATT on BOTTOM (solid shape): 26.49,25.58 26.49,23.57 26.49,23.17 26.33,22.77 26.68,22.51 26.77,22.53 26.86,22.57 26.87,22.57 27.03,22.57 27.14,22.47 27.14,20.03 27.07,19.96 24.79,19.96 24.73,20.02 24.73,20.88 24.59,21.01 24.62,21.04 24.57,21.5 24.12,21.54 24.09,21.52 23.95,21.66 21.16,21.66 21.09,21.73 21.09,22.7 21.26,22.87 21.72,22.87 21.95,23.09 21.95,24.69 22.89,25.64 22.89,25.77 22.93,25.82 26.25,25.82
VCC0V9_LVR_OUT on TOP (solid shape): 22.52,41.34 22.52,39.18 22.51,39.17 22.65,38.76 23.07,38.82 23.14,38.85 23.21,38.82 23.62,38.76 23.77,39.14 23.76,39.17 23.94,39.34 24.31,39.34 24.52,39.56 24.52,40.46 25.34,41.28 26.12,41.28 26.33,41.07 26.33,40.74 26.28,40.66 26.19,40.65 25.98,40.67 25.81,40.56 25.73,40.53 25.66,40.56 25.18,40.58 25.18,40.1 25.18,38.3 25.02,38.13 22.83,38.13 22.83,38.13 22.64,38.13 22.47,37.96 21.94,37.96 21.86,38.04 21.86,41.3 21.95,41.39 22.46,41.39
VCC0V9_LVR_OUT on IN4 (solid shape): 26.37,41.16 26.37,40.77 26.28,40.67 26.04,40.67 26,40.67 25.47,40.67 25.41,40.67 25.27,40.67 25.17,40.58 25.08,40.47 25.08,39.49 25.67,38.89 25.67,38.4 25.24,37.96 24.44,37.96 24.31,38.1 23.93,38.1 23.85,38.18 23.85,38.78 23.92,38.85 24.22,38.85 24.45,39.09 24.45,40.67 24.63,40.85 24.82,40.85 25.21,41.24 26.29,41.24
VCC0V9_SVR on TOP (solid shape): outline of 234 points within 21.53,39.46 26.95,48.71
VCC0V9_SVR on BOTTOM (solid shape): 27.17,42.07 27.17,41.62 27.09,41.54 27.06,41.55 26.93,41.52 26.83,41.43 26.61,41.43 26.45,41.6 26.3,41.6 26.18,41.47 26.18,41.46 26.13,41.41 25.99,41.41 25.83,41.56 25.64,41.56 25.58,41.62 25.58,42.07 25.65,42.13 27.11,42.13
VCC0V9_SVR on BOTTOM (solid shape): 22.25,50.94 22.25,50.79 21.79,50.45 22.25,50.11 22.25,47.76 22.73,47.28 22.73,46.48 22.57,46.31 22.27,46.31 21.78,46.81 21.75,46.83 21.73,46.86 21.27,47.31 21.25,47.32 20.64,47.32 20.64,47.32 20.58,47.32 20.43,47.47 20.43,49.78 20.6,49.94 20.6,51.08 20.65,51.14 22.05,51.14
VCC0V9_SVR on BOTTOM (solid shape): 24.5,41.43 24.55,41.39 24.63,41.3 24.63,39.14 24.44,38.95 24.42,38.95 24.32,38.92 24.24,38.85 24.23,38.83 23.99,38.83 23.96,38.86 23.93,38.9 23.88,38.93 23.88,39.12 24.02,39.26 24.02,39.47 23.83,39.67 23.83,39.8 23.65,39.97 23.65,40.08 23.79,40.37 23.62,40.63 23.62,40.92 23.78,41.09 23.8,41.09 23.85,41.1 23.9,41.12 23.97,41.18 24.01,41.27 24.01,41.29 24.05,41.32 24.07,41.32 24.23,41.34 24.36,41.43
VCC0V9_SVR on IN2 (solid shape): outline of 569 points within 21.14,38.37 26.93,47.36
VCC0V9_SVR on IN4 (solid shape): outline of 465 points within 21.53,39.32 26.99,47.38
VCC3V3_FLASH on IN5 (solid shape): outline of 527 points within 18.73,51.46 22.61,59.93
VCC5V0_SYS on BOTTOM (solid shape): 26.28,57.63 26.71,57.63 26.77,57.6 26.81,57.6 28.45,57.6 28.69,57.36 28.69,53.14 28,52.46 27.5,52.46 27.5,51.17 27.16,51.17 26.97,51.14 26.81,51.05 26.77,51.03 26.46,51.33 26.46,51.47 25.86,52.07 25.86,53.71 26.2,54.04 26.2,54.39 26.28,54.62 26.15,54.83 25.95,55.03 25.95,55.45 26.15,55.65 26.15,56.03 25.79,56.39 25.79,57.24 25.74,57.28 25.74,57.94 25.77,57.97 25.94,57.97
VCCGT_B+ on TOP (solid shape): outline of 644 points within 103.32,68.39 110.43,86.43
VCCGT_B+ on BOTTOM (solid shape): 107.7,85.86 107.7,83.61 107.32,83.23 107.32,80.06 107.25,79.99 107,79.99 106.98,79.97 106.98,78.62 107.27,78.33 107.61,78.33 107.67,78.27 107.67,77.54 107.15,77.02 107.15,76.12 106.62,75.59 106.62,72.78 106.13,72.3 106.13,71.23 106.55,70.81 106.58,70.81 106.65,70.78 106.72,70.76 106.74,70.76 107.51,69.99 107.51,69.98 107.76,69.73 108.97,69.73 109.16,69.54 109.16,68.59 109.03,68.46 106.17,68.46 105.67,68.97 105.67,70.97 105.79,71.1 105.79,72.14 105.16,72.78 105.16,77.22 105.6,77.66 105.86,77.66 106.52,78.33 106.52,79.1 106.53,79.15 106.53,79.66 106.52,79.8 106.34,79.98 105.97,79.98 105.92,80.03 105.92,85.84 105.94,85.86 106,85.9 106.04,85.96 106.06,85.99 107.57,85.99
VCCGT_B+ on IN3 (solid shape): 107.67,85.86 107.67,83.6 107.38,83.31 107.38,80.17 106.78,79.57 106.78,78.62 107.23,78.18 107.75,78.18 107.87,78.05 107.87,77.76 107.09,76.97 107.09,76.01 106.67,75.59 106.67,72.51 106.02,71.87 106.02,71.22 106.55,70.68 106.74,70.68 106.76,70.7 107.54,69.91 108.71,69.91 108.99,69.63 108.99,69 108.46,68.46 106.27,68.46 105.64,69.1 105.64,70.98 105.74,71.08 105.74,71.83 105.08,72.49 105.08,77.12 106.5,78.55 106.5,79.45 105.92,80.03 105.92,85.91 106.02,86.01 107.52,86.01
VCCGT_B+ on IN4 (solid shape): 107.67,85.86 107.67,83.6 107.38,83.31 107.38,80.17 106.78,79.57 106.78,78.62 107.23,78.18 107.75,78.18 107.87,78.05 107.87,77.76 107.09,76.97 107.09,76.01 106.67,75.59 106.67,72.51 106.02,71.87 106.02,71.22 106.55,70.68 106.74,70.68 106.76,70.7 107.54,69.91 108.71,69.91 108.99,69.63 108.99,69 108.46,68.46 106.27,68.46 105.64,69.1 105.64,70.98 105.74,71.08 105.74,71.83 105.08,72.49 105.08,77.12 106.5,78.55 106.5,79.45 105.92,80.03 105.92,85.91 106.02,86.01 107.52,86.01
VCCGT_B+ on IN6 (solid shape): 107.67,85.86 107.67,83.6 107.38,83.31 107.38,80.17 106.78,79.57 106.78,78.62 107.23,78.18 107.75,78.18 107.87,78.05 107.87,77.76 107.09,76.97 107.09,76.01 106.67,75.59 106.67,72.51 106.02,71.87 106.02,71.22 106.55,70.68 106.74,70.68 106.76,70.7 107.54,69.91 108.71,69.91 108.99,69.63 108.99,69 108.46,68.46 106.27,68.46 105.64,69.1 105.64,70.98 105.74,71.08 105.74,71.83 105.08,72.49 105.08,77.12 106.5,78.55 106.5,79.45 105.92,80.03 105.92,85.91 106.02,86.01 107.52,86.01
+AC_IN on BOTTOM (solid shape): 15.75,63.76 15.75,62.49 15.56,62.3 15.56,60.94 15.01,60.4 12.43,60.4 12.14,60.68 12.14,61.81 12.83,62.49 13.84,62.49 14.03,62.68 14.03,63.76 14.1,63.83 15.69,63.83
+AC_IN on BOTTOM (solid shape): 13.23,33.66 13.32,33.61 13.31,33.5 13.47,33 13.91,33.29 13.94,33.36 14.01,33.38 14.42,33.38 14.73,33.07 14.73,32.52 14.48,32.27 13.97,32.27 13.78,32.08 13.78,31.31 13.72,31.25 13.72,30.87 13.92,30.67 14.09,30.67 14.27,30.49 14.42,30.49 14.64,30.26 14.64,29.41 14.49,29.27 12.53,29.27 12.35,29.44 12.35,29.98 11.88,30.46 11.88,31.21 11.88,31.22 11.91,31.35 11.88,31.48 11.88,31.5 11.88,31.69 12.11,31.92 12.6,31.92 12.68,32 12.68,33.45 12.89,33.66
+AC_IN on IN1: outline of 172 points within 11.67,29.28 32.02,64.54
+DC_IN on BOTTOM (solid shape): 22.54,89.48 22.54,87.64 22.35,87.45 22.1,87.45 21.78,87.77 21.78,89.51 21.88,89.61 22.42,89.61
+DC_IN on BOTTOM (solid shape): 21.78,28.96 21.78,27.5 21.4,27.12 21.4,24.94 21.2,24.75 19.46,24.75 19.31,24.9 19.31,25.22 18.99,25.54 18.99,26.3 19.31,26.62 19.31,26.81 19.43,26.93 19.84,26.93 20.1,27.19 20.1,28.98 20.24,29.13 21.62,29.13
+DC_IN on BOTTOM (solid shape): 18.26,79.25 18.26,72.14 18.48,71.92 18.48,71.26 18.19,70.97 17.34,70.97 17.15,70.78 17.15,70.43 16.96,70.24 15.5,70.24 15.18,70.56 15.18,71.45 14.92,71.7 14.67,71.7 14.48,71.89 14.48,79.44 16.74,79.44 16.74,79.38 16.75,79.33 16.77,79.28 16.8,79.23 16.83,79.19 16.87,79.16 16.92,79.13 16.96,79.1 17.02,79.09 17.07,79.08 17.12,79.08 17.17,79.09 17.23,79.1 17.27,79.13 17.32,79.16 17.36,79.19 17.39,79.23 17.42,79.28 17.44,79.33 17.45,79.38 17.45,79.44 17.45,79.49 17.44,79.54 17.42,79.59 17.39,79.64 17.36,79.68 17.32,79.71 17.27,79.74 17.23,79.77 17.17,79.78 17.12,79.79 17.07,79.79 17.02,79.78 16.96,79.77 16.92,79.74 16.87,79.71 16.83,79.68 16.8,79.64 16.77,79.59 16.75,79.54 16.74,79.49 16.74,79.44 14.48,79.44 14.48,79.59 14.99,80.1 17.41,80.1
+DC_IN on VCC: 15.47,16.65 14.23,17.89 14.23,32.42 17.78,35.97 17.78,66.03 14.99,68.82 14.99,72.42 15.85,73.29 27.33,73.29 27.33,68.99 27.7,67.94 28.63,67.36 28.63,65.7 30.86,53.89 37.24,43.72 39.94,41.08 42.93,38.79 42.93,28.33 22.12,28.33 21.21,27.42 21.21,21.87 23.75,19.33 23.75,17.26 23.14,16.65
+DC_IN_SS on BOTTOM (solid shape): outline of 94 points within 22.01,26.19 27.6,29.81
+EDPVDD on TOP (solid shape): 55.3,33.16 65.3,33.16 65.48,32.99 65.48,32.1 65.36,31.97 65.23,32.05 64.74,31.96 64.77,31.45 64.83,31.38 64.83,30.17 64.62,29.96 63.77,29.96 63.66,30.07 63.66,31.22 63.64,31.31 63.7,31.37 63.85,31.9 63.3,31.95 63.23,31.92 63.16,31.95 62.74,32 62.57,31.61 62.55,31.52 62.47,31.48 61.49,31.48 61.41,31.57 61.41,31.79 60.98,32.21 59.59,32.21 59.44,32.36 54.01,32.36 54.01,32.36 53.18,32.36 52.36,31.54 51,31.54 48.22,28.76 47.42,28.76 47.3,28.87 46.46,28.87 46.35,28.76 45.67,28.76 45.58,28.85 45.58,30.12 45.78,30.33 48.15,30.33 50.5,32.68 51.38,32.68 52.19,33.5 54.97,33.5
+EDPVDD on BOTTOM (solid shape): 62.69,33.31 62.69,32.28 62.51,32.1 62.51,31.53 62.4,31.42 61.58,31.42 61.43,31.56 61.43,33.3 61.52,33.38 62.62,33.38
+FB_PLLAVDD on TOP (solid shape): 192.04,85.25 192.04,84.11 192.85,83.3 192.85,82.37 192.71,82.23 191.39,82.23 191.39,84.06 190.75,84.69 190.75,85.21 190.88,85.33 191.96,85.33
+FB_PLLAVDD on IN1 (solid shape): outline of 659 points within 212.68,71.13 217,79.26
+FB_PLLAVDD on IN6 (solid shape): outline of 1676 points within 190.5,77.05 215.98,84.21
+GPU_CORE on TOP (solid shape): 182.26,110.94 182.26,110.36 182.56,110.05 183.2,110.05 184.41,108.85 184.41,105.1 185.14,104.37 185.14,100.82 184.21,99.89 184.21,98.37 184.41,98.18 187.3,98.18 187.61,97.65 187.91,98.19 188.34,98.62 188.34,100.21 188.6,100.47 189.61,100.47 189.8,100.28 189.8,95.07 188.34,93.61 181.8,93.61 180.47,94.94 180.47,110.31 180.47,110.31 180.47,111.09 180.57,111.18 182.02,111.18
+GPU_CORE on TOP (solid shape): outline of 867 points within 203.07,60.65 216.22,78.18
+GPU_CORE on BOTTOM (solid shape): 184.66,109.48 184.66,104.5 184.86,104.3 186.63,104.3 187.24,103.69 187.24,101.55 187.19,101.49 184.54,101.49 184.34,101.29 184.34,96.9 184.44,96.8 188.75,96.8 189.17,96.39 189.17,94.4 188.41,93.64 182.88,93.64 182.58,93.34 179.76,93.34 179.61,93.48 179.61,96.25 180.02,96.66 180.02,110.05 180.53,110.56 183.58,110.56
+GPU_CORE on BOTTOM (solid shape): outline of 3941 points within 201.34,53.84 215.59,78.13
+GPU_CORE on IN1 (solid shape): outline of 1989 points within 177.28,92.99 189.42,111.85
+GPU_CORE on IN2 (solid shape): outline of 3066 points within 174.41,93.23 192.42,111.47
+GPU_CORE on IN4 (solid shape): outline of 15665 points within 180.15,59 218.89,110.5
+GPU_CORE on IN5 (solid shape): outline of 9183 points within 178.82,53.09 213.79,110.69
+GPU_CORE on GND2: 173.49,121.55 203.71,121.55 203.71,96.87 203.71,96.87 210.02,90.56 222.22,90.56 226.89,85.89 226.89,53.64 226.85,53.6 189.49,53.6 189.48,53.61 189.48,59.17 188.2,60.45 175.76,60.45 175.51,60.69 175.51,84.67 173.49,86.69 ; 1 cut-out
+GPU_CORE on VCC: 189.49,53.6 189.49,59.17 188.19,60.46 175.75,60.46 175.52,60.69 175.52,84.7 173.48,86.73 173.48,93.46 172.25,94.69 168.76,94.69 167.2,96.25 167.2,105.16 167.24,105.16 167.62,105.55 169.21,105.55 170.05,106.39 170.05,119.73 171.79,119.73 172.43,119.86 172.97,120.22 173.33,120.58 203.71,120.58 203.71,96.87 210.02,90.56 222.21,90.56 226.89,85.88 226.89,53.6 ; 2 cut-outs
+GPU_CORE_VDDS on TOP (solid shape): 206.41,76.1 206.57,76.1 206.69,75.99 206.69,75.6 206.52,75.43 205.24,75.43 205.08,75.6 205.08,76.83 205.19,76.94 205.57,76.94
+GPU_CORE_VDDS on TOP (solid shape): 211.54,67.86 211.54,66.72 211.43,66.61 211.11,66.61 210.19,67.53 210.19,67.89 210.31,68.01 211.39,68.01
+GPU_CORE_VDDS on TOP (solid shape): 209.24,72.51 209.24,71.71 209.55,71.39 209.55,70.58 209.51,70.54 208.8,70.54 208.74,70.6 208.74,71.06 208.11,71.69 208.11,72.05 208.66,72.59 209.16,72.59
+GPU_CORE_VDDS on TOP (solid shape): 203.5,74.97 204.27,74.97 204.55,74.69 204.55,74.23 204.84,73.94 204.84,73.55 204.77,73.48 204.3,73.48 203.15,74.63 203.15,74.96 203.23,75.03 203.44,75.03
+GPU_CORE_VDDS on TOP (solid shape): 211.53,77.02 211.91,76.65 211.91,75.58 211.83,75.51 210.2,75.51 210.09,75.61 210.09,75.97 210.2,76.08 210.71,76.08 211.1,76.47 211.1,76.89 211.22,77.01 211.24,77.01 211.25,77.02 211.53,77.02
+GPU_CORE_VDDS on TOP (solid shape): 204.66,69.95 204.66,69.56 204.24,69.14 204.24,68.87 203.77,68.4 203.26,68.4 203.14,68.53 203.14,68.72 203.49,69.07 203.49,69.53 203.55,69.58 203.77,69.58 204.28,70.09 204.52,70.09
+GPU_CORE_VDDS on TOP (solid shape): 213.82,75.1 213.82,74.66 213.16,73.99 213.1,73.99 213.09,74 212.99,74 212.55,73.56 212.1,73.56 211.9,73.75 211.9,74.1 211.99,74.18 212.19,74.18 212.46,74.45 212.46,75.16 212.63,75.33 213.6,75.33
+GPU_CORE_VDDS on TOP (solid shape): 212.41,69.86 212.41,69.73 212.58,69.56 212.87,69.56 212.87,69.56 212.96,69.56 213.62,68.91 213.62,68.65 213.49,68.53 213.3,68.53 213.04,68.78 212.72,68.78 211.96,69.54 211.96,69.99 212.03,70.05 212.22,70.05
+GPU_CORE_VDDS on TOP (solid shape): 196.22,109.86 196.22,109.1 196.6,108.72 196.66,108.72 196.8,108.68 196.94,108.72 197.36,108.72 197.74,108.34 197.74,106.75 198.22,106.28 198.22,105.94 198.21,105.88 198.22,105.81 198.22,103.48 197.93,103.2 197.93,101.99 198.06,101.86 198.06,99.39 197.8,99.13 195.45,99.13 194.31,97.99 194.31,97.29 193.49,96.47 190.82,96.47 190.56,96.72 190.56,100.15 190.76,100.34 192.72,100.34 193.04,100.66 193.04,103.89 193.36,104.21 194.88,104.21 195.2,104.53 195.2,109.93 195.33,110.05 196.03,110.05
+GPU_CORE_VDDS on BOTTOM (solid shape): 198.82,109.93 198.82,104.09 197.87,103.13 197.87,102.37 197.99,102.24 197.99,96.72 197.74,96.47 190.69,96.47 190.37,96.78 190.37,97.99 190.5,98.12 192.47,98.12 192.6,98.24 192.6,102.75 193.61,103.77 194.44,103.77 195.33,104.66 195.33,110.24 195.58,110.5 198.25,110.5
+GPU_CORE_VDDS on IN1 (solid shape): 198.82,109.9 198.82,104.07 198.07,103.31 198.07,103.27 197.96,103.01 198.07,102.74 198.07,97.96 196.53,96.41 190.71,96.41 190.52,96.61 190.52,101.87 190.9,102.25 192.05,102.25 193.59,103.79 194.45,103.79 195.31,104.66 195.31,110.24 195.56,110.49 198.24,110.49
+GPU_CORE_VDDS on IN2 (solid shape): 198.63,109.45 198.63,105.94 198.54,105.86 198.54,103.86 197.86,103.17 197.86,101.93 197.68,101.75 197.68,97.7 196.7,96.73 192.86,96.73 192.71,96.57 192.61,96.57 192.55,96.62 192.55,102.72 193.57,103.74 194.41,103.74 195.3,104.64 195.3,110.22 195.55,110.47 197.61,110.47
+GPU_CORE_VDDS on IN2 (solid shape): outline of 3192 points within 202.76,66.18 214.12,78.3
+GPU_CORE_VDDS on IN3 (solid shape): outline of 15681 points within 180.66,59 214.57,110.05
+GPU_CORE_VDDS on IN6 (solid shape): outline of 10970 points within 180.66,61.6 214.56,108.72
+INV_PWR_SRC on BOTTOM (solid shape): outline of 179 points within 47.06,23.92 54.1,33.41
+NVVDDS_B+ on TOP (solid shape): 185.48,111.26 185.48,110.63 185.61,110.5 189.04,110.5 189.43,110.11 189.46,110.08 189.49,110.05 189.49,109.67 189.29,109.48 187.26,109.48 186.75,108.97 185.1,108.97 183.71,110.37 182.56,110.37 182.44,110.5 182.44,111.39 182.56,111.51 185.23,111.51
+NVVDDS_B+ on BOTTOM (solid shape): 189.42,110.02 189.42,109.61 189.17,109.36 186.88,109.36 186.56,109.04 185.1,109.04 184.98,109.17 184.98,110.24 185.29,110.56 188.88,110.56
+ODR_PWR on TOP (solid shape): 327.92,51.25 329.12,51.25 329.5,50.87 330.96,50.87 331.15,50.68 331.15,49.67 330.77,49.28 327.72,49.28 326.96,50.05 326.96,51.29 327.09,51.41 327.76,51.41
+ODR_PWR on IN3 (solid shape): 328.24,51.12 328.24,49.17 328.15,49.08 327.11,49.08 326.96,49.22 326.96,51.28 327.1,51.41 327.94,51.41
+ODR_PWR on IN3 (solid shape): outline of 211 points within 334.2,36.33 337.63,39.45
+PEX_PLL_HVDD on TOP (solid shape): 200.22,66.98 200.22,66.51 200.09,66.38 199.85,66.38 199.58,66.11 199.58,64.08 199.33,63.83 197.64,63.83 197.55,63.91 197.55,64.7 197.68,64.83 198.49,64.83 198.63,64.97 198.63,65.1 198.64,65.19 198.63,65.27 198.63,66.37 198.69,66.43 199.21,66.43 199.39,66.61 199.39,66.75 199.74,67.09 200.11,67.09
+PEX_PLL_VDD on BOTTOM (solid shape): 203.2,106.37 203.2,105.8 203.2,105.8 203.2,103.02 202.8,102.62 201.74,102.62 201.61,102.75 201.61,103.58 201.36,103.83 201.36,106.56 201.42,106.63 202.95,106.63
+PEX_PLL_VDD on IN3 (solid shape): outline of 505 points within 200.52,80.03 203.99,84.58
+PWR_SRC_AC on BOTTOM (solid shape): 53.49,10.04 54.12,10.04 54.62,9.53 55.74,9.53 55.9,9.38 55.9,7.08 55.88,7.06 55.42,7.06 55.41,7.07 55.37,7.07 55.37,7.64 55.02,8 54.66,7.64 54.66,7.13 54.6,7.07 54.13,7.07 53.73,7.47 51.98,7.47 51.88,7.57 51.88,10.17 52.16,10.45 53.09,10.45
+RTCVCC on TOP (solid shape): 96.56,5.33 96.56,4.17 96.43,4.05 95.94,4.05 95.78,4.2 95.78,4.35 95.68,4.45 94.82,4.45 94.64,4.28 94.64,4.1 94.49,3.95 93.9,3.95 93.75,4.1 93.75,4.5 94.01,4.76 94.36,4.76 94.62,5.01 94.62,5.2 94.87,5.46 96.43,5.46
+RTCVCC on IN5 (solid shape): 99.57,6.54 99.57,5.95 99.19,5.57 98.12,5.57 97.51,6.18 98.06,6.18 98.06,6.13 98.08,6.08 98.09,6.03 98.12,5.98 98.15,5.94 98.19,5.91 98.24,5.88 98.29,5.86 98.34,5.85 98.39,5.84 98.44,5.84 98.49,5.85 98.54,5.87 98.59,5.89 98.63,5.93 98.66,5.96 98.69,6.01 98.72,6.05 98.73,6.1 98.74,6.15 98.74,6.21 98.73,6.26 98.72,6.31 98.69,6.36 98.66,6.4 98.63,6.44 98.59,6.47 98.54,6.49 98.49,6.51 98.44,6.52 98.39,6.52 98.34,6.52 98.29,6.5 98.24,6.48 98.19,6.45 98.15,6.42 98.12,6.38 98.09,6.33 98.08,6.28 98.06,6.23 98.06,6.18 97.51,6.18 97.41,6.28 97.41,6.61 97.61,6.82 99.29,6.82
+RTCVCC on IN5 (solid shape): outline of 523 points within 301.3,12.16 312.56,14.23
+SD_VDD2 on BOTTOM (solid shape): 347.91,49.35 347.91,46.85 347.77,46.71 346.65,46.71 346.48,46.87 346.48,47.14 347.17,47.82 347.17,49.5 347.77,49.5
+SDC_IN on TOP (solid shape): 24.43,27.21 24.43,26 25.46,24.96 27.56,24.96 27.69,24.84 27.69,24.2 27.56,24.08 24.96,24.08 24.83,23.95 24.83,21.79 24.64,21.6 22.58,21.6 22.44,21.75 22.44,24.37 21.59,25.22 21.59,27.12 21.78,27.31 24.33,27.31
+SDC_IN on BOTTOM (solid shape): 54.66,5.56 55.02,5.2 55.37,5.56 55.37,6.11 55.94,6.11 56.01,6.03 55.94,5.73 56.14,5.49 56.14,4.31 55.97,4.01 56.14,3.71 56.14,3.06 55.3,2.23 54.89,2.23 54.67,2.01 54.67,1.69 54.75,1.61 54.74,1.52 54.65,1.47 52.39,1.47 52.26,1.6 52.26,2 52.35,2.09 52.35,3.91 52.79,4.35 54,4.35 54,5.97 54.13,6.11 54.66,6.11
+SDC_IN on VCC: 42.38,1.17 31.37,12.18 31.37,13.58 29.82,15.12 26.4,15.12 24.26,17.26 24.26,19.55 21.72,22.09 21.72,27.21 22.33,27.82 46.5,27.82 48.39,25.94 48.39,17.56 50.31,15.63 56.66,15.63 57.21,15.08 57.21,1.17
+VCHGR on TOP (solid shape): 30.95,20.99 30.95,19.33 30.77,19.14 30.77,18.66 30.25,18.14 29.55,18.14 29.47,18.23 29.47,21 29.59,21.12 30.82,21.12
+VCHGR on BOTTOM (solid shape): outline of 145 points within 26.64,17.38 35.75,25.95
+VDISPLAY_VCC on TOP (solid shape): outline of 88 points within 13.82,88.52 18.28,92.91
+VGA_B+ on TOP (solid shape): outline of 178 points within 161.74,96.08 169.23,107.13
+VGA_B+ on BOTTOM (solid shape): 168.4,100.34 168.4,98.69 169.1,97.99 169.1,96.4 168.97,96.27 166.69,96.27 166.5,96.47 166.5,100.4 166.75,100.66 168.09,100.66
+VGA_B+ on BOTTOM (solid shape): 165.89,106.78 167.42,106.78 167.64,106.56 168.91,106.56 169.17,106.31 169.17,104.72 168.69,104.24 166.85,104.24 165.99,105.1 162.05,105.1 161.74,105.42 161.74,106.63 162.24,107.13 165.55,107.13
+VGA_B+ on IN3 (solid shape): outline of 333 points within 161.74,96.53 168.59,106.5
+VLDOIN_1.2V on BOTTOM (solid shape): 285.31,30.17 287.2,30.17 287.29,30.08 287.29,29.96 287.25,29.92 286.07,29.92 286.07,29.92 283.97,29.92 283.97,30.33 283.4,30.33 283.4,30.52 283.94,30.52 283.94,30.52 283.97,30.52 283.97,30.93 284.04,31 284.48,31
+XS_PLLVDD on TOP (solid shape): outline of 87 points within 203.02,62.24 204.92,64.72
B+ on TOP (solid shape): 105.71,58.06 105.71,56.95 106.05,56.62 106.05,56.02 105.73,55.7 104.84,55.7 104.52,56.02 104.52,57.98 104.65,58.11 105.67,58.11
B+ on TOP (solid shape): 105.32,68.73 105.32,68.32 105.41,68.24 106.3,68.24 106.3,67.71 107,67.71 107,68.24 107.5,68.24 107.5,67.71 108.2,67.71 108.2,68.24 109.19,68.24 109.35,68.08 109.35,66.75 109.09,66.49 104.08,66.49 103.95,66.62 103.95,68.79 104.1,68.94 105.11,68.94
B+ on TOP (solid shape): 185.87,117.99 185.87,114.82 186.18,114.5 186.18,113.74 185.92,113.47 185.8,113.47 185.8,113.36 185.61,113.17 185.61,111.83 185.48,111.71 182.56,111.71 182.43,111.84 182.43,113.29 182.56,113.42 183.74,113.42 184.09,113.77 184.09,113.8 184.12,113.81 184.32,114.13 184.12,114.45 184.09,114.46 184.09,115.1 184.09,115.11 184.13,115.26 184.09,115.41 184.09,115.42 184.09,117.6 184.6,118.12 185.74,118.12
B+ on TOP (solid shape): 15.68,16.64 15.68,13.84 15.38,13.55 12.74,13.55 12.54,13.75 12.54,15.08 12.27,15.35 12.12,15.35 12.11,15.35 12,15.38 11.89,15.35 11.88,15.35 11.32,15.35 11.28,15.36 11.24,15.37 11.16,15.44 11.18,15.54 10.89,16.11 10.63,15.52 10.65,15.41 10.56,15.35 10.52,15.35 10.51,15.35 10.4,15.38 10.29,15.35 10.28,15.35 9.72,15.35 9.71,15.35 9.6,15.38 9.49,15.35 9.48,15.35 8.92,15.35 8.91,15.35 8.8,15.38 8.69,15.35 8.68,15.35 8.58,15.35 8.5,15.43 8.5,16.79 8.71,17 15.32,17
B+ on TOP (solid shape): outline of 150 points within 314.11,8.84 319.33,18.8
B+ on TOP (solid shape): outline of 195 points within 33.31,13.92 45.98,23.14
B+ on BOTTOM (solid shape): 138.46,11.45 138.46,9.87 138.27,9.68 136.37,9.68 136.24,9.81 136.24,11.27 136.65,11.67 138.24,11.67
B+ on BOTTOM (solid shape): 247.02,115.45 247.02,114.18 246.83,113.99 245.3,113.99 245.17,114.12 245.17,115.39 245.37,115.58 246.89,115.58
B+ on BOTTOM (solid shape): 253.47,21.75 253.47,19.22 253.24,19 252.39,19 252.26,19.12 252.26,21.83 252.54,22.11 253.11,22.11
B+ on BOTTOM (solid shape): 106.05,68.08 108.84,68.08 109.03,67.89 109.03,66.62 108.84,66.43 104.01,66.43 103.82,66.62 103.82,68.97 104.01,69.16 104.97,69.16
B+ on BOTTOM (solid shape): 164.97,109.93 164.97,109.32 165.29,109 165.51,109 165.55,108.97 165.55,107.58 165.29,107.32 162.04,107.32 161.83,107.54 161.83,110.12 161.95,110.24 164.66,110.24
B+ on BOTTOM (solid shape): 186.12,119.07 186.12,116.72 185.55,116.15 185.55,114.75 185.23,114.44 184.47,114.44 184.28,114.63 184.28,118.36 184.74,118.82 184.74,119.21 184.85,119.33 185.87,119.33
B+ on BOTTOM (solid shape): 135.08,107.86 135.08,105.68 134.65,105.24 127.52,105.24 127.19,105.57 127.19,106.93 127.62,107.36 128.36,107.36 128.36,107.88 128.86,107.88 128.86,107.36 129.56,107.36 129.56,107.88 130.06,107.88 130.06,107.36 131.42,107.36 132.16,108.1 134.84,108.1
B+ on BOTTOM (solid shape): 110.91,100.75 111.02,100.69 111.14,100.68 111.38,100.44 111.38,99.09 110.87,98.59 110.28,98.59 110.24,98.63 110.24,99.12 109.53,99.12 109.53,98.74 109.04,98.74 109.04,99.12 108.33,99.12 108.33,98.63 108.31,98.6 107.48,98.6 106.3,97.42 106.3,96.72 106.06,96.48 104.97,96.48 104.78,96.67 104.78,99.2 106.33,100.75
B+ on BOTTOM (solid shape): 280.1,32.41 280.1,26.03 279.97,25.9 278.88,25.9 278.7,26.08 278.7,28.2 279.02,28.52 279.02,28.53 279.37,28.88 279.37,29.86 279.32,29.92 278.84,29.92 278.84,29.92 278.84,30.37 278.84,30.37 279.37,30.37 279.39,30.38 279.39,31.11 279.37,31.12 278.84,31.12 278.84,31.57 279.37,31.57 279.39,31.58 279.39,32.48 279.49,32.58 279.92,32.58
B+ on BOTTOM (solid shape): outline of 193 points within 31.43,8.96 48.55,25.41
B+ on IN3 (solid shape): 244.92,115.58 245.62,115.58 245.87,115.32 245.87,114.12 245.75,113.99 244.86,113.99 243.65,115.2 243.65,115.52 244.1,115.96 244.54,115.96
B+ on IN3 (solid shape): outline of 1211 points within 8.29,11.88 39.43,23.53
B+ on IN3 (solid shape): outline of 8566 points within 127.52,105.03 187.77,120.32
B+ on IN4 (solid shape): outline of 7109 points within 31.83,15.63 113.06,50.15
B+ on IN5 (solid shape): outline of 21986 points within 32.83,13.98 187.02,120.48
B+ on IN6 (solid shape): 254.26,22.68 254.26,21.85 253.75,21.34 253.75,20.58 253.49,20.33 252.86,20.33 252.48,20.71 252.48,21.98 253.24,22.74 254.19,22.74
B+ on IN6 (solid shape): 280.04,26.3 280.04,25.79 279.66,25.41 279.08,25.41 278.77,25.09 278.58,25.09 278,25.66 278,25.79 278.64,26.42 279.91,26.42
B+ on VCC: outline of 288 points within 108.71,14.11 318.64,52.59
B++ on TOP (solid shape): 332.8,20.39 332.8,17.98 332.74,17.92 332.11,17.92 331.34,17.15 331.34,12.84 330.58,12.07 321.95,12.07 321.25,11.38 321.25,8.77 321.06,8.58 319.15,8.58 318.96,8.77 318.96,8.78 318.93,8.81 318.93,9.85 319.46,9.85 319.46,10.56 318.93,10.56 318.93,11.05 319.46,11.05 319.46,11.76 318.93,11.76 318.93,13.09 319.47,13.63 319.47,17.98 320.49,19 329.31,19 329.95,19.63 329.95,20.39 330.07,20.52 332.68,20.52
B+_0.95V on TOP (solid shape): 107.51,59.32 107.51,57.16 107.7,56.97 107.7,56.46 107.57,56.33 106.62,56.33 105.86,57.1 105.86,58.65 105.68,58.83 104.63,58.83 104.5,58.96 104.5,60.14 104.69,60.33 106.49,60.33
B+_0.95V on BOTTOM (solid shape): 107.76,61.75 107.76,59.7 107.51,59.44 107.51,57.27 107.74,57.03 107.74,56.99 107.75,56.98 107.75,56.4 107.51,56.16 107.51,55.95 107.38,55.83 106.55,55.83 106.36,56.02 106.36,56.97 105.91,57.43 105.91,60.82 106.86,61.78 107.73,61.78
B+_1V on BOTTOM (solid shape): 135.36,11.14 135.36,10 135.83,9.53 135.83,8.92 137.02,7.73 137.02,7.03 136.69,6.7 135.93,6.7 135.64,6.99 134.72,6.99 134.11,6.39 134.11,5.6 134.11,5.54 134.07,5.49 133.17,5.49 133.12,5.54 133.12,7.51 133.43,7.82 133.86,7.82 134.29,8.25 134.29,11.12 134.37,11.19 135.31,11.19
B+_1VSP on TOP (solid shape): 244.86,118.5 244.86,117.23 243.71,116.09 243.71,115.64 243.49,115.42 242.73,115.42 242.57,115.26 242.57,115.13 242.44,115.01 242.13,115.01 241.94,115.2 241.94,116.09 243.27,117.42 243.27,118.5 243.33,118.56 244.79,118.56
B+_1VSP on BOTTOM (solid shape): 244.98,118.5 244.98,114.37 244.79,114.18 243.97,114.18 243.78,114.37 243.78,115.2 243.52,115.45 242.7,115.45 242.51,115.26 242.51,114.56 242.32,114.37 241.11,114.37 241.05,114.44 241.05,116.15 241.24,116.34 242.44,116.34 243.27,117.17 243.27,118.63 243.33,118.69 244.79,118.69
BATBTN# on BOTTOM (solid shape): 350.58,113.36 349.57,113.36 349.57,115.01 350.58,115.01
BATBTN# on BOTTOM (solid shape): 350.58,109.48 349.57,109.48 349.57,111.13 350.58,111.13
BATDRV# on BOTTOM (solid shape): 29.12,19.85 29.12,19.54 28.98,19.4 28.8,19.4 28.25,19.95 27.73,19.95 27.6,20.07 27.6,20.25 27.74,20.39 28.58,20.39
BATT++ on BOTTOM (solid shape): 24.07,20.77 24.32,20.77 24.58,20.52 24.58,19.96 24.64,19.9 24.64,19.85 24.7,19.85 24.75,19.79 27.56,19.79 27.66,19.69 28.14,19.69 28.78,19.06 28.78,11.07 28.7,10.99 23.56,10.99 23.37,11.18 23.37,17.98 22.92,18.42 21.27,18.42 21.08,18.61 21.08,20.7 21.13,20.74 22.66,20.74 22.73,20.73 22.81,20.74 22.99,20.74 23.15,20.9 23.94,20.9
BOOT_1.2V on BOTTOM (solid shape): 287.29,29.68 287.29,29.59 287.23,29.54 285.43,29.54 284.87,28.97 284.87,28.21 284.82,28.16 284.16,28.16 284.11,28.21 284.11,29.36 284.5,29.74 287.23,29.74
BQ24777_REGN on TOP (solid shape): 51.75,20.84 51.75,19.27 51.75,19.27 51.75,19.07 51.46,18.78 51.46,18.28 52.13,17.6 53.34,17.6 53.47,17.47 53.4,17.41 51.88,17.41 51.12,18.17 50.62,18.17 50.52,18.27 50.52,19.59 50.42,19.69 50.42,20.91 50.48,20.97 51.62,20.97
BST1_3V on TOP (solid shape): 342.64,24.52 342.64,23.62 342.52,23.51 340.73,23.51 340.62,23.62 340.62,24.52 340.68,24.58 342.58,24.58
BST1_5V on TOP (solid shape): 344.55,16.77 344.49,16.71 343.03,16.71 342.96,16.77 342.96,17.66 344.55,17.66
BST1_NVVDD on BOTTOM (solid shape): 167.09,113.46 165.72,112.09 165.18,112.09 165.08,111.98 164.5,111.98 164.5,111.99 164.27,111.99 164.22,112.04 164.22,112.89 164.28,112.94 165.1,112.94 165.15,112.89 165.63,112.89 166.18,113.43 166.18,113.61 166.25,113.68 166.66,113.68 166.73,113.69 166.81,113.71 167.09,113.71
BST1_NVVDDS on BOTTOM (solid shape): 183.05,113.14 183.05,112.28 182.56,111.8 182.56,111.2 182.25,110.88 181.48,110.88 181.36,111.01 181.36,111.96 181.48,112.08 181.5,112.09 182.18,112.09 182.44,112.35 182.44,112.85 181.93,113.37 181.75,113.37 181.68,113.44 181.68,113.85 181.67,113.92 181.65,114 181.65,114.22 181.71,114.28 181.9,114.28
BST2_NVVDD on BOTTOM (solid shape): 170.22,113.67 170.22,113.44 170.87,112.78 171.84,112.78 172.02,112.59 172.02,111.58 171.96,111.51 171.17,111.51 169.3,113.38 169.3,113.66 169.4,113.75 170.14,113.75
BST_0.95V on TOP (solid shape): 107.7,62.42 107.7,61.86 107.57,61.73 106.7,61.73 106.36,62.07 106.36,62.94 106.49,63.06 107.05,63.06
BST_3V on TOP (solid shape): 343.99,24.56 343.99,23.64 343.85,23.5 343.85,22.74 344.11,22.49 344.11,21.34 344.04,21.28 343.96,21.28 343.88,21.36 343.88,22.34 343.26,22.96 343.26,24.49 343.35,24.58 343.97,24.58
BST_5V on TOP (solid shape): 344.1,19.28 344.1,18.04 343.85,17.79 342.9,17.79 342.9,17.79 342.71,17.79 342.52,17.6 342.52,16.84 342.39,16.71 341.63,16.71 341.5,16.84 341.5,17.73 341.95,18.17 343.72,18.17 343.89,18.34 343.89,19.28 343.93,19.31 344.07,19.31
BST_+1.35VRUN on TOP (solid shape): 196.6,115.26 196.6,114.63 196.85,114.37 197.3,114.37 197.36,114.31 197.36,113.67 197.17,113.48 196.34,113.48 196.03,113.8 196.03,115.2 196.15,115.32 196.53,115.32
CHAGER_SRC on TOP (solid shape): 47.79,17.99 47.79,13.5 50.04,11.25 50.04,10.82 50.47,10.82 51.56,9.72 51.56,7.63 52.39,6.8 53.15,6.8 53.28,6.68 53.28,6.17 53.21,6.1 48.9,6.1 48.9,6.55 48.2,7.25 44.26,7.25 44.01,7.5 44.01,17.79 44.45,18.23 47.55,18.23
CHAGER_SRC on BOTTOM (solid shape): 49.47,17.85 49.47,11.82 49.81,11.48 49.81,10.96 49.98,10.79 50.5,10.79 51.56,9.72 51.56,7.63 52.17,7.02 53.78,7.02 53.83,6.97 53.83,6.21 53.72,6.1 48.95,6.1 48.9,6.16 48.9,6.55 48.2,7.25 44.26,7.25 44.01,7.5 44.01,17.79 44.45,18.23 49.09,18.23
CHAGER_SRC on IN2 (solid shape): 49.47,17.85 49.47,11.82 51.56,9.72 51.56,6.96 51.16,6.55 48.9,6.55 48.2,7.25 44.26,7.25 44.01,7.5 44.01,17.79 44.45,18.23 49.09,18.23
CHAGER_SRC on IN3 (solid shape): 49.47,17.85 49.47,11.82 51.56,9.72 51.56,6.66 51.45,6.55 48.9,6.55 48.2,7.25 44.26,7.25 44.01,7.5 44.01,17.79 44.45,18.23 49.09,18.23
CHAGER_SRC on IN6 (solid shape): 49.47,17.85 49.47,11.82 51.56,9.72 51.56,6.73 51.39,6.55 48.9,6.55 48.2,7.25 44.26,7.25 44.01,7.5 44.01,17.79 44.45,18.23 49.09,18.23
CHG_BTS on TOP (solid shape): 51.88,17.22 53.4,17.22 53.47,17.15 53.47,17.09 53.4,17.03 50.55,17.03 50.42,17.15 50.42,17.92 50.55,18.04 51.06,18.04
CHG_BTS_C on TOP (solid shape): 49.82,17.91 49.82,15.88 49.69,15.76 49.05,15.76 48.99,15.82 48.99,17.91 49.08,17.99 49.73,17.99
CHG_LGATE on TOP (solid shape): 52.45,18.36 52.45,18.17 52.64,17.98 53.4,17.98 53.47,17.92 53.47,17.85 53.4,17.79 52.13,17.79 51.59,18.33 51.59,18.71 51.69,18.8 52.01,18.8
CHG_LGATE on BOTTOM (solid shape): 49.69,2.52 49.69,2.16 49.32,1.79 47.18,1.79 47.03,1.94 47.03,2.29 47.23,2.5 48.53,2.5 48.71,2.68 49.53,2.68
CHG_LGATE on IN5 (solid shape): 48.83,2.74 49.47,2.74 49.72,2.49 49.72,2.16 49.29,1.72 48.32,1.72 47.63,2.42 47.63,2.8 47.94,3.12 48.45,3.12
CHG_LGATE on IN5 (solid shape): 52.5,18.28 52.5,17.98 52.35,17.83 50.38,17.83 50.17,18.04 50.17,18.55 50.32,18.7 51.52,18.7 51.61,18.79 51.65,18.81 51.69,18.84 51.95,18.84
CHG_SW on TOP (solid shape): 43.18,8.16 43.18,4.64 42.1,3.56 35.69,3.56 35.12,4.14 35.12,6.68 34.86,6.93 33.59,6.93 32.96,6.3 32.13,6.3 31.94,6.49 31.94,7.5 33.08,8.64 42.7,8.64
CHG_SW on TOP (solid shape): 51.18,16.65 51.18,16.46 51.44,16.2 52.26,16.2 52.45,16.39 53.4,16.39 53.47,16.33 53.47,16.26 53.4,16.2 52.64,16.2 52.39,15.95 52.39,15.82 52.26,15.69 50.55,15.69 50.42,15.82 50.42,16.65 50.55,16.77 51.06,16.77
CHG_SW on BOTTOM (solid shape): outline of 108 points within 30.99,1.9 46.42,16.77
CHG_SW on IN1 (solid shape): 43.12,8.85 43.12,7.11 42.93,6.92 42.17,6.92 41.97,7.11 41.97,8.85 42.09,8.97 43,8.97
CHG_SW on IN1 (solid shape): 51.25,16.2 52.26,16.2 52.45,16.01 52.45,15.63 52.13,15.31 50.48,15.31 50.42,15.38 50.42,16.2 50.55,16.33 51.12,16.33
CHG_SW on IN2 (solid shape): outline of 203 points within 29.4,1.6 46.42,16.77
CHG_SW on IN3 (solid shape): outline of 205 points within 29.4,1.79 46.42,16.77
CHG_SW on IN6 (solid shape): outline of 190 points within 29.4,1.6 46.42,16.77
CHG_UGATE on TOP (solid shape): 53.47,16.77 53.47,16.65 53.4,16.58 52.45,16.58 52.2,16.33 51.5,16.33 51.37,16.46 51.37,16.77 51.44,16.84 53.4,16.84
CHG_UGATE on BOTTOM (solid shape): 43.12,12.65 43.12,11.63 42.99,11.5 42.04,11.5 41.85,11.69 41.85,12.65 42.04,12.84 42.93,12.84
CHG_UGATE on BOTTOM (solid shape): 43.57,18.19 43.57,17.53 43.38,17.34 42.47,17.34 42.16,17.65 42.16,18.44 42.34,18.61 43.14,18.61
CHG_UGATE on IN1 (solid shape): 43.12,18.42 43.12,17.22 42.93,17.03 42.23,17.03 42.1,17.15 42.1,18.49 42.23,18.61 42.93,18.61
CHG_UGATE on IN1 (solid shape): 43.05,14.11 43.05,13.22 43.37,12.9 44.07,12.9 44.26,12.71 44.26,12.14 44.07,11.95 42.17,11.95 42.04,12.07 42.04,14.04 42.23,14.23 42.93,14.23
CHG_UGATE on IN1 (solid shape): 51.51,17.22 52.2,17.22 52.39,17.03 52.39,16.46 52.26,16.33 51.42,16.33 51.23,16.52 50.42,16.52 50.36,16.58 50.36,17.47 50.42,17.53 51.19,17.53
DAUL_IN on TOP (solid shape): 18.92,25.35 18.92,24.97 19.31,24.58 21.97,24.58 22.26,24.3 22.26,21.76 22.1,21.6 21.21,21.6 21.15,21.66 21.15,22.01 20.96,22.2 18.05,22.2 17.78,22.47 17.78,22.87 17.57,23.08 16.75,23.08 16.64,23.19 16.64,23.95 16.38,24.2 20.35,24.2 20.35,24.15 20.36,24.1 20.38,24.05 20.41,24 20.44,23.96 20.48,23.92 20.52,23.89 20.57,23.87 20.62,23.85 20.68,23.85 20.73,23.85 20.78,23.85 20.83,23.87 20.88,23.89 20.92,23.92 20.96,23.96 21,24 21.02,24.05 21.04,24.1 21.05,24.15 21.06,24.2 21.05,24.26 21.04,24.31 21.02,24.36 21,24.4 20.96,24.45 20.92,24.48 20.88,24.51 20.83,24.53 20.78,24.55 20.73,24.56 20.68,24.56 20.62,24.55 20.57,24.53 20.52,24.51 20.48,24.48 20.44,24.45 20.41,24.4 20.38,24.36 20.36,24.31 20.35,24.26 20.35,24.2 16.38,24.2 16.38,25.28 16.57,25.47 18.8,25.47
DAUL_IN on BOTTOM (solid shape): 28.64,31.19 29.47,31.19 29.66,31 29.66,30.55 29.91,30.3 29.91,30.11 29.78,29.98 29.78,29.92 30.24,29.46 30.24,28.97 30.07,28.8 30.07,28.1 30.01,28.04 28.09,28.04 27.97,28.16 27.97,29.63 27.56,30.04 27.57,30.08 27.33,30.55 26.89,30.26 26.89,30.24 26.84,30.19 26.73,30.3 26.73,31 26.93,31.19 27.12,31.19 27.24,31.31 27.24,31.44 27.43,31.63 28.2,31.63
DAUL_IN on BOTTOM (solid shape): 18.98,27.32 18.98,26.56 18.8,26.37 18.8,25.39 18.97,25.22 18.97,24.94 19.38,24.53 19.97,24.53 20.05,24.44 20.05,23.63 19.91,23.48 17.04,23.48 16.48,24.04 16.48,24.23 16.47,24.24 16.47,25.75 16.77,26.04 17.81,26.04 17.81,25.99 17.82,25.94 17.84,25.89 17.87,25.84 17.9,25.8 17.94,25.76 17.98,25.73 18.03,25.71 18.08,25.7 18.14,25.69 18.19,25.69 18.24,25.7 18.29,25.71 18.34,25.73 18.38,25.76 18.42,25.8 18.46,25.84 18.48,25.89 18.5,25.94 18.51,25.99 18.52,26.04 18.51,26.1 18.5,26.15 18.48,26.2 18.46,26.24 18.42,26.29 18.38,26.32 18.34,26.35 18.29,26.38 18.24,26.39 18.19,26.4 18.14,26.4 18.08,26.39 18.03,26.38 17.98,26.35 17.94,26.32 17.9,26.29 17.87,26.24 17.84,26.2 17.82,26.15 17.81,26.1 17.81,26.04 16.77,26.04 17.23,26.51 17.23,27.34 17.34,27.44 18.86,27.44
DAUL_IN on IN1 (solid shape): outline of 1904 points within 15.93,8.05 31.31,31.63
DAUL_IN on IN2 (solid shape): outline of 754 points within 15.4,22.96 31.3,31.63
DGPU_PEX_RST# on TOP (solid shape): 221.56,43.64 221.56,42.22 221.46,42.12 220.6,42.12 220.04,42.69 220.04,42.77 219.69,43.12 219.3,43.12 219.12,43.3 219.12,43.82 219.34,44.03 221.17,44.03
DGPU_PWR_EN#_R on TOP (solid shape): 247.22,47.73 247.22,46.93 247.77,46.38 247.77,45.77 248.04,45.5 249.91,45.5 250.2,45.21 250.2,44.42 249.99,44.21 247.27,44.21 245.83,45.66 245.83,46.48 245.73,46.58 245.73,46.61 245.52,46.82 245.52,47.72 245.66,47.86 247.1,47.86
DH1_NVVDD on BOTTOM (solid shape): 167.45,101.99 168.15,101.99 168.34,101.8 168.34,101.29 168.09,101.04 167.07,101.04 166.82,101.29 166.82,102.12 166.94,102.24 167.2,102.24
DH1_NVVDD on BOTTOM (solid shape): 167.11,114.08 167.11,113.99 167.04,113.93 166.12,113.93 166.03,113.84 166.03,113.64 165.47,113.08 165.24,113.08 165.14,113.18 165.14,113.61 165.57,114.04 165.89,114.04 166,114.16 167.03,114.16
DH1_NVVDD on IN4 (solid shape): 167.39,102.62 167.39,101.1 167.32,101.04 166.82,101.04 166.43,101.42 166.43,102.5 166.24,102.69 166.24,102.88 166.69,103.32
DH1_NVVDD on IN4 (solid shape): 166.15,113.77 166.15,113.51 165.93,113.29 165.93,112.09 165.86,112.02 165.29,112.02 165.14,112.18 165.14,113.56 165.57,113.99 165.93,113.99
DH1_NVVDDS on BOTTOM (solid shape): 181.43,114.23 181.43,113.33 181.55,113.22 181.72,113.22 182.28,112.66 182.28,112.43 182.18,112.33 181.93,112.33 181.23,113.03 181.23,114.24 181.29,114.3 181.36,114.3
DH1_NVVDDS on BOTTOM (solid shape): 190.76,110.42 190.76,109.48 190.63,109.36 189.8,109.36 189.65,109.51 189.65,110.02 189.5,110.17 189.5,110.51 189.85,110.87 190.31,110.87
DH1_NVVDDS on IN4 (solid shape): 183.14,112.41 183.14,112.11 182.8,111.77 182.48,111.77 181.37,112.89 181.37,113.11 181.6,113.34 182.21,113.34
DH1_NVVDDS on IN4 (solid shape): 190.95,110.27 190.95,109.8 190.69,109.55 188.72,109.55 188.72,110.24 188.79,110.31 189.17,110.31 189.82,110.96 190.26,110.96
DH2_NVVDD on BOTTOM (solid shape): 168.47,107.83 168.97,107.83 169.17,107.64 169.17,107.13 168.91,106.88 167.9,106.88 167.64,107.13 167.64,108.09 167.75,108.19 168.1,108.19
DH2_NVVDD on BOTTOM (solid shape): 170.6,113.99 170.8,113.99 171.01,113.79 171.29,113.79 171.62,113.46 171.62,113.23 171.49,113.1 171.02,113.1 170.19,113.93 169.36,113.93 169.3,113.98 169.3,114.11 169.37,114.17 170.43,114.17
DH2_NVVDD on IN1 (solid shape): 169.55,108.21 169.55,107.58 169.29,107.32 168.66,107.32 168.4,107.07 167.8,107.07 167.64,107.23 167.64,108.02 167.9,108.28 169.48,108.28
DH2_NVVDD on IN1 (solid shape): 172.08,113.2 172.08,112.16 172,112.08 171.38,112.08 171.31,112.14 171.31,112.76 170.97,113.1 170.96,113.1 170.52,113.54 170.52,113.78 170.81,114.07 171.21,114.07
DH_1.2V on BOTTOM (solid shape): 287.29,29.28 287.29,29.18 287.24,29.14 286.18,29.14 285.37,28.33 285.18,28.33 285.05,28.46 285.05,28.88 285.51,29.35 287.22,29.35
DH_1.2V on BOTTOM (solid shape): 271.5,33.69 271.5,32.79 271.37,32.66 270.75,32.66 270.16,33.25 270.16,34.2 270.26,34.3 270.89,34.3
DH_1.2V on IN6 (solid shape): 271.27,34.24 271.27,31.95 271.15,31.82 270.32,31.82 270.07,32.08 270.07,34.24 270.26,34.43 271.08,34.43
DH_1.2V on IN6 (solid shape): 285.31,29.41 285.81,29.41 286.01,29.22 286.01,28.96 285.37,28.33 284.99,28.33 284.29,29.03 284.29,29.16 284.86,29.73 284.99,29.73
DL1_NVVDD on BOTTOM (solid shape): 175.07,103.51 175.07,102.62 174.94,102.5 173.1,102.5 172.91,102.69 172.91,103.45 173.1,103.64 174.94,103.64
DL1_NVVDD on BOTTOM (solid shape): 167.91,113.31 167.91,112.16 167.58,111.83 167.58,111.83 166.96,111.2 166.78,111.2 166.66,111.32 166.66,111.55 167.27,112.16 167.48,112.16 167.7,112.39 167.7,113.25 167.78,113.33 167.88,113.33
DL1_NVVDD on IN1 (solid shape): 175.13,103.07 175.13,102.5 174.94,102.31 172.98,102.31 172.53,102.75 172.53,102.94 172.85,103.26 174.94,103.26
DL1_NVVDD on IN1 (solid shape): 167.8,112.02 167.8,111.66 167.39,111.26 167.39,110.12 167.39,110.12 166.63,110.12 166.63,111.62 167.23,112.22 167.6,112.22
DL1_NVVDDS on BOTTOM (solid shape): 192.09,104.72 192.09,102.82 191.9,102.62 191.26,102.62 191.01,102.88 191.01,104.78 191.07,104.85 191.96,104.85
DL1_NVVDDS on BOTTOM (solid shape): 183.52,114.76 183.81,114.76 184.24,114.33 184.24,114.05 184.04,113.85 183.81,113.85 183.2,114.46 183.2,114.66 182.97,114.89 182.11,114.89 182.03,114.97 182.03,115.07 182.05,115.1 183.19,115.1
DL1_NVVDDS on IN1 (solid shape): 191.9,104.72 191.9,102.82 191.71,102.62 191.39,102.62 190.95,103.07 190.95,104.66 191.26,104.97 191.64,104.97
DL1_NVVDDS on IN1 (solid shape): 183.55,114.98 183.65,114.93 183.76,114.91 183.78,114.9 184.6,114.08 184.6,114.05 184.98,113.68 184.98,113.67 184.6,113.29 184.26,113.29 183.67,113.88 183.67,113.89 183.58,114.05 183.42,114.14 183.41,114.15 183.14,114.41 183.14,114.79 183.34,114.98
DL2_NVVDD on BOTTOM (solid shape): 169,112.09 169.14,112.09 169.8,111.43 169.8,111.17 169.7,111.07 169.48,111.07 168.71,111.85 168.71,111.86 168.64,111.92 168.64,112.06 168.74,112.16 168.92,112.16
DL2_NVVDD on BOTTOM (solid shape): 174.44,110.07 174.44,109.97 174.56,109.85 174.58,109.79 174.61,109.75 174.61,108.51 174.37,108.28 173.86,108.28 173.62,108.52 173.62,110.05 173.85,110.27 174.23,110.27
DL2_NVVDD on IN4 (solid shape): 169.91,111.3 169.91,111.04 169.79,110.92 169.36,110.92 168.8,111.48 168.8,111.98 168.9,112.09 169.13,112.09
DL2_NVVDD on IN4 (solid shape): 174.51,110.02 174.51,109.22 174.39,109.1 173.17,109.1 172.72,109.55 172.72,109.85 173.09,110.22 174.31,110.22
DL_1.2V on BOTTOM (solid shape): 287.57,28.6 287.57,27.74 286.83,27 286.26,27 286.16,27.09 286.16,27.41 287.41,28.66 287.51,28.66
DL_1.2V on BOTTOM (solid shape): 275.27,26.87 275.27,26.27 275.09,26.09 273.39,26.09 273.24,26.23 273.24,26.45 273.37,26.58 273.94,26.58 274.36,27 275.15,27
DL_1.2V on IN6 (solid shape): 276.29,26.81 276.29,26.36 276.1,26.17 274.13,26.17 274,26.3 274,27 274.07,27.06 276.04,27.06
DL_1.2V on IN6 (solid shape): 287.28,27.82 287.28,27.5 286.58,26.81 286.58,26.3 286.32,26.04 286.11,26.04 285.6,26.55 285.6,26.72 285.62,26.74 285.62,26.87 286.77,28.01 287.08,28.01
LG_3V on TOP (solid shape): 341.95,22.04 342.11,22.04 342.89,21.26 343.3,21.26 343.41,21.15 343.41,21.06 343.36,21 342.37,21 342.09,21.28 341.69,21.28 341.44,21.54 341.44,21.92 341.56,22.04 341.95,22.04
LG_3V on TOP (solid shape): 338.46,20.92 338.46,18.8 338.39,18.74 337.95,18.74 337.57,18.36 337.57,17.98 337.38,17.79 336.49,17.79 336.36,17.92 336.36,18.42 336.49,18.55 337,18.55 337.19,18.74 337.19,20.91 337.37,21.1 338.28,21.1
LG_3V on IN1 (solid shape): 338.46,21.54 338.46,20.52 338.39,20.46 337.31,20.46 337.19,20.58 337.19,21.41 337.38,21.6 338.39,21.6
LG_3V on IN1 (solid shape): 342.52,21.6 342.52,21.34 342.33,21.15 340.49,21.15 340.42,21.22 340.42,22.11 340.49,22.17 341.95,22.17
LG_5V on TOP (solid shape): 333.82,16.52 333.82,15.44 333.34,14.96 331.76,14.96 331.66,15.06 331.66,16.33 331.79,16.46 332.61,16.46 332.8,16.65 333.69,16.65
LG_5V on TOP (solid shape): 343.4,19.58 343.4,19.42 343.36,19.38 342.66,19.38 342.25,18.97 341.37,18.97 341.28,19.06 341.28,19.41 341.44,19.57 342.43,19.57 342.46,19.59 343.38,19.59
LG_5V on IN1 (solid shape): 333.31,17.92 333,17.6 333,15.06 332.8,14.87 331.98,14.87 331.79,15.06 331.79,17.98 332.61,18.8 333.31,18.8
LG_5V on IN1 (solid shape): 342.39,19.44 342.39,19.12 342.23,18.96 341.72,18.96 341.3,18.55 340.11,18.55 340.11,19.44 340.23,19.57 342.27,19.57
LX1_NVVDD on BOTTOM (solid shape): 168.4,103.89 168.4,102.69 168.21,102.5 167.45,102.5 167.2,102.75 167.2,103.96 167.32,104.09 168.21,104.09
LX1_NVVDD on BOTTOM (solid shape): 167.5,112.47 167.48,112.44 167.12,112.44 166.04,111.37 165.78,111.37 165.03,110.62 164.52,110.62 164.44,110.7 164.44,111.49 164.48,111.53 165.03,111.53 165.43,111.93 165.98,111.93 167.3,113.25 167.3,113.33 167.5,113.33
LX1_NVVDD on IN6 (solid shape): 167.01,112.53 167.01,112.21 166.18,111.39 165.74,111.39 165.61,111.51 165.61,112.02 166.37,112.78 166.75,112.78
LX1_NVVDD on IN6 (solid shape): 167.01,104 168.25,104 168.4,103.85 168.4,103.2 168.34,103.14 166.77,103.14 166.03,103.88 166.03,103.93 166.53,104.43 166.58,104.43
LX1_NVVDDS on BOTTOM (solid shape): 192.53,110.24 192.53,109.42 192.47,109.36 191.39,109.36 191.2,109.55 191.2,110.24 191.39,110.44 192.34,110.44
LX1_NVVDDS on BOTTOM (solid shape): 182.92,114.66 182.92,114.31 183.12,114.1 183.33,114.1 184.09,113.34 184.61,113.34 184.85,113.1 184.85,112.47 183.88,112.47 183.88,112.71 182.11,114.49 182.03,114.49 182.03,114.69 182.89,114.69
LX1_NVVDDS on IN4 (solid shape): 192.66,110.31 192.66,109.42 192.47,109.23 191.96,109.23 191.71,109.48 191.71,110.05 191.33,110.44 191.33,110.63 191.77,111.07 191.9,111.07
LX1_NVVDDS on IN4 (solid shape): 183.01,114.37 183.12,114.37 184.23,113.26 184.23,112.98 183.88,112.63 183.76,112.63 182.44,113.95 182.44,114.25 182.56,114.37 183.01,114.37
LX2_NVVDD on BOTTOM (solid shape): 169.12,113.31 169.12,113.16 170.96,111.32 171.9,111.32 172.02,111.2 172.02,110.31 171.9,110.18 170.69,110.18 169.96,109.45 169.94,109.45 169.94,109.43 169.64,109.13 169.49,109.13 169.1,108.74 169.1,108.53 168.85,108.28 168.4,108.28 168.21,108.47 168.21,109.01 168.59,109.39 168.61,109.39 168.74,109.45 168.84,109.56 168.9,109.61 168.98,109.6 169.22,109.55 169.43,109.66 169.69,109.91 169.69,110.19 170.06,110.56 170.06,111.54 169.23,112.37 169.05,112.37 168.97,112.45 168.97,112.89 168.95,112.99 168.91,113.08 168.91,113.29 168.96,113.34 169.08,113.34
LX_0.95V on TOP (solid shape): 110.87,61.54 110.87,60.52 110.75,60.4 109.54,60.4 109.41,60.52 109.41,61.54 109.6,61.73 110.68,61.73
LX_0.95V on BOTTOM (solid shape): 114.36,61.73 114.36,58.94 114.75,58.56 114.75,57.03 114.62,56.9 113.73,56.9 113.48,57.16 113.48,58.62 112.78,59.32 111.62,59.32 111.49,59.44 111.49,60.04 111.42,60.12 110.58,60.12 110.05,60.65 108.97,60.65 108.97,61.67 109.03,61.73 109.98,61.73 110.43,62.18 113.92,62.18
