# Allegro board Dell XPS 9560 LA-E331P R10.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB3TP1_RE: length 1.8
  BOTTOM w0.152: UI3.12 320.91,34.87 320.87,34.91 320.87,35.81 CI20.1
USB3TP2: length 157.5
  IN3 w0.099: v2(24.11,103.01) 23.83,103.28 23.51,103.28 18.7,98.47 18.7,95.42 20.3,93.82 20.3,92.36 20.83,91.83 21.42,91.83 22.94,90.31 24.53,90.31 27.5,87.34 27.5,83.26 25.78,81.54 25.78,77.1 26.54,76.34 26.54,68.17 27.95,66.76 27.95,52.07 29.47,50.55 30.42,50.55 31.4,49.57 31.4,48.56 31.63,48.32 31.63,45.21 32.64,44.2 33.08,44.2 33.94,43.35 33.94,41.73 33.75,41.54 33.75,36.86 39.84,30.76 40.12,30.76 41.61,29.27 43.03,29.27 44.53,27.78 44.53,27.24 46.77,25 50.17,25 50.39,24.77 56.45,24.77 57.49,23.73 65.79,23.73 66.3,23.22 71.36,23.22 72,23.86 75.26,23.86 76.85,22.27 80.2,22.27 80.78,21.7 82.03,21.7 82.22,21.51 83.09,21.51 83.36,21.78 83.36,23.16 84.16,23.96 84.62,23.96 84.91,24.25 87.42,24.25 89.17,26.01 89.17,26.81 89.78,27.42 92.54,27.42 93.09,26.87 93.09,26.34 93.21,26.22 93.31,26.22 v2(93.5,26.41)
  BOTTOM w0.089: v2(93.5,26.41) 94.11,25.8 UH2.A12
  BOTTOM w0.152: CI10.1 19.66,104.35 19.66,103.58 20.73,102.52 23.48,102.52 23.96,103.01 v2(24.11,103.01)
USB3TP2_D+: length 10.1
  TOP w0.152: RI42.2 19.65,103.92 19.7,103.92 20.42,103.2 20.42,102.98 20.27,102.83 20.12,102.83 19.96,102.99 DI7.5 DI7.6 18.36,102.99 18.26,102.89 18.12,102.89 17.96,103.06 17.96,103.3 18.14,103.48 18.14,104.9 17.96,105.08 v5(17.96,105.42) 17.96,105.9 17.51,106.35 16.97,106.35 16.18,107.14 JUSB1.9
USB20_FP_N1_CONN: length 10.6
  BOTTOM w0.17: JFP.4 220.65,6.67 220.68,6.71 220.68,7.15 220.33,7.5 220.33,8.82 221.21,9.7 221.21,9.99 220.84,10.36 DI13.2 220.6,10.87 221.35,11.62 221.35,12.53 221.91,13.09 v5(222.66,13.09) 222.96,13.09 223.2,13.32 ML17.2
USB20_FP_P1_CONN: length 10.6
  BOTTOM w0.17: ML17.3 223.37,12.42 223.13,12.19 222.87,12.19 222.7,12.35 222.7,12.53 222.57,12.66 222.09,12.66 221.78,12.35 v1(221.78,12.09) 221.78,11.62 222.53,10.87 DI13.3 221.77,10.36 221.55,10.14 221.55,9.53 220.77,8.75 220.77,7.68 221.12,7.33 221.12,6.71 221.15,6.67 JFP.3
USB20_N1: length 268.5
  IN1 w0.107: v2(97.44,13.75) 97.32,13.87 97.32,14.09 97.44,14.21 99.18,14.21 99.71,14.74 101.54,14.74 102.19,15.39 102.19,16.52 102.91,17.25 128.17,17.25 130.23,15.19 150.18,15.19 150.88,14.49 154.19,14.49 155.35,13.32 178.43,13.32 178.6,13.15 185.42,13.15 185.53,13.27 214.34,13.27 215.32,12.29 243.19,12.29 243.77,11.72 249.17,11.72 250.03,10.85 261.18,10.85 263.83,13.51 265.97,13.51 270.63,18.16 273.18,18.16 274.26,19.24 277.6,19.24 279.09,20.73 281.47,20.73 282.83,22.08 287.97,22.08 290.02,24.13 292.92,24.13 293.38,23.67 296.68,23.67 297.17,24.15 302.82,24.15 304.88,26.21 304.88,29.1 313.78,38 314.49,38 318.33,41.84 319.55,41.84 320.01,42.3 321.25,42.3 326.66,47.71 326.66,53.97 329.6,56.92 329.6,58.91 329.78,59.08 v2(329.81,59.08)
  BOTTOM w0.089: UH2.AF5 97.28,13.33 97.28,13.6 v2(97.44,13.75)
  BOTTOM w0.152: UI2.2 330.07,61.79 329.99,61.71 329.99,61.13 329.63,60.78 329.63,59.26 v2(329.81,59.08)
USB20_N2: length 164.4
  TOP w0.152: UI1.2 25.14,88.7 25.22,88.62 25.22,86.33 24.77,85.87 23.93,85.87 23.61,85.55 23.61,85.18 v2(23.42,84.99)
  IN6 w0.107: v2(23.42,84.99) 23.43,84.99 23.8,85.37 23.8,85.63 23.08,86.35 23.08,87.65 22.4,88.33 21.39,88.33 18.67,85.61 18.67,77.2 14.86,73.39 14.86,68.72 16.72,66.86 16.72,63.3 17.11,62.91 17.11,40.14 16.05,39.08 16.05,35.61 19.69,31.96 20.24,31.96 20.98,31.23 21.93,31.23 23.46,29.7 26.32,29.7 26.9,29.12 27.88,29.12 28.73,28.27 30.84,28.27 31.04,28.07 32.25,28.07 32.51,28.33 32.51,28.77 33.86,30.12 39.41,30.12 40.21,30.92 43.63,30.92 45.06,29.48 48.73,29.48 50.42,27.8 56.02,27.8 58.52,25.29 61.91,25.29 65.19,22.02 66.8,22.02 68.66,20.16 71.16,20.16 75.62,15.7 83.56,15.7 85.17,17.31 85.17,17.81 85.59,18.23 90.01,18.23 90.32,17.92 90.32,16.34 91.27,15.39 96.85,15.39 97.06,15.19 97.33,15.19 v2(97.71,14.8)
  BOTTOM w0.089: UH2.AD5 97.4,14.26 97.31,14.35 97.31,14.44 97.68,14.8 v2(97.71,14.8)
USB20_N4: length 290.8
  IN1 w0.107: v2(328.17,79.57) 329.02,79.57 329.34,79.26 329.34,65.95 329.03,65.64 329.03,61.6 330.96,59.67 330.96,57.69 328.93,55.66 328.93,53.51 327.9,52.48 327.9,50.58 327.22,49.89 327.22,47.29 324.28,44.35 324.28,43.27 322.69,41.68 320.46,41.68 319.98,41.19 318.36,41.19 312.48,35.31 312.48,34.01 308.99,30.52 308.99,29.71 307.61,28.33 307.4,28.33 306.31,27.24 306.31,26.73 305.52,25.94 305.52,24.86 305.12,24.46 304.67,24.46 303.95,23.73 297.33,23.73 296.85,23.25 293.13,23.25 292.99,23.4 291.07,23.4 290.56,22.89 290.56,22.72 289.31,21.47 285.24,21.47 283.44,19.67 279.24,19.67 278.38,18.8 274.43,18.8 273.29,17.66 270.73,17.66 266.16,13.09 264.11,13.09 261.26,10.25 249.72,10.25 248.79,11.17 243.13,11.17 242.97,11.33 236.8,11.33 236.56,11.09 233.46,11.09 233.27,10.91 219.94,10.91 219.18,11.67 215.12,11.67 214.13,12.66 189.86,12.66 189.77,12.57 186.49,12.57 185.7,11.78 179.39,11.78 178.26,12.91 155.18,12.91 154.11,13.98 150.31,13.98 149.53,14.75 130.07,14.75 128.68,16.15 105.2,16.15 104.49,15.44 103.03,15.44 101.48,13.89 100.93,13.89 100.82,14 100.82,14.25 100.57,14.5 100.06,14.5 99.98,14.41 99.98,14.3 100.22,14.06 v2(100.36,14.06)
  BOTTOM w0.089: v2(100.36,14.06) 100.12,14.29 99.66,14.29 99.33,13.97 UH2.AE1
  BOTTOM w0.152: LN1.1 329.75,79.79 329.4,79.43 328.54,79.43 328.4,79.57 v2(328.17,79.57)
USB20_N4_R: length 2.2
  BOTTOM w0.152: LN1.2 329.64,81.96 329.64,82.66 329.46,82.84 329.46,83.09 329.55,83.18 JNGFF1.5
USB20_N7: length 142.2
  IN3 w0.089: 101.85,14.02 101.83,14.04 101.83,14.05 101.59,14.28 101.59,15.63 101.4,15.82 100.95,15.82 100.66,16.11 100.66,16.47 v2(100.55,16.58)
  IN3 w0.099: v2(227.9,11.88) 227.68,11.66 227.68,11.03 227.27,10.61 220.39,10.61 218.02,12.99 162.41,12.99 160.78,14.62 121.01,14.62 118.47,12.07 116.9,12.07 114.86,10.03 113.79,10.03 112.89,10.93 110.67,10.93 109.75,11.85 108.5,11.85 106.77,11.85 106.19,12.43 103.44,12.43 101.85,14.02
  BOTTOM w0.089: UH2.AB3 98.54,15.54 98.9,15.9 100.62,15.9 100.71,15.99 100.71,16.42 v2(100.55,16.58)
  BOTTOM w0.152: ML17.1 227.28,13.32 228.02,12.59 228.02,12.28 228.02,12.27 228.02,12 v2(227.9,11.88)
USB20_N9: length 254.6
  IN1 w0.107: v2(321.13,45.97) 320.89,45.97 320.56,45.64 320.56,44.73 318.33,42.49 317.82,42.49 315.14,39.81 314,39.81 309.8,35.62 309.35,35.62 304.05,30.32 304.05,28.51 300.88,25.35 297.49,25.35 296.46,24.32 293.6,24.32 292.81,25.12 290.14,25.12 288.04,23.02 282.63,23.02 280.95,21.34 278.81,21.34 277.37,19.9 273.93,19.9 273.35,19.32 268.98,19.32 268.29,18.63 268.29,16.69 265.72,14.12 263.58,14.12 262.89,13.43 261.52,13.43 259.66,11.58 252.56,11.58 251.24,12.9 244.35,12.9 243.82,13.43 232.14,13.43 231.86,13.71 215.84,13.71 215.35,14.2 179.96,14.2 179.73,13.96 155.69,13.96 154.55,15.1 151.13,15.1 150.15,16.09 130.26,16.09 128.44,17.9 100.48,17.9 99.77,17.2 99.77,16.78 v2(99.97,16.58)
  BOTTOM w0.089: UH2.AA1 99.54,16.16 v2(99.97,16.58)
  BOTTOM w0.152: LI1.1 330.14,45.08 330.04,44.99 330.04,44.66 329.52,44.14 329.04,44.14 327.08,46.1 321.26,46.1 v2(321.13,45.97)
USB20_N9_R: length 10.8
  BOTTOM w0.152: LI1.2 330.14,47.44 330.07,47.51 330.07,47.89 329.9,48.06 329.9,48.24 330.05,48.38 330.71,48.38 330.92,48.18 330.92,47.71 v5(331.18,47.45) 331.41,47.21 331.72,47.21 331.86,47.21 332.65,46.41 DI3.2 333.01,46.96 333.24,47.19 333.62,47.19 334.34,47.91 334.34,49.21 334.16,49.4 334.16,49.86 334.39,50.09 JTS.4
USB20_N12: length 51.3
  IN1 w0.107: v2(100.57,15.35) 100.57,15.89 100.34,16.11 98.94,16.11 98.54,15.71 98,15.71 97.8,15.9 97.8,16.41 97.49,16.72 93.64,16.72 91.9,18.46 83.63,18.46 83.09,17.92 78.18,17.92 77.13,16.87 71.92,16.87 71.47,17.33 65.18,17.33 64.8,16.95 62.21,16.95 61.86,16.61 60.92,16.61 59.2,18.32 v2(58.19,18.32)
  BOTTOM w0.089: UH2.AD3 98.69,14.29 99.12,14.29 99.3,14.47 100.21,14.47 100.53,14.79 100.53,15.31 v2(100.57,15.35)
  BOTTOM w0.152: LV22.1 58.19,19.34 58.19,18.96 58.65,18.5 58.65,18.32 58.54,18.21 58.3,18.21 v2(58.19,18.32)
USB20_N12_R: length 16.7
  BOTTOM w0.152: JEDP1.31 56.55,31.36 57.06,30.84 58.53,30.84 60.07,29.31 60.07,26.93 59.88,26.74 v1(59.88,26.55) 60.07,26.36 DV12.3 60.07,24.57 59.56,24.06 58.55,24.06 58.24,23.75 57.98,23.75 57.97,23.75 57.95,23.75 57.52,23.32 57.52,22.34 58.24,21.62 58.24,21.33 58.29,21.27 LV22.2
USB20_P1: length 268.5
  IN1 w0.107: v2(96.88,13.75) 97.12,13.99 97.12,14.17 97.36,14.41 99.09,14.41 99.62,14.94 101.45,14.94 101.98,15.47 101.98,16.6 102.83,17.45 128.25,17.45 130.31,15.39 150.26,15.39 150.96,14.69 154.27,14.69 155.43,13.53 178.52,13.53 178.69,13.36 185.33,13.36 185.45,13.47 214.43,13.47 215.4,12.5 243.28,12.5 243.85,11.92 249.25,11.92 250.11,11.06 261.1,11.06 263.75,13.71 265.89,13.71 270.54,18.36 273.1,18.36 274.18,19.44 277.51,19.44 279.01,20.93 281.39,20.93 282.74,22.28 287.89,22.28 289.93,24.33 293.01,24.33 293.47,23.87 296.6,23.87 297.08,24.35 302.73,24.35 304.67,26.3 304.67,29.18 313.7,38.21 314.41,38.21 318.25,42.05 319.47,42.05 319.93,42.5 321.16,42.5 326.45,47.79 326.45,54.06 329.4,57 329.4,58.91 v2(329.22,59.08)
  BOTTOM w0.089: v2(96.88,13.75) 96.88,13.34 UH2.AG7
  BOTTOM w0.152: UI2.3 329.57,61.82 329.65,61.73 329.65,61.27 329.3,60.92 329.3,59.16 v2(329.22,59.08)
USB20_P2: length 164.4
  TOP w0.152: UI1.3 25.64,88.73 25.55,88.64 25.55,86.19 24.91,85.54 24.07,85.54 23.94,85.42 23.94,85.05 v2(24,84.99)
  IN6 w0.107: v2(97.14,14.82) 96.77,15.19 91.18,15.19 90.12,16.25 90.12,17.84 89.93,18.03 85.67,18.03 85.37,17.73 85.37,17.23 83.64,15.5 75.54,15.5 71.07,19.96 68.57,19.96 66.72,21.81 65.11,21.81 61.83,25.09 58.44,25.09 55.94,27.59 50.34,27.59 48.65,29.28 44.98,29.28 43.54,30.72 40.3,30.72 39.5,29.92 33.95,29.92 32.72,28.69 32.72,28.25 32.33,27.86 30.96,27.86 30.76,28.06 28.65,28.06 27.79,28.92 26.82,28.92 26.23,29.5 23.37,29.5 21.85,31.02 20.89,31.02 20.16,31.76 19.61,31.76 15.85,35.52 15.85,39.17 16.9,40.23 16.9,62.83 16.51,63.22 16.51,66.78 14.66,68.64 14.66,73.47 18.47,77.28 18.47,85.69 21.3,88.53 22.49,88.53 23.28,87.73 23.28,86.44 24,85.71 v2(24,84.99)
  BOTTOM w0.089: UH2.AD7 96.7,14.37 v2(97.14,14.82)
USB20_P4: length 290.7
  IN1 w0.107: v2(99.81,13.92) 99.81,13.89 100.02,13.69 101.56,13.69 103.12,15.24 104.58,15.24 105.28,15.95 128.59,15.95 129.99,14.55 149.45,14.55 150.22,13.78 154.03,13.78 155.09,12.71 178.18,12.71 179.31,11.58 185.78,11.58 186.57,12.37 189.85,12.37 189.94,12.45 214.05,12.45 215.03,11.47 219.09,11.47 219.86,10.7 233.36,10.7 233.55,10.89 236.65,10.89 236.88,11.12 242.89,11.12 243.04,10.97 248.71,10.97 249.63,10.05 261.35,10.05 264.19,12.89 266.24,12.89 270.81,17.46 273.37,17.46 274.52,18.6 278.46,18.6 279.33,19.47 283.53,19.47 285.33,21.27 289.4,21.27 290.77,22.64 290.77,22.81 291.16,23.2 292.9,23.2 293.05,23.05 296.94,23.05 297.41,23.53 304.03,23.53 304.76,24.25 305.21,24.25 305.73,24.77 305.73,25.86 306.52,26.65 306.52,27.15 307.49,28.13 307.7,28.13 309.2,29.62 309.2,30.44 312.69,33.93 312.69,35.23 318.45,40.99 320.07,40.99 320.55,41.47 322.77,41.47 324.49,43.19 324.49,44.27 327.42,47.2 327.42,49.81 328.11,50.49 328.11,52.4 329.13,53.43 329.13,55.58 331.17,57.61 331.17,59.75 329.24,61.68 329.24,65.56 329.54,65.86 329.54,79.35 329.11,79.78 328.57,79.78 v2(328.17,80.18)
  BOTTOM w0.089: v2(99.81,13.92) 99.5,13.62 99.22,13.62 98.96,13.88 UH2.AE2
  BOTTOM w0.14: 328.27,80.31 328.17,80.21 v2(328.17,80.18)
  BOTTOM w0.152: 328.27,80.31 328.51,80.31 328.61,80.21 328.61,79.83 328.68,79.76 329.26,79.76 329.42,79.92 329.42,80.1 329.25,80.27 LN1.4
USB20_P4_R: length 2.2
  BOTTOM w0.152: JNGFF1.3 329.05,83.2 329.13,83.12 329.13,82.7 329.31,82.52 329.31,81.91 LN1.3
USB20_P7: length 142.2
  IN3 w0.089: 101.98,14.16 101.97,14.17 101.96,14.17 101.77,14.36 101.77,15.7 101.48,16 101.03,16 100.85,16.18 100.85,16.36 101.07,16.58 v2(101.13,16.58)
  IN3 w0.099: 101.98,14.16 103.52,12.62 106.27,12.62 106.85,12.04 108.42,12.04 109.83,12.04 110.74,11.12 112.96,11.12 113.87,10.22 114.78,10.22 116.83,12.26 118.39,12.26 120.93,14.81 160.86,14.81 162.49,13.18 218.1,13.18 220.47,10.8 227.19,10.8 227.49,11.11 227.49,11.9 227.37,12.03 227.1,12.03 v2(226.96,11.88)
  BOTTOM w0.089: v2(101.13,16.58) 100.98,16.43 100.98,15.97 100.71,15.71 99.08,15.71 UH2.AB2
  BOTTOM w0.152: v2(226.96,11.88) 227.03,11.81 227.31,11.81 227.47,11.97 227.47,12.06 227.68,12.28 227.68,12.46 227.15,12.99 226.32,12.99 225.75,12.42 ML17.4
USB20_P9: length 254.6
  IN1 w0.107: v2(320.72,46.38) 320.72,46.09 320.36,45.73 320.36,44.81 318.24,42.69 317.73,42.69 315.05,40.01 313.91,40.01 309.72,35.82 309.27,35.82 303.85,30.4 303.85,28.6 300.8,25.55 297.41,25.55 296.38,24.52 293.69,24.52 292.89,25.32 290.05,25.32 287.96,23.22 282.54,23.22 280.87,21.55 278.73,21.55 277.29,20.11 273.85,20.11 273.26,19.52 268.89,19.52 268.09,18.72 268.09,16.77 265.63,14.32 263.49,14.32 262.81,13.64 261.43,13.64 259.57,11.78 252.64,11.78 251.32,13.1 244.44,13.1 243.91,13.63 232.22,13.63 231.94,13.92 215.92,13.92 215.44,14.4 179.88,14.4 179.64,14.17 155.77,14.17 154.64,15.3 151.22,15.3 150.23,16.29 130.34,16.29 128.53,18.11 100.39,18.11 99.57,17.28 99.57,16.8 v2(99.36,16.59)
  BOTTOM w0.089: UH2.AA2 98.93,16.16 v2(99.36,16.59)
  BOTTOM w0.152: LI1.4 329.64,45.08 329.71,45.01 329.71,44.8 329.39,44.47 329.17,44.47 327.22,46.43 320.84,46.43 320.8,46.38 v2(320.72,46.38)
USB20_P9_R: length 10.9
  BOTTOM w0.152: LI1.3 329.64,47.45 329.74,47.56 329.74,47.75 329.57,47.92 329.57,48.38 329.91,48.71 v5(330.34,48.71) 330.85,48.71 331.25,48.32 331.25,47.85 331.55,47.54 331.85,47.54 332.65,48.35 DI3.3 333.01,47.76 333.25,47.52 333.48,47.52 334.01,48.05 334.01,49.07 333.82,49.26 333.82,49.85 333.59,50.09 JTS.5
USB20_P12: length 51.2
  IN1 w0.107: v2(58.26,17.73) 58.65,18.12 59.12,18.12 60.83,16.4 61.95,16.4 62.29,16.75 64.89,16.75 65.26,17.12 71.38,17.12 71.84,16.67 77.21,16.67 78.26,17.72 83.17,17.72 83.71,18.26 91.82,18.26 93.56,16.52 97.41,16.52 97.6,16.33 97.6,15.82 97.92,15.5 98.62,15.5 99.03,15.91 100.26,15.91 100.37,15.8 100.37,15.67 v2(100.01,15.31)
  BOTTOM w0.089: v2(100.01,15.31) 100.27,15.06 100.27,14.9 100.03,14.66 99.23,14.66 99.1,14.79 98.75,14.79 98.65,14.7 98.65,14.6 98.75,14.5 98.9,14.5 UH2.AD2
  BOTTOM w0.152: LV22.4 57.86,19.37 57.86,18.66 57.76,18.55 57.76,18.14 58.18,17.73 v2(58.26,17.73)
USB20_P12_R: length 16.7
  BOTTOM w0.152: JEDP1.32 56.05,32.22 56.22,32.06 56.22,31.22 56.92,30.51 58.4,30.51 59.74,29.17 59.74,27.07 59.63,26.96 58.52,26.96 v1(58.29,26.73) 58.17,26.61 DV12.1 58.17,24.15 58.1,24.08 57.84,24.08 57.84,24.08 57.81,24.08 57.19,23.45 57.19,22.2 57.91,21.48 57.91,21.28 57.79,21.16 LV22.3
USB8723_TEST: length 1.7
  BOTTOM w0.14: UI3.14 323.13,33.14 RI24.1
USB_DET#_L: length 373.9
  TOP w0.14: RE89.2 CE71.1 287.26,4.12 284.28,7.1 v3(284.28,7.25) 283.63,7.9 v2(283.63,10.4)
  IN2 w0.099: v2(279.39,22.06) 278.78,22.06 278.05,21.33 264.75,21.33 264.35,20.93 260.12,20.93 259.61,20.42 257.43,20.42 256.71,21.14 254.91,21.14 252.42,18.65 176.22,18.65 175.66,19.22 173.31,19.22 173.12,19.4 159.31,19.4 158.44,20.27 158.44,24.82 157.25,26.02 156.38,26.02 152.66,29.74 144.77,29.74 140.31,34.2 116.68,34.2 111.33,39.55 100.41,39.55 96.64,35.77 86.63,35.77 83.63,32.77 81.92,32.77 81.6,32.45 52.11,32.45 51.96,32.3 47.32,32.3 46.61,33.01 46.61,33.91 46.11,34.42 40.08,34.42 35.15,39.35 35.15,42.47 34.15,43.47 33.85,43.47 33.13,44.19 32.63,44.19 32.14,44.68 32.14,46.26 32.41,46.54 32.41,46.85 32.02,47.23 32.02,47.89 31.4,48.52 31.4,49.16 30.87,49.68 30,49.68 29.72,49.96 29.45,49.96 28.17,51.24 28.17,66.74 26.88,68.03 26.88,77.47 25.99,78.37 25.99,88.83 27.53,90.38 27.53,102.57 21.88,108.21 14.83,108.21 JUSB1.10
  BOTTOM w0.14: v2(279.39,22.06) 281.22,22.06 282.68,20.59 282.68,18.27 282.3,17.89 282.3,15.16 284,13.47 284,10.77 v2(283.63,10.4)
USB_DET#_R: length 98
  TOP w0.14: v3(286.73,16.2) 286.28,15.76 v2(286.28,15.57) 286.64,15.21 RE54.2 CE37.1 ; QI10.2 317.87,40.04 318.31,39.6 v2(318.31,38.2)
  IN3 w0.091: v2(332.23,59.7) 332.23,60.14 335.22,63.13 335.22,65.98 JUSB2.10
  IN6 w0.099: v2(286.28,15.57) 286.42,15.57 287.51,16.66 290.29,16.66 291.02,15.92 291.02,15.25 291.64,14.64 294.8,14.64 295.09,14.93 301.39,14.93 301.74,15.29 303.72,15.29 304.3,15.86 307.03,15.86 307.49,16.33 311.64,16.33 312.07,16.76 312.07,17.31 315.75,20.99 315.75,27.37 319.18,30.8 319.18,34.24 318.01,35.4 318.01,37.89 v2(318.31,38.2) 318.9,38.78 320.75,38.78 323.17,41.2 323.17,43.33 323.17,43.79 326.3,46.92 326.3,48.21 328.67,50.59 328.67,52.15 332.23,55.71 v2(332.23,59.7)
USB_DET_EC#_L: length 9.2
  TOP w0.14: RE89.1 RE90.2 291.48,5.69 CE70.1 291.48,6.93 v1(292.89,8.34) 292.89,8.98 293.26,9.35 293.26,11.03 293.51,11.29 293.93,11.29 294.01,11.38 UE3.B68
USB_DET_EC#_R: length 16.9
  TOP w0.14: v2(285.56,12.9) 285.56,12.96 286.63,14.03 RE54.1 RE50.2 287.86,14.36 288.6,14.36 CE38.1 ; v2(295.23,14.5) 295.23,14.36 294.74,13.88 UE3.B63
  IN6 w0.099: v2(285.56,12.9) 285.56,13.67 287.25,15.36 288.62,15.36 289.45,14.54 291.31,14.54 291.43,14.42 295.15,14.42 v2(295.23,14.5)
USB_ILIM_SEL: length 82.6
  TOP w0.14: UE4.3 277.23,10.4 v2(276.7,9.86) ; v2(326,43.46) 325.51,42.97 v1(325.02,42.97) 324.74,43.25 RI35.1 324.52,44.22 323.37,44.22 323.03,43.87 DI12.1
  IN6 w0.099: v2(326,43.46) 326,39.59 324.2,37.8 324.2,35.67 323.66,35.13 323.66,33.69 322.04,32.07 322.04,29.93 318.6,26.49 318.6,25.04 318.12,24.55 318.12,20.36 314.17,16.41 314.17,13.24 311.22,10.3 304.03,10.3 303.68,10.65 295.3,10.65 294.51,11.43 293.22,11.43 292.42,10.64 289.13,10.64 288.6,10.1 288.6,9.71 287.78,8.9 284.95,8.9 283.87,9.98 281.95,9.98 281.62,10.31 277.14,10.31 v2(276.7,9.86)
USB_L_CTL: length 5.1
  TOP w0.14: RI4.2 27.98,91.46 UI1.8 ; RI4.2 28.04,90.96 UI1.7 ; RI4.2 28.73,91.66 28.73,93.13 v1(28.64,93.23)
USB_OC0#: length 319
  TOP w0.14: v2(70.47,12.53) 70.47,12.72 v3(70.85,13.1)
  IN1 w0.099: v2(333,63.16) 332.36,62.53 332.36,60.97 331.77,60.38 331.77,57.11 329.8,55.14 329.8,51.1 327.83,49.13 327.83,46.09 325.1,43.36 325.1,37.13 317.96,30 317.96,25.07 315.08,22.18 308.45,22.18 306.77,20.51 301.2,20.51 300.67,19.98 296.23,19.98 296.07,20.14 294.57,20.14 294.36,20.35 291.76,20.35 291.28,19.87 287.14,19.87 285.62,18.35 285.16,18.35 283.82,17.01 278.7,17.01 277.41,15.72 270.54,15.72 266.7,11.88 266.21,11.88 264,9.67 262.53,9.67 261.89,9.04 248.79,9.04 247.97,9.85 233.93,9.85 233.73,9.65 215.27,9.65 213.58,11.35 202,11.35 200.89,10.24 199.98,10.24 199.91,10.31 197.08,10.31 197.03,10.26 188.18,10.26 188.09,10.17 183.8,10.17 183.41,10.55 178.63,10.55 177.59,11.59 154.58,11.59 154.1,12.07 149.47,12.07 149.07,12.48 130.52,12.48 128.31,14.69 105.59,14.69 104.99,14.09 103.41,14.09 102.23,12.9 101.36,12.9 100.73,12.27 99.18,12.27 98.75,12.69 96.5,12.69 95.91,13.28 95.91,13.95 95.35,14.51 92.34,14.51 91.24,13.41 85.01,13.41 84.71,13.11 78.55,13.11 78.14,13.51 71.45,13.51 v2(70.47,12.53)
  BOTTOM w0.089: 75.06,13.7 75.16,13.6 76.71,13.6 77.05,13.94 78.13,13.94 78.51,14.32 UH2.AD43
  BOTTOM w0.127: v2(70.47,12.53) 70.88,12.94 RH552.1 71.35,13.62 72.73,13.62 72.91,13.79 74.96,13.79
  BOTTOM w0.14: v2(333,63.16) 333,64.59 332.8,64.78 332.2,64.78 331.94,64.51 UI2.13 ; 74.96,13.79 75.06,13.7
USB_OC1#: length 143.3
  TOP w0.14: v1(22.61,92.6) 22.61,91.95 v2(22.99,91.58) 23.1,91.46 UI1.13
  IN2 w0.099: v2(22.34,35) 22.86,35 23.28,35.42 30.03,35.42 31.01,34.44 33.26,34.44 34.52,33.18 38.68,33.18 40.31,31.55 44.74,31.55 47.29,29 58.19,29 59.68,27.5 60.96,27.5 63.08,25.38 65.86,25.38 66.51,24.74 74.18,24.74 75.37,23.54 75.37,21.48 73.53,19.64 73.53,15.06 74.44,14.15 76.08,14.15 v2(76.63,14.7)
  IN5 w0.099: v2(22.99,91.58) 23.43,91.13 23.43,85.92 22.59,85.08 22.59,68.89 23.72,67.76 23.72,65.66 24.02,65.36 24.02,65.04 25.08,63.99 25.08,61.38 25.67,60.79 25.67,57.73 25.97,57.43 25.97,55.68 23.78,53.48 23.78,45.64 23.81,45.61 23.81,44.57 23.64,44.4 23.64,44.22 22.85,43.43 22.85,41.59 22.33,41.07 22.33,35 v2(22.34,35)
  BOTTOM w0.089: v2(76.63,14.7) 76.91,14.42 77.84,14.42 77.98,14.56 78.78,14.56 78.89,14.45 UH2.AD42
  BOTTOM w0.127: v2(76.63,14.7) 76.34,14.7 76.26,14.63 75.08,14.63 74.8,14.35 72.82,14.35 72.63,14.17 71.68,14.17 71.33,14.53 71.32,14.53 71.17,14.68 70.73,14.68 RH553.1
USB_OC2#: length 6.9
  TOP w0.089: v2(80.7,13.74) 80.7,15.01 80.17,15.54 v1(77.89,15.54) 76.19,15.54 RH554.1
  BOTTOM w0.089: UH2.AD39 v2(80.7,13.74)
USB_OC3#: length 6.3
  BOTTOM w0.089: 76.26,15.12 76.73,15.12 77.15,14.7 77.85,14.7 77.99,14.84 UH2.AC44
  BOTTOM w0.127: RH555.1 73.46,14.7 v1(74.1,14.7) 74.16,14.64 74.66,14.64 74.88,14.86 ; 76.26,15.12 76.16,15.02 75.05,15.02
  BOTTOM w0.14: 75.05,15.02 74.88,14.86
USB_OC4#: length 7
  BOTTOM w0.089: 75.06,16.84 76.43,16.84 76.48,16.79 77.93,16.79 77.98,16.83 78.4,16.83 UH2.Y43
  BOTTOM w0.127: 75.06,16.84 v1(74.68,16.84) 73.69,16.84 72.67,17.86 RP8.3
USB_OC5#: length 9.9
  TOP w0.089: v2(76.65,16.25) 76.65,16.26 v3(76.11,16.8)
  IN6 w0.089: v2(79.92,17.15) 79.64,16.87 77.25,16.87 76.65,16.26 v2(76.65,16.25)
  BOTTOM w0.089: 75.06,16.48 76.42,16.48 v2(76.65,16.25) ; v2(79.92,17.15) 79.64,16.87 UH2.Y41
  BOTTOM w0.127: 75.03,16.48 73.48,16.48 72.61,17.36 RP8.4
  BOTTOM w0.14: 75.03,16.48 75.06,16.48
USB_OC6#: length 6.7
  BOTTOM w0.089: 75.1,17.26 76.35,17.26 76.63,16.98 77.85,16.98 77.9,17.02 78.2,17.02 UH2.W44
  BOTTOM w0.127: RP8.2 72.78,18.36 v1(73.55,17.59) 73.88,17.26 75.1,17.26
USB_OC7#: length 7.3
  BOTTOM w0.089: UH2.W43 78.67,17.11 78.43,17.34 77.96,17.34 77.85,17.45 77.28,17.45 77.06,17.66 77.04,17.66 77,17.71 v1(75.69,17.71) 75.06,17.71
  BOTTOM w0.127: RP8.1 72.94,18.86 74.09,17.71 75.06,17.71
USB_PWR_EN: length 431.8
  TOP w0.127: v2(108.41,5.29) 108.42,5.28 RH544.1 ; UI4.1 26.15,83.1 25.97,82.93 25.07,82.93 v2(24.87,83.13) 24.61,83.38 v1(24.39,83.38)
  TOP w0.14: UI5.1 324.06,49.3 326.87,46.49 v2(328.93,46.49)
  IN2 w0.089: 33.66,42.33 32.99,42.99 32.98,42.99 32.32,43.65 32.32,43.98 31.45,44.86 31.45,47.13
  IN2 w0.099: v2(59.12,7.48) 58.32,7.48 57.34,8.45 57.34,11.95 59.18,13.79 59.18,19.36 56.71,21.84 56.71,22.6 54.3,25 47.89,25 47.29,25.61 45.2,25.61 42.45,28.35 39.48,28.35 38.12,29.71 37.5,29.71 v2(37.15,29.36) ; v2(24.87,83.13) 24.87,78.92 26.48,77.3 26.48,67.86 27.77,66.57 27.77,51.03 27.93,50.88 27.93,48.4 28.37,47.96 31.01,47.96 31.45,47.52 31.45,47.13 ; 33.66,42.33 34.19,41.8 34.19,40.62 34.24,40.57 34.24,37.84 v2(34.75,37.33)
  IN5 w0.089: 75.06,5.83 75.95,5.83 77.02,4.77 79.43,4.77 79.63,4.96 82.36,4.96 82.56,4.77 86.43,4.77 87.07,4.13 89.35,4.13 90.2,3.28 90.2,2.87 v2(90.33,2.73)
  IN5 w0.099: v2(59.12,7.48) 59.72,6.87 64.95,6.87 65.75,6.07 69.72,6.07 69.96,5.83 75.06,5.83 ; v2(37.15,29.36) 34.75,31.76 v2(34.75,37.33)
  IN6 w0.089: v2(90.33,2.73) 90.34,2.74 90.69,2.74 91.61,3.65 92.15,3.65 92.93,4.43 95.47,4.43 95.58,4.32 97.17,4.32 97.47,4.02 98.55,4.02 99.05,4.52 99.05,5.48 99.89,6.32 101.83,6.32 101.84,6.32 101.98,6.32
  IN6 w0.099: 101.98,6.32 104.63,6.32 104.97,5.98 107.71,5.98 v2(108.41,5.29) 109.19,5.29 109.84,5.94 115.6,5.94 117.43,7.76 127.25,7.76 127.4,7.61 130.13,7.61 130.75,6.99 134.87,6.99 135.89,8.01 144.62,8.01 147.22,5.41 149.8,5.41 150.41,4.79 165.69,4.79 165.91,5.01 174.45,5.01 176.06,6.61 178.23,6.61 179.2,7.58 201.58,7.58 202.58,8.58 205.21,8.58 205.83,9.2 210.77,9.2 213.91,6.06 226.78,6.06 227.96,4.88 239.8,4.88 240.58,4.1 242.67,4.1 243.37,4.8 244.59,4.8 245.39,5.6 261.99,5.6 262.77,6.38 267.68,6.38 268.31,5.74 272.43,5.74 273.49,4.68 281.89,4.68 282.21,4.36 295.53,4.36 295.74,4.57 301.08,4.57 301.67,5.17 302.97,5.17 303.61,4.52 304.05,4.52 304.38,4.86 305.58,4.86 306.36,5.64 306.36,5.95 306.89,6.48 316.14,6.48 319.88,10.22 319.88,22.34 324.46,26.92 324.46,34.75 325.2,35.49 325.2,37.66 328.41,40.87 328.41,45.97 v2(328.93,46.49)
  BOTTOM w0.089: v2(90.33,2.73) 90.34,2.73 90.34,2.74 90.21,2.87 90.21,3.43 90.35,3.57 90.35,4.2 90.16,4.39 90.16,4.76 90.31,4.91 UH2.BC19
USB_PWR_EN_L: length 7.1
  TOP w0.127: UI1.5 27.51,89.96 27.83,89.65 27.83,88.55 27.9,88.48 27.9,87.14 RI26.1
  TOP w0.14: RI26.1 27.45,86.66 UI4.4 27.45,85.02 27.75,84.72 v1(28.53,84.72)
USB_PWR_EN_R: length 22.4
  TOP w0.14: RI28.2 325.62,51.58 325.36,51.84 UI5.4 325.36,52.7 v2(325.53,52.87) 325.78,53.11 RI27.1 326.33,54.04 v1(326.33,55.47)
  BOTTOM w0.14: UI2.5 327.85,63.01 327.68,62.85 327.68,62.6 328.27,62.01 328.27,57.88 330.01,56.14 330.01,52.87 329.28,52.14 328.37,52.14 327.13,53.39 326.05,53.39 v2(325.53,52.87)
USB_PWR_SHR_EN_L#: length 358.8
  TOP w0.127: RI5.2 28.32,90.09 v2(27.93,90.48) 27.92,90.46 UI1.6
  TOP w0.14: v2(292.81,16.04) 292.9,16.13 UE3.A55 ; v2(287.85,20.71) 287.85,21.32 v3(288.86,22.34) 289.27,22.74 v2(289.43,22.74)
  IN2 w0.089: 33.4,46.89 33.17,47.13
  IN2 w0.099: v2(27.93,90.48) 26.19,88.73 26.19,78.45 27.08,77.55 27.08,68.11 28.38,66.82 28.38,51.32 29.53,50.16 29.8,50.16 30.08,49.88 31.8,49.88 32.97,48.72 32.97,47.33 33.17,47.13 ; 33.4,46.89 33.72,46.57 33.72,44.18 35.35,42.56 35.35,39.43 40.16,34.62 46.19,34.62 46.81,34 46.81,33.09 47.4,32.5 51.87,32.5 52.03,32.65 80.84,32.65 81.69,33.51 84.04,33.51 87.24,36.71 95.43,36.71 98.47,39.75 111.41,39.75 116.76,34.4 140.4,34.4 144.86,29.94 152.74,29.94 156.46,26.22 157.47,26.22 159.69,24 159.69,20.28 160.36,19.6 173.2,19.6 173.39,19.42 175.74,19.42 176.26,18.89 252.38,18.89 254.82,21.34 256.79,21.34 257.5,20.63 259.54,20.63 260.04,21.14 264.27,21.14 264.67,21.53 267.58,21.53 268.51,22.46 289.16,22.46 v2(289.43,22.74)
  BOTTOM w0.14: v2(287.85,20.71) 288.04,20.71 288.67,21.34 290.62,21.34 291.88,22.61 291.88,22.96 292.17,23.25 295.26,23.25 295.78,22.73 295.78,21.84 295.77,21.82 295.77,19.68 295.5,19.41 295.5,18.98 295.89,18.59 296.27,18.59 296.61,18.25 296.61,14.52 296.15,14.07 294.78,14.07 v2(292.81,16.04)
USB_PWR_SHR_EN_R#: length 91.7
  TOP w0.14: UE4.19 277.23,17.53 v2(276.63,18.13) 276.63,18.78 v1(276.29,19.12)
  IN6 w0.099: v2(276.63,18.13) 276.63,18.31 277.78,19.45 278.2,19.45 279.33,20.58 281.5,20.58 282.73,21.81 285.88,21.81 286.36,21.33 291.38,21.33 291.55,21.49 293.11,21.49 294.98,23.36 296.9,23.36 297.57,24.03 305.33,24.03 305.93,24.63 305.93,25.14 306.15,25.36 307.26,25.36 307.73,25.83 307.73,27.83 308.8,28.9 308.8,33.91 313.17,38.28 314.38,38.28 319.43,43.33 319.43,43.33 322.97,46.88 322.97,48.32 323.77,49.11 323.77,50.67 324.38,51.28 324.38,52.03 324.29,52.12 324.29,52.47 v2(326.83,55.01)
  BOTTOM w0.14: UI2.6 327.67,63.51 327.44,63.29 327.44,62.46 328.03,61.87 328.03,57.78 329.77,56.04 329.77,53.16 329.44,52.83 RI10.2 328.46,52.83 326.83,54.46 v2(326.83,55.01)
USB_PWR_SHR_VBUS_EN_L: length 318.4
  TOP w0.14: UI4.2 26.8,82.53 RI8.2 26.4,82.14 v2(25.5,82.14) ; v2(277.39,20.87) 278.53,19.73 UE4.17
  IN2 w0.089: 33.66,43.38 33.02,44.01 32.54,44.01
  IN2 w0.099: 33.66,43.38 33.77,43.27 34.07,43.27 34.95,42.39 34.95,39.26 40,34.21 46.02,34.21 46.41,33.83 46.41,32.92 47.99,31.34 49.77,31.34 50.54,32.1 52.04,32.1 52.19,32.25 81.68,32.25 82,32.57 84.73,32.57 87.73,35.57 96.72,35.57 100.48,39.33 111.26,39.33 116.6,33.99 140.22,33.99 144.68,29.54 152.56,29.54 156.28,25.82 157.17,25.82 158.24,24.74 158.24,19.99 159.03,19.2 173.03,19.2 173.34,18.89 175.69,18.89 176.13,18.45 252.5,18.45 254.99,20.94 256.63,20.94 257.38,20.19 259.66,20.19 260.2,20.73 264.43,20.73 264.83,21.13 277.13,21.13 v2(277.39,20.87) ; 32.54,44.01 31.65,44.91 31.65,47.61 31.1,48.16 28.45,48.16 28.13,48.48 28.13,50.96 27.97,51.12 27.97,66.65 26.68,67.95 26.68,77.39 25.5,78.56 v2(25.5,82.14)
USB_PWR_SHR_VBUS_EN_R: length 83.5
  TOP w0.14: RI28.1 326.54,50.12 326.68,49.98 RI13.2 326.68,49.06 326.14,48.52 325.31,48.52 324.71,49.12 UI5.2 324.71,52.27 v2(324.69,52.29) ; UE4.18 277.88,17.52 v2(277.22,18.18) 277.22,18.46 v1(277.69,18.93)
  IN6 w0.099: v2(277.22,18.18) 277.28,18.18 279.48,20.38 281.59,20.38 282.81,21.61 285.79,21.61 286.27,21.13 291.15,21.13 291.64,20.64 292.35,20.64 293,21.29 293.19,21.29 295.06,23.16 296.98,23.16 297.65,23.83 306.03,23.83 307.93,25.73 307.93,27.75 309,28.81 309,32.64 v2(309.46,33.11) 309.46,34.29 313.25,38.08 314.46,38.08 319.63,43.24 319.63,43.25 323.17,46.8 323.17,48.23 323.97,49.03 323.97,50.58 324.69,51.31 v2(324.69,52.29)
  BOTTOM w0.14: DI11.1 313.56,32.28 312.74,33.11 v2(309.46,33.11)
USB_R_CTL: length 11.3
  BOTTOM w0.14: 327.53,64.01 327.53,64.33 327.71,64.51 UI2.8 ; 327.53,64.01 327.15,63.63 v1(327.15,61.83) 327.79,61.2 327.79,57.68 329.06,56.41 RI9.2 ; 327.53,64.01 UI2.7
USB_STATUS#_L: length 394.9
  TOP w0.14: v2(326.26,45.37) 326.26,46.62 324.6,48.28 RI32.2 ; v2(28.58,94.5) v3(27.75,94.5) 27.2,93.95 27.2,92.46 26.53,91.79 26.25,91.79 26.14,91.9 UI1.9
  IN2 w0.099: v2(326.26,45.37) 326.26,45.37 325.35,44.46 325.35,40.12 322.24,37 322.24,36.2 314.5,28.46 310.19,28.46 310.01,28.64 308.92,28.64 308.75,28.46 303,28.46 302.18,27.64 300.79,27.64 300.17,28.26 296.28,28.26 293.86,25.84 293.09,25.84 290.45,23.2 290.45,22.74 289.91,22.2 280.15,22.2 279.19,21.24 278.88,21.24 278.07,20.43 275.28,20.43 274.78,20.93 265.48,20.93 264.79,20.24 263.15,20.24 262.39,19.48 258.03,19.48 257.44,18.89 254.93,18.89 254.26,18.22 176.08,18.22 175.65,18.65 173.3,18.65 173.05,18.91 158.95,18.91 157.97,19.89 157.97,24.73 157.19,25.51 156.3,25.51 152.47,29.34 144.56,29.34 140.51,33.39 116.34,33.39 111.29,38.43 99.86,38.43 96.68,35.25 87.69,35.25 84.46,32.01 78.42,32.01 77.53,31.12 74.73,31.12 73.53,29.92 71.13,29.92 70.17,30.88 53.89,30.88 52.86,31.9 50.62,31.9 49.86,31.14 47.9,31.14 45.91,33.13 v2(45.91,33.75)
  IN5 w0.099: v2(28.58,94.5) 28.78,94.29 28.78,84.16 26.95,82.33 26.95,80.49 26.42,79.96 26.42,68.94 28.49,66.87 28.49,57.77 29.53,56.73 29.53,52.84 33.3,49.07 33.3,47.65 33.72,47.23 33.72,46.45 34.31,45.86 34.31,44.61 35.87,43.05 35.87,40.79 38.98,37.69 38.98,36.53 40.72,34.79 44.88,34.79 v2(45.91,33.75)
USB_STATUS#_R: length 23.1
  TOP w0.14: RI33.2 v2(321.77,48.28) 321.39,48.28 v1(321.18,48.08)
  IN6 w0.099: v2(326.71,62.98) 326.71,62.37 327.92,61.16 327.92,57.06 323.65,52.8 323.65,52.04 323.03,51.42 323.03,50.21 321.77,48.95 v2(321.77,48.28)
  BOTTOM w0.14: UI2.9 329.07,65.01 328.92,64.86 327.67,64.86 326.71,63.89 v2(326.71,62.98)
USBC_MCP23017_SMBCLK: length 33.3
  TOP w0.14: RE109.2 RE21.1 ; RE21.1 294.64,3.62 v3(295.4,2.86) ; RE21.1 295.12,4.66 295.12,5.64 v2(295.25,5.78) ; UE4.8 281.28,12.16 v2(283.01,10.42) ; UE3.B4 296.52,11.1 296.67,11.25 296.67,11.98 v2(296.52,12.14)
  IN3 w0.091: v2(296.52,12.14) 296.66,12 296.66,11.1 295.87,10.31 295.87,6.89 295.25,6.27 v2(295.25,5.78)
  BOTTOM w0.14: v2(296.52,12.14) 296.69,11.97 296.69,11.05 294.97,9.34 294.97,8.91 294.72,8.66 294.23,8.66 293.69,8.13 285.03,8.13 283.01,10.15 v2(283.01,10.42)
USBC_MCP23017_SMBDAT: length 30.4
  TOP w0.14: UE3.A3 296.27,9.43 296.65,9.05 296.65,8.91 296.97,8.59 296.97,8.34 296.84,8.21 v2(296.53,8.21) 296.53,8.52 296.18,8.87 296.08,8.87 295.89,8.68 295.89,8.59 296.04,8.44 296.04,8.22 295.72,7.9 RE20.1 296.1,7.45 296.23,7.32 296.23,6.93 296.36,6.8 296.65,6.8 296.77,6.93 v1(296.77,7.22) 296.93,7.37 297.18,7.37 297.31,7.25 297.31,5.6 297.09,5.37 297.09,4.6 296.67,4.19 RE108.2 ; UE4.9 281.39,12.81 v2(282.65,11.55)
  BOTTOM w0.14: v2(296.53,8.21) 295.92,8.21 295.24,7.53 289.6,7.53 289.49,7.65 284.79,7.65 282.31,10.13 282.31,11.21 v2(282.65,11.55)
USBP1_D+: length 3.8
  BOTTOM w0.152: LI2.4 327.59,66.79 327.68,66.7 327.68,66.38 v1(327.73,66.33) 327.94,66.11 329.44,66.11 329.57,65.98 UI2.10
USBP1_D-: length 3.7
  BOTTOM w0.152: UI2.11 330.07,65.72 329.9,65.89 329.9,66.12 329.58,66.44 v5(329.1,66.44) 328.18,66.44 328.05,66.57 328.05,66.75 328.09,66.79 LI2.1
USBP1_R_D+: length 13.9
  IN3 w0.099: v2(327.67,71.05) 327.84,71.22 327.84,71.46 328.08,71.7 330.23,71.7 331.75,73.22 334.86,73.22 335.59,73.95 JUSB2.3
  BOTTOM w0.152: LI2.3 327.59,68.95 327.58,68.96 327.58,69.58 D123.1 327.72,70.66 327.72,71 v2(327.67,71.05)
USBP1_R_D-: length 13.8
  IN3 w0.099: v2(328.26,71.04) 328.03,71.27 328.03,71.38 328.16,71.51 330.31,71.51 331.83,73.03 334.65,73.03 334.85,72.83 334.85,72.37 335.27,71.95 JUSB2.2
  BOTTOM w0.152: v2(328.26,71.04) 328.05,70.84 328.05,70.14 D124.1 327.92,69.82 327.92,69.1 328.09,68.92 LI2.2
USBP2_D+: length 9.5
  TOP w0.152: UI1.10 25.64,92.59 v2(26.51,93.46)
  IN3 w0.099: v2(26.51,93.46) 26.18,93.13 26.18,93.02 26,92.85 25.61,92.85 25.15,93.32 25.15,96.01 24.36,96.8 v2(23.33,96.8)
  BOTTOM w0.152: LI5.4 22.73,97.17 22.87,97.02 23.1,97.02 v2(23.33,96.8)
USBP2_D-: length 9.2
  TOP w0.152: UI1.11 25.14,92.56 25.88,93.3 v2(25.88,93.46)
  IN3 w0.099: v2(25.88,93.46) 25.99,93.35 25.99,93.1 25.92,93.04 25.69,93.04 25.34,93.39 25.34,96.08 24.44,96.99 23.74,96.99 v2(23.33,97.39)
  BOTTOM w0.152: v2(23.33,97.39) 23.29,97.35 23.01,97.35 22.7,97.67 LI5.1
USBP2_R_D+: length 11.4
  IN2 w0.107: JUSB1.3 14.68,101.39 14.8,101.28 15.11,101.28 15.27,101.44 15.27,101.51 15.8,102.04 16.81,102.04 18.47,100.38 18.47,97.98 18.71,97.74 18.98,97.74 19.18,97.54 v2(19.18,97.54)
  BOTTOM w0.152: LI5.3 20.63,97.17 20.47,97.34 20.25,97.34 D125.1 19.98,97.22 19.61,97.59 19.3,97.59 19.28,97.61 19.24,97.61 v2(19.18,97.54)
USBP2_R_D-: length 11.5
  IN2 w0.107: JUSB1.2 14.68,103.44 15.88,102.24 16.89,102.24 18.67,100.47 18.67,98.07 18.8,97.94 19.06,97.94 19.18,98.05 v2(19.18,98.18)
  BOTTOM w0.152: v2(19.18,98.18) 19.43,97.92 19.75,97.92 D126.1 19.98,98.01 20.32,97.67 LI5.2
VCORE_B+: length 9.7
  BOTTOM w0.508: PR1102.1 118.76,112.42 118.87,112.42 120,113.55 123.06,113.55 124.14,112.47 127.06,112.47
  vias: v2(137.92,119.13) v2(137.92,118.5) v2(138.53,119.08) v2(138.53,118.5) v2(138.56,117.86) v2(139.64,111.6) v2(139.64,110.25) v2(139.64,108.91) v2(139.7,117.21) v2(139.7,115.87) v2(139.7,114.52) v2(140.72,117.21) v2(140.72,115.87) v2(140.72,114.52) v2(140.66,111.6) v2(140.66,110.25) v2(140.66,108.91) v2(141.52,106.75) v2(141.52,106.12) v2(156.28,116.66) v2(156.28,115.64) v2(157.63,116.66) v2(157.63,115.64) v2(158.97,116.66) v2(158.97,115.64) v2(159.64,118.13) v2(160.27,118.13) v2(160.91,118.13) v2(161.54,118.13) v2(162.18,118.13) v3(137.97,119.78)
VFB_1.35V: length 12.8
  TOP w0.14: v1(195.66,110.83) 195.84,111.01 v2(196.15,111.01)
  TOP w0.254: v2(196.15,111.01) 196.33,110.83 PR724.1
  IN3 w0.254: v2(196.15,111.01) 195.84,111.32 195.84,116.63 v2(196.18,116.98)
  BOTTOM w0.254: PR722.2 PR704.2 194.54,118.03 194.82,118.31 PC755.2 195.62,118.31 196.41,117.52 196.41,117.21 v2(196.18,116.98) 195.63,116.43 PU700.1
VGA_CLK_REQ#: length 166
  TOP w0.127: v2(70.46,11.28) 70.88,11.7 RH551.2
  TOP w0.14: v2(198.97,48.98) 198.74,48.98 197.5,50.22 QV103.1
  IN5 w0.089: 101.98,12.4 101.07,11.48 99.15,11.48 98.78,11.85 92.14,11.85 91.49,11.2 91.49,10.16 91.47,10.14 90.78,9.45 89.58,9.45 89.28,9.15 87.97,9.15 87.76,9.36 85.56,9.36 85.08,9.83 84.39,9.83 v2(83.92,9.37) 83.6,9.04 81.54,9.04 81.2,9.38 81.2,9.49 80.87,9.83 79.24,9.83 79.15,9.91 75.06,9.91
  IN5 w0.099: v2(182.44,19.71) 182.44,19.29 175.65,12.5 161.41,12.5 161.13,12.22 149.67,12.22 149.32,11.87 123.14,11.87 122.35,11.09 116.52,11.09 115.55,12.06 114.37,12.06 113.84,11.53 108.47,11.53 107.84,12.16 106.09,12.16 105.78,12.47 102.05,12.47 101.98,12.4 ; 75.06,9.91 72.07,9.91 70.71,11.28 v2(70.46,11.28)
  BOTTOM w0.089: UH2.AR31 84.18,9.14 v2(83.92,9.37)
  BOTTOM w0.14: v2(198.97,48.98) 193.21,48.98 180.91,36.68 180.91,32.04 181.36,31.59 181.36,24.58 180.2,23.42 180.2,21.95 v2(182.44,19.71)
VGA_EDID_CLK: length 4.5
  BOTTOM w0.102: v1(210.38,55.98) 210.38,56.9 210.06,57.22 210.06,58.52 UV18.R2
  BOTTOM w0.14: v1(210.38,55.98) 209.92,55.53 RV572.1
VGA_EDID_DATA: length 5
  BOTTOM w0.102: RV573.1 208.41,55.9 v2(209.39,56.87) 209.86,57.34 209.86,58.6 210.01,58.76 210.01,59.27 UV18.R3
VGA_ID: length 7.2
  TOP w0.14: UE3.A10 299.77,9.27 v2(299.67,9.17) ; RE112.1 299.4,5.39 299.77,5.76 v2(300.17,5.76)
  IN3 w0.091: v2(299.67,9.17) 301.41,7.43 301.41,6.19 300.98,5.76 v2(300.17,5.76)
VR_ON: length 208.9
  TOP w0.14: v2(177.03,21.88) 177.74,21.18 177.74,19.87 178.09,19.52 178.09,16.77 175.53,14.21 v3(175.53,12.59) 175.64,12.48 175.64,5.98 RZ71.1 175.18,5.86 174.66,6.39 UZ12.4 174.43,5.62 174.07,5.27 173.08,5.27 172.78,4.97 172.36,4.97 172.11,5.22 172.11,5.65 171.92,5.84 RZ60.2
  TOP w0.254: PR1118.1 v2(111.99,112.72)
  IN4 w0.089: 137.2,81.3 137.2,80.43 137.67,79.96 137.67,77.58 136.83,76.74 134.62,76.74
  IN4 w0.091: 137.2,81.3 135.78,82.73 135.78,85.23 134.91,86.1 134.91,94.49 135.6,95.19 135.6,99.23 133.34,101.49 129.63,101.49 128.84,102.28 124.49,102.28 123.24,103.53 123.24,108.3 120.42,111.12 113.62,111.12 112.02,112.72 v2(111.99,112.72) ; 134.62,76.74 133.26,76.74 132.21,75.69 132.21,71 132.91,70.3 132.91,68.84 132.02,67.95 132.02,66.4 132.59,65.82 132.59,57.48 125.8,50.69 125.8,46.88 113.62,34.69 113.62,26.35 113.96,26.01 172.91,26.01 v2(177.03,21.88)
VR_SVID_ALERT#: length 28.1
  TOP w0.14: v3(132.42,106.04) 132.42,105.18 RH152.2 RH153.1 133.95,104.8 v2(134.37,104.38) ; v2(115.83,112.72) 115.76,112.66 PR1132.1
  IN4 w0.091: v2(115.83,112.72) 116.1,112.72 116.61,113.23 116.61,113.88 117.24,114.51 122.55,114.51 126.68,110.37 129.1,110.37 134.37,105.1 v2(134.37,104.38)
VR_SVID_ALERT#_C: length 2.6
  TOP w0.14: PU1100.44 116.6,109.92 116.31,110.21 116.31,110.64 PR1132.2
VR_SVID_ALERT#_R: length 34.8
  TOP w0.14: v2(137.53,94.75) 137.48,94.7 v3(137.48,94.12) ; RH153.2 134.07,103.5 v2(134.07,102.35)
  IN2 w0.099: v2(142.01,82.13) 142.01,81.14 141.61,80.73 138.08,80.73 136.98,81.82 135.37,81.82 134.37,82.82 134.37,89.53 137.53,92.68 v2(137.53,94.75)
  IN4 w0.091: v2(134.07,102.35) 137.53,98.89 v2(137.53,94.75)
  BOTTOM w0.076: v2(142.01,82.13) 142.33,81.81 UH1.BH31
VR_SVID_CLK: length 63.2
  TOP w0.14: PR1319.1 PR1131.2 114.44,113.09 v2(114.11,113.42) ; v3(138.49,95.83) 138.23,95.56 v2(138.23,94.75)
  IN2 w0.099: v2(138.23,94.75) 138.23,92.6 134.93,89.3 134.93,83.1 135.74,82.29 137.29,82.29 138.46,81.12 141.38,81.12 141.62,81.36 141.62,82.39 v2(142.01,82.78)
  IN4 w0.091: v2(114.11,113.42) 115.75,115.06 122.82,115.06 126.87,111.01 129.25,111.01 134.95,105.3 134.95,102.31 138.23,99.03 v2(138.23,94.75)
  BOTTOM w0.076: UH1.BH32 142.33,82.46 v2(142.01,82.78)
VR_SVID_CLK_C: length 3.1
  TOP w0.14: PU1100.45 116.2,109.86 115.81,110.25 v1(115.41,110.25) 114.81,110.84 PR1319.2
VR_SVID_DATA: length 60.3
  TOP w0.14: v2(136.83,94.75) 136.65,94.93 v3(136.65,95.77) ; PR1318.1 PR1145.2 116.65,113.13 117.39,113.86 v2(117.45,113.86) ; v2(133.48,102.15) 133.41,102.09 RH151.2
  IN2 w0.099: v2(136.83,94.75) 136.83,92.77 133.82,89.76 133.82,82.59 135,81.41 136.69,81.41 137.77,80.32 141.38,80.32 142.2,79.51 v2(142.95,79.51)
  IN4 w0.091: v2(136.83,94.75) 136.83,98.8 v2(133.48,102.15) 132.96,102.68 132.96,105.62 128.78,109.8 126.43,109.8 122.3,113.93 117.51,113.93 v2(117.45,113.86)
  BOTTOM w0.076: v2(142.95,79.51) 142.95,80.04 UH1.BH29
VR_SVID_DATA_C: length 2.4
  TOP w0.14: PU1100.43 v1(117,110.13) 117,110.84 PR1318.2
VREF_NVVDD: length 5.4
  TOP w0.254: PR1005.1 167.39,117.04 167.6,116.82 v1(167.92,116.82) 168.31,116.82 v2(168.73,117.24)
  BOTTOM w0.203: PU1001.8 168.21,116.72 v2(168.73,117.24) 169.39,117.24 169.48,117.34 PC1005.1
VREF_NVVDDS: length 3.4
  TOP w0.254: PC1501.1 177.2,114.99 PR1505.1 177.41,114.88 177.93,115.4 v2(178.23,115.4)
  BOTTOM w0.203: v2(178.23,115.4) PU1501.8
VSET AUDIO: length 3.4
  BOTTOM w0.108: v1(2.73,14.64) 2.83,14.74 UA3.4 3.94,15.96 RA80.1 RA79.2
VSET_5085: length 4.1
  TOP w0.14: UE3.A17 304.77,11.63 305.02,11.38 305.02,10.28 v1(305.4,9.9) 305.61,9.9 305.79,10.08 CE41.1 RE58.1
WLAN_CLK_REQ#: length 368.5
  TOP w0.14: v3(337.76,85.23) 337.76,86.15 338.61,87 v2(338.63,87) ; RP2.5 67.33,5.14 66.96,4.77 66.73,4.77 v2(66.42,4.45)
  IN5 w0.089: 75.06,4.76 75.09,4.76 75.62,4.23 79.65,4.23 79.85,4.43 82.14,4.43 82.34,4.23 86.21,4.23 86.85,3.59 87.14,3.59 87.98,2.76 v2(87.98,2.52)
  IN5 w0.099: v2(66.42,4.45) 67.44,5.47 69.47,5.47 69.71,5.23 74.59,5.23 75.06,4.76
  IN6 w0.089: v2(87.98,2.52) 87.98,3.26 88.76,4.04 92.26,4.04 92.83,4.61 95.54,4.61 95.65,4.5 97.24,4.5 97.55,4.2 98.47,4.2 98.87,4.59 98.87,5.55 99.82,6.5 101.75,6.5 101.78,6.53 101.98,6.53
  IN6 w0.099: v2(338.63,87) 338.61,87 337.31,85.71 337.31,83.16 334.76,80.61 334.76,65.52 336.92,63.36 336.92,57.69 332.09,52.86 332.09,50.44 328.21,46.56 328.21,40.96 325,37.75 325,35.58 324.26,34.83 324.26,31.01 320.82,27.57 320.82,24.82 319.68,23.68 319.68,10.31 316.06,6.68 306.81,6.68 306.16,6.04 306.16,5.73 305.68,5.24 304.55,5.24 304.42,5.37 301.42,5.37 300.83,4.77 295.65,4.77 295.45,4.57 282.29,4.57 281.98,4.88 273.58,4.88 272.52,5.94 268.4,5.94 267.73,6.61 262.72,6.61 261.91,5.8 245.31,5.8 244.59,5.08 228.05,5.08 226.86,6.26 214.03,6.26 210.28,10.01 203.04,10.01 201.57,8.54 200.13,8.54 199.37,7.78 179.12,7.78 178.15,6.82 175.98,6.82 174.99,5.82 172.41,5.82 171.8,5.21 165.82,5.21 165.61,4.99 150.5,4.99 149.88,5.61 147.31,5.61 144.7,8.21 135.81,8.21 134.79,7.19 130.84,7.19 130.22,7.81 127.48,7.81 127.33,7.96 117.34,7.96 115.56,6.18 105.05,6.18 104.71,6.53 101.98,6.53
  BOTTOM w0.089: v2(87.98,2.52) 87.97,2.52 87.87,2.62 87.87,3.54 87.71,3.71 87.71,4.39 UH2.BD25
  BOTTOM w0.14: JNGFF1.45 341.55,87.21 341.2,87.56 339.19,87.56 v2(338.63,87)
WLAN_WIGIG60GHZ_DIS#: length 109.6
  TOP w0.14: v2(274.41,17.92) 273.79,17.92 v1(273.13,17.26) RE71.2 273.34,16.06 UE4.22
  IN6 w0.099: v2(274.41,17.92) 276.15,19.65 278.12,19.65 278.59,20.13 279.31,20.84 281.48,20.84 282.64,22.01 285.96,22.01 286.44,21.53 291.3,21.53 291.46,21.69 293.02,21.69 294.9,23.56 296.82,23.56 297.49,24.23 305.25,24.23 305.73,24.72 305.73,25.22 306.07,25.56 307.18,25.56 307.53,25.91 307.53,28 308.6,29.07 308.6,33.99 313.08,38.48 314.29,38.48 322.77,46.96 322.77,49.67 323.23,50.12 323.23,51.33 323.85,51.96 323.85,52.71 328.15,57.01 328.15,61.21 327.13,62.23 327.13,69.61 326.54,70.19 326.54,72.04 329.33,74.83 329.33,77.52 327.09,79.77 v2(327.09,81.1)
  BOTTOM w0.14: DN1.1 326.9,81.29 v2(327.09,81.1)
WLAN_WIGIG60GHZ_DIS#_R: length 21.8
  TOP w0.14: v2(328.36,82.5) 328.36,83.22 v1(328.38,83.24)
  IN2 w0.099: v2(341.26,88.91) 339.28,88.91 338.89,88.52 334.57,88.52 332.94,86.9 332.94,83.75 332.26,83.07 328.93,83.07 v2(328.36,82.5)
  BOTTOM w0.14: v2(328.36,82.5) 328.3,82.43 DN1.2 ; v2(341.26,88.91) 342.3,89.95 JNGFF1.48
XDP_BPM#0: length 24
  TOP w0.089: 134.62,78.46 134.85,78.23 v2(134.85,78.02)
  TOP w0.14: v2(126.39,90.09) 126.53,90.09 126.95,90.51 JXDP.21 ; 134.62,78.46 v3(134.56,78.52)
  IN2 w0.089: v2(134.85,78.02) 134.62,78.25
  IN2 w0.099: v2(126.39,90.09) 126.92,89.56 126.92,89.27 126.54,88.88 126.23,88.88 125.85,88.51 125.85,88.05 129.11,84.8 129.11,82.33 129.38,82.06 129.72,82.06 131.69,80.09 131.69,79.67 132.92,78.43 134.44,78.43 134.62,78.25
  BOTTOM w0.076: v2(134.85,78.02) 135.37,78.54 137.12,78.54 137.21,78.46 137.77,78.46 UH1.BR27
XDP_BPM#1: length 25.1
  TOP w0.14: v2(134.25,78.01) 133.11,79.16 v3(132.83,79.16) ; v2(126.39,90.69) 126.71,91.01 JXDP.23
  IN2 w0.099: v2(126.39,90.69) 125.98,90.27 125.98,88.91 125.65,88.59 125.65,87.97 128.91,84.72 128.91,82.25 129.3,81.86 129.64,81.86 131.49,80.01 131.49,79.58 133.47,77.61 133.85,77.61 v2(134.25,78.01)
  BOTTOM w0.076: UH1.BT27 137.38,78.71 134.95,78.71 134.62,78.38
  BOTTOM w0.14: 134.62,78.38 v2(134.25,78.01)
XDP_DBRESET#: length 18.8
  TOP w0.14: v3(128.66,106.21) 128.66,105.07 129.11,104.63 129.11,102.95 127.47,101.31 126.05,101.31 125.2,100.46 v2(125.2,96.02) 124.21,97.01 JXDP.48
  BOTTOM w0.14: v2(125.2,96.02) 125.2,95.94 124.72,95.46 RH8.1 RH5.2 CH175.1
XDP_PLTRST#: length 7.7
  TOP w0.14: JXDP.46 121.42,96.51 121.16,96.24 120.68,96.24 120.32,95.88 118.76,95.88 RH492.2 RH479.2 RH480.2 117.65,92.87 v1(117.65,92.59)
XDP_PRDY#: length 125.9
  TOP w0.089: v2(136.04,78) 136.04,78.2 v3(136.32,78.48)
  TOP w0.14: v2(126.3,88.24) 126.3,87 126.8,86.51 JXDP.5
  IN2 w0.102: v2(126.3,88.24) 126.3,87.98 128.05,86.24 128.67,86.24 129.97,84.94 129.97,82.1 131.89,80.18 131.89,79.75 133.01,78.63 135.41,78.63 v2(136.04,78)
  IN4 w0.089: v2(136.04,78) 135.41,77.36 134.62,77.36
  IN4 w0.091: v2(111.39,16.67) 111.8,16.26 112.21,16.26 112.38,16.43 112.38,18.21 111.82,18.77 111.82,26.28 112.28,26.74 112.28,34.29 125.23,47.23 125.23,51.26 132.01,58.05 132.01,65.29 130.98,66.32 130.98,75.28 133.07,77.36 134.62,77.36
  BOTTOM w0.076: UH1.BP27 138.26,78.29 137.07,78.29 136.98,78.38 136.42,78.38 v2(136.04,78)
  BOTTOM w0.089: 100,8.53 99.11,8.53 99.06,8.49 98.26,8.49 98.15,8.59 UH2.AT4
  BOTTOM w0.102: 101.73,7.64 100.89,7.64 100,8.53
  BOTTOM w0.14: v2(111.39,16.67) 112.4,15.66 112.84,15.66 114.26,14.24 114.26,12.48 112.11,10.34 112.11,7.56 110.81,6.25 108.41,6.25 107.03,7.64 104.85,7.64 104.38,7.17 102.2,7.17 101.73,7.64
XDP_PREQ#: length 128.6
  TOP w0.089: v3(136.78,81.41) v2(136.78,80.8)
  TOP w0.14: JXDP.3 130.03,86.01 130.63,86.61 v2(131.22,86.61)
  IN2 w0.089: 134.62,80.85 136.72,80.85 v2(136.78,80.8)
  IN2 w0.099: 134.62,80.85 134.27,80.85 132.08,83.04 132.08,84.9 131.5,85.48 131.5,86.33 v2(131.22,86.61)
  IN4 w0.089: v2(136.78,80.8) 136.78,80.4 137.43,79.75 137.43,77.75 136.61,76.93 134.62,76.93
  IN4 w0.091: 134.62,76.93 133.18,76.93 131.98,75.74 131.98,70.91 132.71,70.18 132.71,68.96 131.71,67.95 131.71,66.44 132.4,65.74 132.4,57.67 125.61,50.88 125.61,46.96 113.41,34.76 113.41,17.06 v2(113.01,16.66)
  BOTTOM w0.076: UH1.BL30 140.32,80.65 136.92,80.65 v2(136.78,80.8) 135.91,80.8 135.55,80.43 134.62,80.43
  BOTTOM w0.089: 101.98,6.71 101.51,7.18 100.66,7.18 100.3,7.55 99.7,7.55 99.62,7.63 99.4,7.63 99.06,7.97 98.48,7.97 UH2.AT3
  BOTTOM w0.14: 134.62,80.43 133.87,80.43 133.74,80.31 132.15,80.31 RH156.2 ; v2(113.01,16.66) 114.81,14.86 114.81,12.35 113.34,10.88 113.34,8.03 112.81,7.51 112.74,7.51 111.01,5.77 108.21,5.77 107.75,6.23 106.81,6.23 105.88,7.16 105.2,7.16 104.72,6.68 102.01,6.68 101.98,6.71
XDP_PWRGOOD: length 6.9
  TOP w0.14: JXDP.39 129.23,95.01 129.6,94.64 129.6,93.16 129.95,92.82 129.95,92.35 RH481.2 RH482.2 131.66,90.97 v1(131.76,90.86)
XDP_TDI: length 26.4
  TOP w0.14: JXDP.56 121.39,99.01 121.08,98.7 v2(120.98,98.7) ; v2(136.18,98) 136.02,98 v3(135.46,98.56)
  IN3 w0.091: v2(120.98,98.7) 121.97,98.7 123.55,97.12 124.26,97.12 125,97.86 127.89,97.86 129.02,96.73 129.93,96.73 130.96,95.7 132.41,95.7 132.6,95.89 132.6,96.22 134.38,98 v2(136.18,98)
  BOTTOM w0.14: v2(136.18,98) 135.93,97.75 RH541.1 ; v2(120.98,98.7) 120.98,97.67 120,96.69 120,96.39 119.7,96.09 118.99,96.09 RH477.1
XDP_TDO: length 22.7
  TOP w0.14: JXDP.52 121.39,98.01 120.98,97.6 v2(120.98,96.67) ; v2(132.28,98.73) 132.28,98.16 132.5,97.94 v3(133.27,97.94)
  IN4 w0.091: v2(132.28,98.73) 131.45,99.56 131.09,99.56 129.85,100.81 122.37,100.81 121.58,100.02 121.58,97.27 v2(120.98,96.67)
  BOTTOM w0.14: RH478.1 120.14,95.83 120.98,96.67 v2(120.98,96.67) ; RH540.1 132.49,97.75 132.28,97.96 v2(132.28,98.73)
XDP_TMS: length 24.9
  TOP w0.14: JXDP.58 121.23,99.51 v2(121.02,99.3) ; v2(131.33,94.33) 131.68,93.98 131.68,93.79 132.16,93.32 v1(133.1,93.32)
  IN2 w0.254: v2(131.33,94.33) 130.3,94.33 127.01,97.62 125.95,97.62 124.65,96.33 124.65,96.04 124.29,95.68 123.61,95.68 122.19,97.1 122.19,98.76 121.65,99.3 v2(121.02,99.3)
  BOTTOM w0.14: v2(121.02,99.3) 121.41,98.91 121.41,97.76 120.24,96.59 120.24,96.29 119.8,95.85 119.64,95.85 RH12.1 ; v2(131.33,94.33) 130.8,94.33 RH542.1
XDP_TRST#: length 24.5
  TOP w0.14: JXDP.54 121.4,98.51 120.42,97.53 120.42,96.48 v1(120.23,96.29) 119.85,96.29 v2(119.57,96.57)
  IN6 w0.099: v2(119.57,96.57) 120.04,96.1 121.12,96.1 121.12,96.09 121.75,96.09 122.32,95.52 122.32,87.36 126.86,82.83 v2(127.97,82.83)
  BOTTOM w0.14: RH543.1 128.38,82.83 v2(127.97,82.83)
XTAL24_IN: length 6
  TOP w0.089: v2(101.47,26.82) 101.47,27.06 101.73,27.31
  TOP w0.14: 101.73,27.31 101.86,27.44 RA96.2
  BOTTOM w0.089: v2(101.47,26.82) 101.22,26.82 100.98,27.06 99.63,27.06 98.87,26.3 97.6,26.3 97.05,25.75 UH2.A6
XTAL24_IN_R: length 3
  TOP w0.14: RA96.1 102.53,26.97 102.36,26.81 RH72.1 102.48,26.64 CH47.1 103.52,26.64 YH2.1
XTAL24_OUT: length 6.1
  TOP w0.089: 101.98,25.18 101.91,25.25 101.91,25.86 101.59,26.18 v2(101.34,26.18)
  TOP w0.14: 101.98,25.18 RA97.2
  BOTTOM w0.089: UH2.A5 97.49,25.75 97.68,25.94 97.68,25.94 97.82,26.08 99.18,26.08 99.86,26.76 101.02,26.76 101.34,26.43 v2(101.34,26.18)
XTAL24_OUT_R: length 5.4
  TOP w0.14: YH2.3 104.88,26.3 103.47,26.3 CH48.1 102.79,26.03 102.65,26.17 RH72.2 102.36,25.84 102.61,25.59 RA97.1
XTAL_25_IN: length 2.6
  BOTTOM w0.14: YT1.1 21.87,32.29 CT43.1 21.8,32.13 21.61,31.93 21.61,31.93 21.49,31.82 21.49,31.82 21.44,31.77 RA98.2
XTAL_25_IN_R: length 5
  BOTTOM w0.102: UT1.D22 23.12,35.84 23.12,34.71 22.78,34.37 22.04,34.37 21.97,34.3
  BOTTOM w0.14: 21.97,34.3 21.91,34.24 21.91,33.03 21.28,32.4 RA98.1
XTAL_25_OUT: length 2
  BOTTOM w0.14: YT1.3 25.64,31.77 25.98,32.12 CT44.1 26.49,32.13 RA99.2
XTAL_25_OUT_R: length 4.6
  BOTTOM w0.102: UT1.D23 23.35,35.33 23.49,35.2 24.94,35.2 25.77,34.36 26.02,34.36 26.08,34.3
  BOTTOM w0.14: 26.08,34.3 26.49,33.89 RA99.1
XTAL_OUT: length 10.5
  TOP w0.14: v2(218.19,53.09) 218.26,53.02 RV585.2 218.26,51.15 CV858.2 219.03,50.33 YV1.3
  BOTTOM w0.14: UV18.H2 216.51,58.9 216.98,58.42 216.98,55.66 217.88,54.76 v5(217.88,54.14) 217.88,53.4 v2(218.19,53.09)
XTALIN: length 13.7
  TOP w0.14: v2(217.23,52.97) 217.35,52.85 RV585.1 217.35,51.15 CV857.2 217.37,50.72 217.81,50.29 217.81,48.97 216.83,47.99 YV1.1
  BOTTOM w0.14: UV18.H3 215.97,59.7 215.84,59.57 215.84,58.72 216.07,58.49 216.4,58.49 216.65,58.24 v5(216.65,55.93) 216.65,55.52 217.01,55.16 217.18,54.99 217.55,54.62 217.55,53.29 v2(217.23,52.97)
XTALOUT: length 14.5
  TOP w0.14: RV581.1 220.79,50.49 220.2,51.08 220.2,51.58 219.96,51.82 219.96,52.95 217.34,55.57 215.77,55.57 214.76,56.59 214.76,57.47 v1(214.62,57.61) 214.5,57.73 214.5,59.58 v2(215.01,60.09)
  BOTTOM w0.102: v2(215.01,60.09) 215.42,60.5 UV18.J4
XTALSSIN: length 8.7
  TOP w0.14: RV579.1 220.65,52.82 220.71,52.88 220.71,54.19 v1(220.27,54.63) 218.54,56.37 217.46,56.37 216.96,56.87 216.45,56.87 v2(216.12,57.19)
  BOTTOM w0.102: v2(216.12,57.19) 216.24,57.3 UV18.H1
N06747: length 4.8
  TOP w0.14: CA77.1 4.83,34.57 4.83,35.31 4.53,35.61 CA130.1 4.22,35.61 3.62,36.2 v2(3.49,36.2)
  BOTTOM w0.14: UA1.18 4.38,36.92 v1(3.94,36.48) 3.66,36.2 v2(3.49,36.2)
N06883: length 4
  BOTTOM w0.203: UA1.43 12.53,40.92 12.68,41.07 12.68,41.6 12.55,41.73 12.55,42.72 12.99,43.16 CA24.1 12.99,44.29 CA25.1
N07271: length 4.8
  TOP w0.14: v1(3.94,38.44) 3.73,38.24 v2(2.93,38.24) 2.82,38.12 CA26.1 2.82,37.31 2.73,37.22 CA27.1
  BOTTOM w0.14: v2(2.93,38.24) 3.16,38.47 4.6,38.47 4.61,38.48 4.62,38.48 4.66,38.52 UA1.22
N09031: length 11.4
  TOP w0.14: RA7.2 RA4.2 RA57.1 CA19.1 v1(2.24,34.26) 2.24,38.12 v2(2.35,38.24)
  BOTTOM w0.14: CA16.1 2.25,38.34 v2(2.35,38.24)
