# Allegro board Dell XPS 9560 LA-E331P R10.brd (continued)
## Nets (continued)
FBA_D33: UV18.AF29 UV24.U2
FBA_D34: UV18.AG29 UV24.T4
FBA_D35: UV18.AF28 UV24.T2
FBA_D36: UV18.AD30 UV24.N4
FBA_D37: UV18.AD29 UV24.N2
FBA_D38: UV18.AC29 UV24.M4
FBA_D39: UV18.AD28 UV24.M2
FBA_D40: UV18.AJ29 UV24.U11
FBA_D41: UV18.AK29 UV24.U13
FBA_D42: UV18.AJ30 UV24.T11
FBA_D43: UV18.AK28 UV24.T13
FBA_D44: UV18.AM29 UV24.N11
FBA_D45: UV18.AM31 UV24.N13
FBA_D46: UV18.AN29 UV24.M11
FBA_D47: UV18.AM30 UV24.M13
FBA_D48: UV18.AN31 UV24.A11
FBA_D49: UV18.AN32 UV24.A13
FBA_D50: UV18.AP30 UV24.B11
FBA_D51: UV18.AP32 UV24.B13
FBA_D52: UV18.AM33 UV24.E11
FBA_D53: UV18.AL31 UV24.E13
FBA_D54: UV18.AK33 UV24.F11
FBA_D55: UV18.AK32 UV24.F13
FBA_D56: UV18.AD34 UV24.A4
FBA_D57: UV18.AD32 UV24.A2
FBA_D58: UV18.AC30 UV24.B4
FBA_D59: UV18.AD33 UV24.B2
FBA_D60: UV18.AF31 UV24.E4
FBA_D61: UV18.AG34 UV24.E2
FBA_D62: UV18.AG32 UV24.F4
FBA_D63: UV18.AG33 UV24.F2
FBA_DBI0#: UV18.P30 UV23.D2
FBA_DBI1#: UV18.F31 UV23.D13
FBA_DBI2#: UV18.F34 UV23.P13
FBA_DBI3#: UV18.M32 UV23.P2
FBA_DBI4#: UV18.AD31 UV24.P2
FBA_DBI5#: UV18.AL29 UV24.P13
FBA_DBI6#: UV18.AM32 UV24.D13
FBA_DBI7#: UV18.AF34 UV24.D2
FBA_EDC0: UV18.M31 UV23.C2
FBA_EDC1: UV18.G31 UV23.C13
FBA_EDC2: UV18.E33 UV23.R13
FBA_EDC3: UV18.M33 UV23.R2
FBA_EDC4: UV18.AE31 UV24.R2
FBA_EDC5: UV18.AK30 UV24.R13
FBA_EDC6: UV18.AN33 UV24.C13
FBA_EDC7: UV18.AF33 UV24.C2
FBA_MA0_MA10_H: UV18.Y30 UV24.K4
FBA_MA0_MA10_L: UV18.V30 UV23.H4
FBA_MA1_MA9_H: UV18.AA34 UV24.K5
FBA_MA1_MA9_L: UV18.U34 UV23.H5
FBA_MA2_BA0_H: UV18.AA28 UV24.K11
FBA_MA2_BA0_L: UV18.U29 UV23.H11
FBA_MA3_BA3_H: UV18.AA29 UV24.K10
FBA_MA3_BA3_L: UV18.T31 UV23.H10
FBA_MA4_BA2_H: UV18.AC34 UV24.H11
FBA_MA4_BA2_L: UV18.R34 UV23.K11
FBA_MA5_BA1_H: UV18.AC33 UV24.H10
FBA_MA5_BA1_L: UV18.R33 UV23.K10
FBA_MA6_MA11_H: UV18.Y28 UV24.H5
FBA_MA6_MA11_L: UV18.U28 UV23.K5
FBA_MA7_MA8_H: UV18.AA33 UV24.H4
FBA_MA7_MA8_L: UV18.U33 UV23.K4
FBA_MA12_RFU_H: UV18.W31 UV24.J5
FBA_MA12_RFU_L: UV18.V29 UV23.J5
FBA_RAS#_H: UV18.Y31 UV24.L3
FBA_RAS#_L: UV18.U31 UV23.G3
FBA_RST#_H: RV613.1 UV18.Y34 UV24.J2
FBA_RST#_L: RV614.1 UV18.V34 UV23.J2
FBA_WCK0: UV18.K31 UV23.D4
FBA_WCK0_N: UV18.L30 UV23.D5
FBA_WCK1: UV18.H34 UV23.P4
FBA_WCK1_N: UV18.J34 UV23.P5
FBA_WCK2: UV18.AG30 UV24.P4
FBA_WCK2_N: UV18.AG31 UV24.P5
FBA_WCK3: UV18.AJ34 UV24.D4
FBA_WCK3_N: UV18.AK34 UV24.D5
FBA_WE#_H: UV18.AA32 UV24.G12
FBA_WE#_L: UV18.U32 UV23.L12
FBC_ABI#_H: UV18.G17 UV26.J4
FBC_ABI#_L: UV18.F15 UV25.J4
FBC_CAS#_H: UV18.E17 UV26.G3
FBC_CAS#_L: UV18.C17 UV25.L3
FBC_CKE_H: RV608.2 UV18.B17 UV26.J3
FBC_CKE_L: RV606.2 UV18.B15 UV25.J3
FBC_CLK0: RV629.1 UV18.D12 UV25.J12
FBC_CLK0#: RV628.1 UV18.E12 UV25.J11
FBC_CLK1: RV638.1 UV18.E20 UV26.J12
FBC_CLK1#: RV637.1 UV18.F20 UV26.J11
FBC_CS#_H: UV18.D18 UV26.L12
FBC_CS#_L: UV18.D13 UV25.G12
FBC_D0: UV18.G9 UV25.A4
FBC_D1: UV18.E9 UV25.A2
FBC_D2: UV18.G8 UV25.B4
FBC_D3: UV18.F9 UV25.B2
FBC_D4: UV18.F11 UV25.E4
FBC_D5: UV18.G11 UV25.E2
FBC_D6: UV18.F12 UV25.F4
FBC_D7: UV18.G12 UV25.F2
FBC_D8: UV18.G6 UV25.A11
FBC_D9: UV18.F5 UV25.A13
FBC_D10: UV18.E6 UV25.B11
FBC_D11: UV18.F6 UV25.B13
FBC_D12: UV18.F4 UV25.E11
FBC_D13: UV18.G4 UV25.E13
FBC_D14: UV18.E2 UV25.F11
FBC_D15: UV18.F3 UV25.F13
FBC_D16: UV18.C2 UV25.U11
FBC_D17: UV18.D4 UV25.U13
FBC_D18: UV18.D3 UV25.T11
FBC_D19: UV18.C1 UV25.T13
FBC_D20: UV18.B3 UV25.N11
FBC_D21: UV18.C4 UV25.N13
FBC_D22: UV18.B5 UV25.M11
FBC_D23: UV18.C5 UV25.M13
FBC_D24: UV18.A11 UV25.U4
FBC_D25: UV18.C11 UV25.U2
FBC_D26: UV18.D11 UV25.T4
FBC_D27: UV18.B11 UV25.T2
FBC_D28: UV18.D8 UV25.N4
FBC_D29: UV18.A8 UV25.N2
FBC_D30: UV18.C8 UV25.M4
FBC_D31: UV18.B8 UV25.M2
FBC_D32: UV18.F24 UV26.U4
FBC_D33: UV18.G23 UV26.U2
FBC_D34: UV18.E24 UV26.T4
FBC_D35: UV18.G24 UV26.T2
FBC_D36: UV18.D21 UV26.N4
FBC_D37: UV18.E21 UV26.N2
FBC_D38: UV18.G21 UV26.M4
FBC_D39: UV18.F21 UV26.M2
FBC_D40: UV18.G27 UV26.U11
FBC_D41: UV18.D27 UV26.U13
FBC_D42: UV18.G26 UV26.T11
FBC_D43: UV18.E27 UV26.T13
FBC_D44: UV18.E29 UV26.N11
FBC_D45: UV18.F29 UV26.N13
FBC_D46: UV18.E30 UV26.M11
FBC_D47: UV18.D30 UV26.M13
FBC_D48: UV18.A32 UV26.A11
FBC_D49: UV18.C31 UV26.A13
FBC_D50: UV18.C32 UV26.B11
FBC_D51: UV18.B32 UV26.B13
FBC_D52: UV18.D29 UV26.E11
FBC_D53: UV18.A29 UV26.E13
FBC_D54: UV18.C29 UV26.F11
FBC_D55: UV18.B29 UV26.F13
FBC_D56: UV18.B21 UV26.A4
FBC_D57: UV18.C23 UV26.A2
FBC_D58: UV18.A21 UV26.B4
FBC_D59: UV18.C21 UV26.B2
FBC_D60: UV18.B24 UV26.E4
FBC_D61: UV18.C24 UV26.E2
FBC_D62: UV18.B26 UV26.F4
FBC_D63: UV18.C26 UV26.F2
FBC_DBI0#: UV18.E11 UV25.D2
FBC_DBI1#: UV18.E3 UV25.D13
FBC_DBI2#: UV18.A3 UV25.P13
FBC_DBI3#: UV18.C9 UV25.P2
FBC_DBI4#: UV18.F23 UV26.P2
FBC_DBI5#: UV18.F27 UV26.P13
FBC_DBI6#: UV18.C30 UV26.D13
FBC_DBI7#: UV18.A24 UV26.D2
FBC_EDC0: UV18.D10 UV25.C2
FBC_EDC1: UV18.D5 UV25.C13
FBC_EDC2: UV18.C3 UV25.R13
FBC_EDC3: UV18.B9 UV25.R2
FBC_EDC4: UV18.E23 UV26.R2
FBC_EDC5: UV18.E28 UV26.R13
FBC_EDC6: UV18.B30 UV26.C13
FBC_EDC7: UV18.A23 UV26.C2
FBC_MA0_MA10_H: UV18.D16 UV26.K4
FBC_MA0_MA10_L: UV18.D15 UV25.H4
FBC_MA1_MA9_H: UV18.A18 UV26.K5
FBC_MA1_MA9_L: UV18.A14 UV25.H5
FBC_MA2_BA0_H: UV18.F18 UV26.K11
FBC_MA2_BA0_L: UV18.F14 UV25.H11
FBC_MA3_BA3_H: UV18.E18 UV26.K10
FBC_MA3_BA3_L: UV18.E14 UV25.H10
FBC_MA4_BA2_H: UV18.A20 UV26.H11
FBC_MA4_BA2_L: UV18.A12 UV25.K11
FBC_MA5_BA1_H: UV18.B20 UV26.H10
FBC_MA5_BA1_L: UV18.B12 UV25.K10
FBC_MA6_MA11_H: UV18.G18 UV26.H5
FBC_MA6_MA11_L: UV18.G15 UV25.K5
FBC_MA7_MA8_H: UV18.B18 UV26.H4
FBC_MA7_MA8_L: UV18.B14 UV25.K4
FBC_MA12_RFU_H: UV18.F17 UV26.J5
FBC_MA12_RFU_L: UV18.E15 UV25.J5
FBC_RAS#_H: UV18.D17 UV26.L3
FBC_RAS#_L: UV18.D14 UV25.G3
FBC_RST#_H: RV615.1 UV18.A17 UV26.J2
FBC_RST#_L: RV616.1 UV18.A15 UV25.J2
FBC_WCK0: UV18.F8 UV25.D4
FBC_WCK0_N: UV18.E8 UV25.D5
FBC_WCK1: UV18.A5 UV25.P4
FBC_WCK1_N: UV18.A6 UV25.P5
FBC_WCK2: UV18.D24 UV26.P4
FBC_WCK2_N: UV18.D25 UV26.P5
FBC_WCK3: UV18.B27 UV26.D4
FBC_WCK3_N: UV18.C27 UV26.D5
FBC_WE#_H: UV18.C18 UV26.G12
FBC_WE#_L: UV18.C14 UV25.L12
FBVDD_EN: DV13.1 PR706.1 QZ6.5 RV550.1
FBVDDQ_SENSE: PR730.1 UV18.F1
FCCM_GT: PU1100.11 PU1300.2 PU1301.2
FCCM_SA: PU1100.34 PU1302.7
FCCM_VCORE: PU1100.24 PU1200.2 PU1201.2 PU1202.2
FFS_INT1: RF4.2 UF1.11 UH2.AW17
FFS_INT2: QF1.2 RF5.2 UF1.9 UH2.AN41
FFS_INT2_Q: JHDD.11 QF1.3 RD100.2 RF2.2
FRM_LCK: RV564.1 RV1100.2
FWP#: RE68.2 RE70.2 UE3.B65
GC5_MODE: RV1088.2 T210.1(TP-1)
GC6_EVENT#_D: DV14.2 RV551.1 RV1097.2 RV1120.2
GPU_CORE_PG: DV16.3 PR1017.2 RV1522.2 UV28.2
GPU_CORE_VDDS_PG: PR986.1 PR1518.2
GPU_EVENT#: DV14.1 UH2.AR24
GPU_GC6_FB_EN: DV13.3 QV98.1 RV1114.2 RV1133.1 UH2.AW27
GPU_GC6_FB_EN_GPU: QV98.3 RV566.1 RV1096.2 RV1114.1 RV1118.2
GPU_GPIO0: RV1095.1 RV1118.1 UV18.P6
GPU_GPIO1: RV1096.1 RV1124.1 UV18.M3
GPU_GPIO2: RV1097.1 UV18.L6
GPU_GPIO3: RV1098.1 UV18.P5
GPU_GPIO4: RV1099.1 UV18.P7
GPU_GPIO5: RV1100.1 RV1119.1 UV18.L7
GPU_GPIO6: RV1101.1 RV1120.1 UV18.M7
GPU_GPIO8: RV1086.1 RV1121.1 UV18.L3
GPU_GPIO9: RV1102.1 UV18.M2
GPU_GPIO10: RV1103.1 UV18.L1
GPU_GPIO11: RV1104.1 RV1122.1 UV18.M5
GPU_GPIO12: RV1105.1 UV18.N3
GPU_GPIO13: RV1106.1 RV1123.1 UV18.M4
GPU_GPIO16: RV1107.1 UV18.R8
GPU_GPIO20: RV1088.1 UV18.P4
GPU_GPIO21: RV1090.1 UV18.P1
GPU_GPIO23: RV1091.1 UV18.T8
GPU_GPIO25: RV1108.1 UV18.R4
GPU_GPIO26: RV1109.1 UV18.R5
GPU_JTAG_TCK: T201.1(TP-1) UV18.AM10
GPU_JTAG_TDI: T202.1(TP-1) UV18.AM11
GPU_JTAG_TDO: T203.1(TP-1) UV18.AP12
GPU_JTAG_TMS: T204.1(TP-1) UV18.AP11
GPU_JTAG_TRST#: RV593.1 UV18.AN11
GPU_LEVEL: DV15.2 RV554.1 RV1105.2
GPU_PEX_RST_HOLD#: RV563.1 RV1090.2 RV1091.2 UV21.2
GPU_PSI: PR1001.2 PR1501.2 RV552.1 RV1101.2 RV1123.2
GPU_PWR_LEVEL: DV15.1 UE3.B41
H_CATERR#: RH570.2 UH1.BM30
H_CPUPWRGD: UH1.BT31 UH2.AM3
H_DRAMRST#: CD69.1 RD31.2 RD35.2 UH2.BC14
H_PECI: RE48.2 RH190.1 RH539.2
H_PECI_R: RH190.2 UH1.BT34
H_PM_DOWN: RH155.1 UH2.AH2
H_PM_DOWN_R: RH155.2 UH1.BP31
H_PM_SYNC_R: RH189.2 UH1.BM34
H_PROCHOT#: PR315.1 PR1103.1 RE96.2 RH158.1 RH165.2
H_PROCHOT#_EC: RE96.1 UE3.A46
H_PROCHOT#_R: RH158.2 UH1.BR30
H_THERMTRIP#: RH191.1 UH2.AJ3
H_THERMTRIP#_R: QE10.3 RH163.2 RH191.2 UH1.J31
H_VCCST_PWRGD: RH154.1 RH164.2 RH482.1 RZ82.2 UZ19.4
H_VCCST_PWRGD_EC: RZ82.1 RZ84.2 UE3.A44 UZ19.1
HD_SOC_SEL: RA15.2 RA16.2 UA1.6
HDA_BITCLK: CH50.2 RP15.8 UH2.BA9
HDA_BITCLK_AUDIO: CA33.1 CA120.2 RP15.1 UA1.13
HDA_RST#: RP15.6 UH2.BD8
HDA_SDIN0: RH96.2 UH2.BE7
HDA_SDIN0_AUDIO: RA6.1 RH96.1
HDA_SDOUT: CH51.2 RH454.2 RP15.5 UH2.BB7
HDA_SDOUT_AUDIO: CA38.1 RP15.4 UA1.17
HDA_SYNC: RP15.7 UH2.BD9
HDA_SYNC_AUDIO: CA34.1 RP15.2 UA1.14
HDD_DET#: JHDD.12 RH513.1 UH2.AG39
HDD_DEVSLP: RD100.1 UH2.AG43
HDMI_CEC: CV182.2 JHDMI1.13
HDMI_HPLUG: CV180.2 JHDMI1.19 QV14.1 RV123.1
HDMI_RESERVED: CV181.2 JHDMI1.14
HOST_DEBUG_TX: JDEG1.8 RE64.2 UE3.B44
HOST_SD_WP#: QR1.2 RH563.2 UH2.AU44
HP_JD#: DA3.1 JAUDIO.8 JHP1.6 RA14.1 RA82.2
HP_LINE1_JD: CA23.1 RA13.2 RA14.2 UA1.9
HPOUT_D_L_C: CA42.2 DA2.1 JHP1.1 LA6.2
HPOUT_D_R_C: CA43.1 DA9.1 JHP1.2 LA7.2
HPOUT_L: RA28.2 RA30.2 RA52.1 RA75.2 UA1.32
HPOUT_L_R1: LA6.1 RA52.2
HPOUT_R: RA27.2 RA29.2 RA31.2 RA51.1 UA1.33
HPOUT_R_R2: LA7.1 RA51.2
I2C0_SCK: RH424.2 RH521.2 UH2.AR38
I2C0_SCK_DSP: JAUDIO.5 QE18.4 RE136.2 RH521.1 UA1.12
I2C0_SDA: RH425.2 RH522.2 UH2.AT42
I2C0_SDA_DSP: JAUDIO.3 QE18.1 RE137.2 RH522.1 UA1.11
I2C1_SCK_TP: QE2.3 RH119.2 UH2.AR41
I2C1_SCK_TP_C: CE79.1 DE5.3 JTP.6 QE19.3 RE9.1
I2C1_SDA_TP: QE2.6 RH120.2 UH2.AR44
I2C1_SDA_TP_C: CE80.1 DE5.2 JTP.7 QE19.6 RE7.1
I2C_EN8723: RI25.1 UI3.24
I2CA_SCL: RV1108.2 RV1110.1
I2CA_SDA: RV1109.2 RV1111.1
I2CB_SCL: RV570.1 UV18.R7
I2CB_SDA: RV571.1 UV18.R6
I2S_BCLK: JAUDIO.9 UA1.56
I2S_IN: JAUDIO.15 UA1.5
I2S_LRCK: JAUDIO.13 UA1.1
I2S_MCLK: JAUDIO.11 UA1.55
I2S_OUT: JAUDIO.17 UA1.3
I2S_RST_AUDIO#: CA37.1 RA17.2 RA93.1 RP15.3
I2S_RST_AUDIO#_R: RA93.2 UA1.15
I2S_SDIN0_AUDIO_R: RA6.2 UA1.16
I_ADP: PR314.1 UE3.A12
I_BATT: PR317.1 RE55.2
ILIM_HI1: RI12.1 UI2.16
ILIM_HI3: RI7.1 UI1.16
ILIM_LO1: RI11.1 UI2.15
ILIM_LO3: RI6.1 UI1.15
ILIM_SEL_L: DI12.3 RI31.2 RI33.1 RI34.2 UI1.4
ILIM_SEL_R: DI12.2 RI30.2 RI32.1 RI34.1 RI35.2 UI2.4
ILMT_0.95V: PR811.2 PR812.1 PU800.3
ILMT_1V: PR510.2 PR512.1 PU500.3
ILMT_1VSP: PR909.2 PR910.1 PU900.3
IMVP_VR_ON: UE3.A1 UZ21.1
IMVP_VR_PG: PR1119.1 UH14.1
INTRUDER#: RH531.1 UH2.BE11
INV_PWM: DV2.1 JEDP1.25 RV109.1
IRQ_SERIRQ: RH111.1 UE3.A28 UH2.BA17
ISEN1_GT: PC1125.2 PR1303.2 PU1100.9
ISEN1_VCORE: PC1124.1 PR1201.2 PR1214.2 PR1216.2 PU1100.21
ISEN2_GT: PC1122.2 PR1306.2 PU1100.10
ISEN2_VCORE: PC1123.1 PR1205.2 PR1212.2 PR1217.2 PU1100.22
ISEN3_VCORE: PC1120.1 PR1209.2 PR1213.2 PR1215.2 PU1100.23
ISUMN_GT: PC1112.2 PC1119.1 PC1122.1 PC1125.1 PC1133.2 PH1102.2 PR1123.2 PR1127.1 PR1130.1 PR1302.1 PR1304.2
ISUMN_SA: PC1110.1 PC1111.1 PC1136.1 PH1101.1 PL1306.3 PR1115.2 PR1117.1 PR1120.1
ISUMN_VCORE: PC1120.2 PC1123.2 PC1124.2 PC1126.1 PC1127.1 PC1135.1 PH1103.1 PR1133.2 PR1134.1 PR1135.2 PR1203.1 PR1207.1 PR1211.1
ISUMP_GT: PC1112.1 PC1133.1 PR1122.1 PR1123.1 PR1301.2 PR1305.2 PU1100.7
ISUMP_SA: PC1111.2 PC1136.2 PR1120.2 PR1121.2 PR1309.2 PU1100.32
ISUMP_VCORE: PC1127.2 PC1135.2 PR1134.2 PR1136.2 PR1202.2 PR1206.2 PR1210.2 PU1100.19
JTAG_CLK: JDEG1.4 RP20.3 UE3.B56
JTAG_RST#: CE44.1 JTAG1.1 RE59.2 RE61.1 UE3.B47
JTAG_TDI: JDEG1.2 RP20.1 UE3.A51
JTAG_TDO: JDEG1.5 RP20.4 UE3.B55
JTAG_TMS: JDEG1.3 RP20.2 UE3.A53
KB_DET#: JKB.5 RH557.1 UH2.BD22
LAN_WAKE#: RH545.1 UE3.B27 UH2.BD11
LCD_DBC: RH527.1 RH528.1 UH2.U35
LCD_TST: RE32.2 RV110.1 UE3.A38
LCD_VCC_TEST_EN: DV7.2 UE3.A39
LCD_VDD: RV1104.2 T208.1(TP-1)
LDO_EN: PC219.1 PD202.1 PD203.1 PR272.2 PU203.1
LG_3V: PC415.1 PQ402.4 PU400.11
LG_5V: PC416.1 PQ403.4 PU400.15
LID_CL_SIO#: CE31.1 RE41.2 RE45.2 UE3.A21
LID_SW_IN#: CE16.1 RE15.2 RE45.1 UE2.3
LINE1-VREFO: DA7.2 DA14.2 RA27.1 UA1.40
LINE1_L: CA45.1 UA1.35
LINE1_L_C: CA119.2 RA31.1
LINE1_R: CA119.1 UA1.34
LINE1_R_C: CA45.2 RA30.1
LPC_AD0: JLPDE1.3 UE3.A30 UH2.AT22
LPC_AD1: JLPDE1.4 UE3.B32 UH2.AV22
LPC_AD2: JLPDE1.5 UE3.A31 UH2.AT19
LPC_AD3: JLPDE1.6 UE3.B33 UH2.BD16
LPC_FRAME#: JLPDE1.7 UE3.B31 UH2.BE16
LX1_NVVDD: PC1022.2 PU1000.3 PU1001.20
LX1_NVVDDS: PC1519.2 PU1501.20 PU1502.3
LX2_NVVDD: PC1047.1 PU1001.16 PU1002.3
LX_0.95V: PC805.2 PL801.1 PR802.1 PU800.10
LX_1.8V: PL1400.1 PR1401.1 PU1400.6
LX_1V: PC505.2 PL501.1 PR502.1 PU500.10
LX_1VSP: PC905.2 PL901.1 PR903.1 PU900.10
LX_3V: PC410.1 PL400.2 PQ400.1 PQ400.2 PQ400.3 PQ402.5 PR413.1 PU400.8
LX_5V: PC411.2 PL401.1 PQ401.1 PQ401.2 PQ401.3 PQ403.5 PR414.1 PU400.18
M_CLK_DDR0: JDIMM1.137 UH1.AG1
M_CLK_DDR1: JDIMM1.138 UH1.AK2
M_CLK_DDR2: JDIMM2.137 UH1.AM9
M_CLK_DDR3: JDIMM2.138 UH1.AM7
M_CLK_DDR#0: JDIMM1.139 UH1.AG2
M_CLK_DDR#1: JDIMM1.140 UH1.AK1
M_CLK_DDR#2: JDIMM2.139 UH1.AN9
M_CLK_DDR#3: JDIMM2.140 UH1.AM8
M_ODT0: JDIMM1.155 UH1.AD3
M_ODT1: JDIMM1.161 UH1.AE4
M_ODT2: JDIMM2.155 UH1.AF7
M_ODT3: JDIMM2.161 UH1.AE8
MCARD_PCIE#_SATA: RD58.1 RH508.1 UD2.4 UH2.AG36
MCARD_PCIE_SATA#: JNGFF2.61 RD10.2 RD58.2 UD2.2
ME_EN: RH454.1 RH487.1 SW4.2
ME_FWP_EC: RH487.2 SW4.3 UE3.B1
ME_SUS_PWR_ACK: RH506.1 UE3.A8 UH2.BD19
MEC_XTAL1: CE42.1 UE3.A61 YE1.1
MEC_XTAL2: CE43.1 RE51.2 YE1.2
MEC_XTAL2_R: RE51.1 UE3.A62
MEDIACARD_IRQ#: RH546.1 RR10.1 UH2.AL39
MEM_VDD_CTL: PR728.1 RV1086.2 RV1124.2
MEM_VREF: QV95.2 QV96.2 QV101.2 QV102.2 RV567.1 RV1103.2
MIC1-VREFO_L: RA20.1 RA21.1 UA1.38
MIC1-VREFO_R: RA19.1 RA75.1 UA1.39
MONO_IN: CA16.2 UA1.23
MSATA_DEVSLP: JNGFF2.38 RD7.2 UH2.AG42
MSCLK: JDEG1.6 RE63.2 RE103.1
MSCLK_R: RE103.2 RE119.2 UE3.B43
MSDATA: JDEG1.7 RE27.1 RE65.2 RE102.1
MSDATA_R: RE102.2 RE118.2 UE3.A40
NB_MUTE#: JAUDIO.4 RA12.2 RA68.1 UA1.52 UE4.20
NC_B4: RT207.2 UT1.B4
NC_B5: RT208.2 UT1.B5
NC_G2: RT209.2 UT1.G2
NGFF_ON: DN3.1 RN33.2 UN3.3
NGFF_PWREN: DN3.2 RH520.2 UH2.BC27
NRB_BIT: RH524.2 UH2.BD28
NVVDD_EN: CV919.1 DA56.1 PC1015.1 PR1004.1 PU1001.3 QZ15.5 RV1130.1
NVVDD_PGOOD: PR1017.1 PR1019.1 PU1001.13
NVVDD_PWM_VID: PR1003.1 RV1095.2 RV1122.2
NVVDD_VID: PR1003.2 PU1001.5
NVVDDS_EN: PR987.1 PU1501.3 QZ14.2 RV1806.1 RV1807.1
NVVDDS_PGOOD: PR1518.1 PU1501.13
NVVDDS_PSI: PR1500.2 PR1501.1 PR1502.1 PU1501.4
NVVDDS_PWM_VID: PR1503.1 RV1098.2
NVVDDS_VID: PR1503.2 PU1501.5
P_SYS: PC1100.2 PR324.1 PR1100.2 PU1100.1 UE3.A57
PANEL_BKEN_EC: DV1.2 UE4.4
PANEL_BKEN_PCH: DV1.3 UH2.W35
PBAT_PRES#: PD102.2 PD102.3 PR111.2 PR112.1 PR322.1 UE3.A49
PBAT_SMBCLK: PD101.2 PR106.2 RE18.2 UE3.A56
PBAT_SMBDAT: PD101.3 PR108.2 RE17.2 UE3.B59
PBTN_SW#: CE29.1 DE2.2 JAPS.11 RE36.2 SW1.1
PCH_ALW_ON: PR500.2 RZ46.2 RZ1140.1 UE3.A34 UZ23.2
PCH_ALW_ON_R: RZ1133.2 RZ1140.2 UZ4.3
PCH_BATLOW#: RH515.1 UH2.BD13
PCH_CPU_BCLK_N: UH1.A32 UH2.H2
PCH_CPU_BCLK_P: UH1.B31 UH2.G2
PCH_CPU_PCIBCLK_N: UH1.C36 UH2.J1
PCH_CPU_PCIBCLK_P: UH1.D35 UH2.J2
PCH_DPWROK: RH309.1 UE3.A36
PCH_DPWROK_R: RH309.2 RH401.2 UH2.AV11
PCH_ITP_PMODE: RH479.1 UH2.AT2
PCH_JTAG_TCK: JXDP.55 RH95.2 UH2.AN3
PCH_JTAG_TDI: RH100.2 RH477.2 UH2.AP2
PCH_JTAG_TDO: RH97.2 RH478.2 UH2.AP1
PCH_JTAG_TMS: RH12.2 RH98.2 UH2.AR2
PCH_JTAGX: RH491.1 UH2.AR3
PCH_PCIE_WAKE#: RH453.1 UE3.B46 UH2.BC13
PCH_PECI: RH539.1 UH2.AL3
PCH_PLTRST#: UH2.BB27 UH7.1 UH7.2
PCH_PLTRST#_EC: JLPDE1.8 JNGFF1.44 JNGFF2.50 QT20.1 RE31.2 RH77.1 UE1.17 UE3.B30 UH7.4 UR1.1 UV19.2
PCH_PLTRST#_EC_AR: QT20.6 RT435.2 UT1.L4
PCH_PWROK: RH529.1 UH2.AW11 UH14.4
PCH_RSMRST#: RH133.1 RH481.1 UE3.A45
PCH_RSMRST#_R: RH88.2 RH133.2 UH2.BA11
PCH_RTCRST#: CH53.1 CLRP1.1 JAPS.9 RH84.2 RT1133.1 UH2.BC10
PCH_RTCX1: CH45.1 RH70.1 UH2.BC9 YH1.1
PCH_RTCX2: CH46.1 RH70.2 UH2.BD10 YH1.2
PCH_SATA_LED#: RH512.1 UH2.AD44
PCH_SMBCLK: JDIMM1.253 JDIMM2.253 JXDP.53 QH4.1 RH463.2 UF1.4
PCH_SMBDATA: JDIMM1.254 JDIMM2.254 JXDP.51 QH4.4 RH462.2 UF1.6
PCH_SPI_CLK: RP4.1 UH8.6
PCH_SPI_CLK_R: JSPI1.13 JSPI1.14 RH579.2 RP4.8 UH2.BC31
PCH_SPI_CS1#: T18.1(TP-1) UH2.AW31
PCH_SPI_CS2#: RE126.1 RE133.1 UH2.AT31
PCH_SPI_CS2#_R: RE133.2 UE1.20
PCH_SPI_CS#: JSPI1.11 JSPI1.12 RH74.2 UH2.BD31 UH8.1
PCH_SPI_HOLD#: RH576.1 UH8.7
PCH_SPI_HOLD#_R: JSPI1.7 JSPI1.8 RH78.2 RH455.2 RH576.2 UH2.BD30
PCH_SPI_SI: RP4.2 UH8.5
PCH_SPI_SI_R: JSPI1.17 JSPI1.18 RH489.1 RH578.2 RP4.7 UH2.BB29
PCH_SPI_SO: RP4.3 UH8.2
PCH_SPI_SO_R: JSPI1.15 JSPI1.16 RH577.2 RP4.6 UH2.BE30
PCH_SPI_WP#: RP4.4 UH8.3
PCH_SPI_WP#_R: JSPI1.9 JSPI1.10 RH75.2 RH573.2 RP4.5 UH2.BC29
PCH_SRTCRST#: CH52.1 RH83.2 UH2.BB10
PCH_SYS_PWROK_XDP: JXDP.47 RH489.2 RH490.2 RH493.2
PCH_TPM_CLK: RE115.1 RH579.1
PCH_TPM_CLK_C: RE11.1 RE115.2 UE1.19
PCH_TPM_SI: RE114.1 RH578.1
PCH_TPM_SO: RE113.1 RH577.1
PCH_TRIGGER: RH167.1 UH2.AL2
PCH_TRIGGER_R: RH167.2 UH1.H23
PCH_XDP_CLK_N: JXDP.42 UH2.L1
PCH_XDP_CLK_P: JXDP.40 UH2.L2
PCI_CLK_LPC1: CH199.1 JLPDE1.10 RH428.2
PCIE_PRX_CARDTX_N2: CR13.1 UH2.E17
PCIE_PRX_CARDTX_N2_C: CR13.2 UR1.8
PCIE_PRX_CARDTX_P2: CR10.1 UH2.G17
PCIE_PRX_CARDTX_P2_C: CR10.2 UR1.7
PCIE_PRX_SSDTX_N10: JNGFF2.29 UH2.G29
PCIE_PRX_SSDTX_N11: JNGFF2.17 UH2.L31
PCIE_PRX_SSDTX_N12: JNGFF2.5 UH2.G33
PCIE_PRX_SSDTX_P10: JNGFF2.31 UH2.E29
PCIE_PRX_SSDTX_P11: JNGFF2.19 UH2.K31
PCIE_PRX_SSDTX_P12: JNGFF2.7 UH2.H33
PCIE_PRX_TBTX_N15: CT3.1 UH2.F41
PCIE_PRX_TBTX_N15_C: CT3.2 UT1.V22
PCIE_PRX_TBTX_N16: CT7.1 UH2.D43
PCIE_PRX_TBTX_N16_C: CT7.2 UT1.P22
PCIE_PRX_TBTX_P15: CT1.1 UH2.E41
PCIE_PRX_TBTX_P15_C: CT1.2 UT1.V23
PCIE_PRX_TBTX_P16: CT5.1 UH2.E42
PCIE_PRX_TBTX_P16_C: CT5.2 UT1.P23
PCIE_PRX_WLANTX_N1: JNGFF1.35 UH2.H15
PCIE_PRX_WLANTX_P1: JNGFF1.33 UH2.G15
PCIE_PTX_CARDRX_N2: CR9.1 UH2.B19
PCIE_PTX_CARDRX_N2_C: CR9.2 UR1.4
PCIE_PTX_CARDRX_P2: CR7.1 UH2.C19
PCIE_PTX_CARDRX_P2_C: CR7.2 UR1.3
PCIE_PTX_SSDRX_N10: CD45.1 UH2.C32
PCIE_PTX_SSDRX_N10_C: CD45.2 JNGFF2.35
PCIE_PTX_SSDRX_N11: CD43.1 UH2.C33
PCIE_PTX_SSDRX_N11_C: CD43.2 JNGFF2.23
PCIE_PTX_SSDRX_N12: CD37.1 UH2.B35
PCIE_PTX_SSDRX_N12_C: CD37.2 JNGFF2.11
PCIE_PTX_SSDRX_P10: CD46.1 UH2.B32
PCIE_PTX_SSDRX_P10_C: CD46.2 JNGFF2.37
PCIE_PTX_SSDRX_P11: CD44.1 UH2.B33
PCIE_PTX_SSDRX_P11_C: CD44.2 JNGFF2.25
PCIE_PTX_SSDRX_P12: CD42.1 UH2.A35
PCIE_PTX_SSDRX_P12_C: CD42.2 JNGFF2.13
PCIE_PTX_TBRX_N15: CT4.2 UH2.B39
PCIE_PTX_TBRX_N15_C: CT4.1 UT1.Y22
PCIE_PTX_TBRX_N16: CT8.2 UH2.A41
PCIE_PTX_TBRX_N16_C: CT8.1 UT1.T22
PCIE_PTX_TBRX_P15: CT2.2 UH2.A39
PCIE_PTX_TBRX_P15_C: CT2.1 UT1.Y23
PCIE_PTX_TBRX_P16: CT6.2 UH2.A40
PCIE_PTX_TBRX_P16_C: CT6.1 UT1.T23
PCIE_PTX_WLANRX_N1: CN20.1 UH2.A16
PCIE_PTX_WLANRX_P1: CN21.1 UH2.B16
PCIE_PTX_WLANRX_RE_N1: CN20.2 JNGFF1.29
PCIE_PTX_WLANRX_RE_P1: CN21.2 JNGFF1.27
PCIE_WAKE#: JNGFF1.47 RD59.2 RE19.1 RE120.2 UE3.B8
PD_EE_CLK: RT210.2 UT4.A3 UT5.6
PD_EE_CS#: RT168.2 RT213.2 UT4.B3 UT5.1
PD_EE_DI: RT211.2 UT4.B4 UT5.5
PD_EE_DO: RT169.2 RT212.2 UT4.A4 UT5.2
PD_EE_WP#: RT170.2 UT5.3
PD_HOLD#: RT171.2 UT5.7
PD_I2C_ALERT#: RE99.1 UE3.A42 UT4.B6
PEG_GTX_C_HRX_N0: CV819.2 UH1.E10
PEG_GTX_C_HRX_N1: CV821.2 UH1.E11
PEG_GTX_C_HRX_N2: CV823.2 UH1.E12
PEG_GTX_C_HRX_N3: CV825.2 UH1.E13
PEG_GTX_C_HRX_N4: CV827.2 UH1.E14
PEG_GTX_C_HRX_N5: CV829.2 UH1.E15
PEG_GTX_C_HRX_N6: CV831.2 UH1.E16
PEG_GTX_C_HRX_N7: CV833.2 UH1.E17
PEG_GTX_C_HRX_N8: CV835.2 UH1.F18
PEG_GTX_C_HRX_N9: CV837.2 UH1.D19
PEG_GTX_C_HRX_N10: CV839.2 UH1.F20
PEG_GTX_C_HRX_N11: CV841.2 UH1.D21
PEG_GTX_C_HRX_N12: CV843.2 UH1.F22
PEG_GTX_C_HRX_N13: CV845.2 UH1.D23
PEG_GTX_C_HRX_N14: CV847.2 UH1.F24
PEG_GTX_C_HRX_N15: CV849.2 UH1.D25
PEG_GTX_C_HRX_P0: CV818.2 UH1.F10
PEG_GTX_C_HRX_P1: CV820.2 UH1.D11
PEG_GTX_C_HRX_P2: CV822.2 UH1.F12
PEG_GTX_C_HRX_P3: CV824.2 UH1.D13
PEG_GTX_C_HRX_P4: CV826.2 UH1.F14
PEG_GTX_C_HRX_P5: CV828.2 UH1.D15
PEG_GTX_C_HRX_P6: CV830.2 UH1.F16
PEG_GTX_C_HRX_P7: CV832.2 UH1.D17
PEG_GTX_C_HRX_P8: CV834.2 UH1.E18
PEG_GTX_C_HRX_P9: CV836.2 UH1.E19
PEG_GTX_C_HRX_P10: CV838.2 UH1.E20
PEG_GTX_C_HRX_P11: CV840.2 UH1.E21
PEG_GTX_C_HRX_P12: CV842.2 UH1.E22
PEG_GTX_C_HRX_P13: CV844.2 UH1.E23
PEG_GTX_C_HRX_P14: CV846.2 UH1.E24
PEG_GTX_C_HRX_P15: CV848.2 UH1.E25
PEG_GTX_HRX_N0: CV819.1 UV18.AJ14
PEG_GTX_HRX_N1: CV821.1 UV18.AG14
PEG_GTX_HRX_N2: CV823.1 UV18.AJ15
PEG_GTX_HRX_N3: CV825.1 UV18.AK16
PEG_GTX_HRX_N4: CV827.1 UV18.AJ17
PEG_GTX_HRX_N5: CV829.1 UV18.AG17
PEG_GTX_HRX_N6: CV831.1 UV18.AJ18
PEG_GTX_HRX_N7: CV833.1 UV18.AK19
PEG_GTX_HRX_N8: CV835.1 UV18.AJ20
PEG_GTX_HRX_N9: CV837.1 UV18.AG20
PEG_GTX_HRX_N10: CV839.1 UV18.AJ21
PEG_GTX_HRX_N11: CV841.1 UV18.AK22
PEG_GTX_HRX_N12: CV843.1 UV18.AJ23
PEG_GTX_HRX_N13: CV845.1 UV18.AG23
PEG_GTX_HRX_N14: CV847.1 UV18.AJ24
PEG_GTX_HRX_N15: CV849.1 UV18.AK25
PEG_GTX_HRX_P0: CV818.1 UV18.AK14
PEG_GTX_HRX_P1: CV820.1 UV18.AH14
PEG_GTX_HRX_P2: CV822.1 UV18.AK15
PEG_GTX_HRX_P3: CV824.1 UV18.AL16
PEG_GTX_HRX_P4: CV826.1 UV18.AK17
PEG_GTX_HRX_P5: CV828.1 UV18.AH17
PEG_GTX_HRX_P6: CV830.1 UV18.AK18
PEG_GTX_HRX_P7: CV832.1 UV18.AL19
PEG_GTX_HRX_P8: CV834.1 UV18.AK20
PEG_GTX_HRX_P9: CV836.1 UV18.AH20
PEG_GTX_HRX_P10: CV838.1 UV18.AK21
PEG_GTX_HRX_P11: CV840.1 UV18.AL22
PEG_GTX_HRX_P12: CV842.1 UV18.AK23
PEG_GTX_HRX_P13: CV844.1 UV18.AH23
PEG_GTX_HRX_P14: CV846.1 UV18.AK24
PEG_GTX_HRX_P15: CV848.1 UV18.AL25
PEG_HTX_C_GRX_N0: CH36.2 UV18.AM12
PEG_HTX_C_GRX_N1: CH34.2 UV18.AM14
PEG_HTX_C_GRX_N2: CH32.2 UV18.AP15
PEG_HTX_C_GRX_N3: CH30.2 UV18.AM15
PEG_HTX_C_GRX_N4: CH28.2 UV18.AM17
PEG_HTX_C_GRX_N5: CH26.2 UV18.AP18
PEG_HTX_C_GRX_N6: CH24.2 UV18.AM18
PEG_HTX_C_GRX_N7: CH22.2 UV18.AM20
PEG_HTX_C_GRX_N8: CH20.2 UV18.AP21
PEG_HTX_C_GRX_N9: CH18.2 UV18.AM21
PEG_HTX_C_GRX_N10: CH16.2 UV18.AM23
PEG_HTX_C_GRX_N11: CH14.2 UV18.AP24
PEG_HTX_C_GRX_N12: CH12.2 UV18.AM24
PEG_HTX_C_GRX_N13: CH10.2 UV18.AM26
PEG_HTX_C_GRX_N14: CH8.2 UV18.AP27
PEG_HTX_C_GRX_N15: CH6.2 UV18.AM27
PEG_HTX_C_GRX_P0: CH35.2 UV18.AN12
PEG_HTX_C_GRX_P1: CH33.2 UV18.AN14
PEG_HTX_C_GRX_P2: CH31.2 UV18.AP14
PEG_HTX_C_GRX_P3: CH29.2 UV18.AN15
PEG_HTX_C_GRX_P4: CH27.2 UV18.AN17
PEG_HTX_C_GRX_P5: CH25.2 UV18.AP17
PEG_HTX_C_GRX_P6: CH23.2 UV18.AN18
PEG_HTX_C_GRX_P7: CH21.2 UV18.AN20
PEG_HTX_C_GRX_P8: CH19.2 UV18.AP20
PEG_HTX_C_GRX_P9: CH17.2 UV18.AN21
PEG_HTX_C_GRX_P10: CH15.2 UV18.AN23
PEG_HTX_C_GRX_P11: CH13.2 UV18.AP23
PEG_HTX_C_GRX_P12: CH11.2 UV18.AN24
PEG_HTX_C_GRX_P13: CH9.2 UV18.AN26
PEG_HTX_C_GRX_P14: CH7.2 UV18.AP26
PEG_HTX_C_GRX_P15: CH5.2 UV18.AN27
PEG_HTX_GRX_N0: CH36.1 UH1.B10
PEG_HTX_GRX_N1: CH34.1 UH1.B11
PEG_HTX_GRX_N2: CH32.1 UH1.B12
PEG_HTX_GRX_N3: CH30.1 UH1.B13
PEG_HTX_GRX_N4: CH28.1 UH1.B14
PEG_HTX_GRX_N5: CH26.1 UH1.B15
PEG_HTX_GRX_N6: CH24.1 UH1.B16
PEG_HTX_GRX_N7: CH22.1 UH1.B17
PEG_HTX_GRX_N8: CH20.1 UH1.C18
PEG_HTX_GRX_N9: CH18.1 UH1.A19
PEG_HTX_GRX_N10: CH16.1 UH1.C20
PEG_HTX_GRX_N11: CH14.1 UH1.A21
PEG_HTX_GRX_N12: CH12.1 UH1.C22
PEG_HTX_GRX_N13: CH10.1 UH1.A23
PEG_HTX_GRX_N14: CH8.1 UH1.C24
PEG_HTX_GRX_N15: CH6.1 UH1.A25
PEG_HTX_GRX_P0: CH35.1 UH1.C10
PEG_HTX_GRX_P1: CH33.1 UH1.A11
PEG_HTX_GRX_P2: CH31.1 UH1.C12
PEG_HTX_GRX_P3: CH29.1 UH1.A13
PEG_HTX_GRX_P4: CH27.1 UH1.C14
PEG_HTX_GRX_P5: CH25.1 UH1.A15
PEG_HTX_GRX_P6: CH23.1 UH1.C16
PEG_HTX_GRX_P7: CH21.1 UH1.A17
PEG_HTX_GRX_P8: CH19.1 UH1.B18
PEG_HTX_GRX_P9: CH17.1 UH1.B19
PEG_HTX_GRX_P10: CH15.1 UH1.B20
PEG_HTX_GRX_P11: CH13.1 UH1.B21
PEG_HTX_GRX_P12: CH11.1 UH1.B22
PEG_HTX_GRX_P13: CH9.1 UH1.B23
PEG_HTX_GRX_P14: CH7.1 UH1.B24
PEG_HTX_GRX_P15: CH5.1 UH1.B25
PEG_RCOMP: RH24.2 UH1.G2
PEX_TERMP: RV578.2 UV18.AP29
PEX_TSTCLK_OUT: RV47.2 UV18.AJ26
PEX_TSTCLK_OUT#: RV47.1 UV18.AK26
PLTRST_CPU#: RH480.1 UH1.BP35 UH2.AK2
POWER_SW_IN#: CE30.1 RE34.2 RE36.1 RE110.1 UE3.B67
PP_HV: CT155.1 RT1092.2 UT4.A6 UT4.A7 UT4.A8 UT4.B7
PROC_DETECT#: RH519.1 UH2.Y44
PS8713_PD#: DI11.2 RI36.2 RI46.2
PSID: ADP100.4 PR102.1
PSID-1: PQ101.2 PR103.2 PR105.1
PSID-2: PQ100.2 PQ101.1 PR104.1
PSID-3: PQ100.3 PR100.2 PR101.2 UE3.B24
PTP_DIS#: JTP.3 UE4.21
PTP_INT#: DH1.1 QE13.1 RE138.1
PTP_INT#_EC: RE138.2 RP19.2 UE3.B37
PTP_INT#_R: JTP.4 QE13.3 RE87.2
PWM1_GT: PU1100.12 PU1300.1
PWM1_VCORE: PU1100.25 PU1200.1
PWM2_GT: PU1100.13 PU1301.1
PWM2_VCORE: PU1100.26 PU1201.1
PWM3_VCORE: PU1100.27 PU1202.1
PWM_SA: PU1100.35 PU1302.3
PWR_BTN_DOCK1#: QV89.3 RT182.2 RT194.2
PWR_DEBUG#_XDP: JXDP.45 RH483.2 RH488.1
PWR_TB_DOCK#: RE110.2 RT195.2
PWRBTN#_XDP: CH174.1 JXDP.41 RH2.2 RH6.1
PWRBTN_LED#: LED6.1 UE3.B57
REFADJ_NVVDD: PR1007.2 PU1001.6
REFADJ_NVVDDS: PR1507.2 PU1501.6
REFIN_NVVDD: PC1017.1 PR1006.1 PR1008.1 PU1001.7
REFIN_NVVDDS: PC1518.1 PR1508.1 PR1509.1 PU1501.7
REM_DIODE1_N: CE32.1 CE45.1 CE69.1 QE7.1 QE7.2 QE15.3 UE3.B13
REM_DIODE1_P: CE32.2 CE45.2 CE69.2 QE7.3 QE15.1 QE15.2 UE3.A13
REM_DIODE2_N: CE33.1 CE46.2 CE47.2 QE5.1 QE5.2 QE6.3 UE3.B14
REM_DIODE2_P: CE33.2 CE46.1 CE47.1 QE5.3 QE6.1 QE6.2 UE3.A14
REM_DIODE3_N: CE35.1 CE49.2 CE68.2 QE8.1 QE8.2 QE11.3 UE3.A15
REM_DIODE3_P: CE35.2 CE49.1 CE68.1 QE8.3 QE11.1 QE11.2 UE3.B16
REM_DIODE4_N: CE36.1 CE50.1 CE72.1 QE9.3 QE12.1 QE12.2 UE3.A16
REM_DIODE4_P: CE36.2 CE50.2 CE72.2 QE9.1 QE9.2 QE12.3 UE3.B17
RESET_OUT#: RE33.2 RH91.2 RH490.1 UE3.B39 UH2.AY1
RING2: LA5.1 RA21.2 UA1.36
RING2_L: CA41.2 DA5.1 JHP1.3 LA5.2
ROM_CS: T205.1(TP-1) UV18.H6
ROM_SCLK: RV641.1 RV644.2 UV18.H4
ROM_SI: RV639.1 RV642.2 UV18.H5
ROM_SO: RV640.1 RV643.2 UV18.H7
RREF: RR6.2 UR1.9
RTCRST_ON: QR104.2 RE143.2 UE4.2
RTD3_CIO_PWR_EN: QT20.4 RT39.2 UH2.R39
RTD3_CIO_PWR_EN_AR: QT20.3 RT436.2 UT1.F1
RTD3_USB_PWR_EN: RT40.2 UT1.D4
RUN_ON: RE37.2 UE3.B9
RUN_ON#: QE4.5 QE4.6 RE56.2
RUN_ON_EC: QE4.2 RE35.1 RE37.1 RZ43.2 RZ76.1 UZ1.3 UZ1.5 UZ7.3 UZ20.1
RUN_ON_P: PR610.2 PR800.2 RZ50.1 RZ58.2 RZ90.1 UZ9.4 UZ11.4
RUNPWROK: QE4.3 RE52.2 UE3.B26 UH14.2
S5_1.2V: PC613.1 PR606.2 PU600.8
SATA_PRX_DTX_N1B: CS20.1 UH2.D39
SATA_PRX_DTX_N1B_RC: CS20.2 JHDD.8
SATA_PRX_DTX_P1B: CS19.1 UH2.E37
SATA_PRX_DTX_P1B_RC: CS19.2 JHDD.9
SATA_PRX_SSDTX_N0A: JNGFF2.43 UH2.G31
SATA_PRX_SSDTX_P0A: JNGFF2.41 UH2.H31
SATA_PTX_DRX_N1B: CS18.1 UH2.B38
SATA_PTX_DRX_N1B_RC: CS18.2 JHDD.6
SATA_PTX_DRX_P1B: CS17.1 UH2.C38
SATA_PTX_DRX_P1B_RC: CS17.2 JHDD.5
SATA_PTX_SSDRX_N0A: CD53.1 UH2.C31
SATA_PTX_SSDRX_N0A_C: CD53.2 JNGFF2.47
SATA_PTX_SSDRX_P0A: CD51.1 UH2.B31
SATA_PTX_SSDRX_P0A_C: CD51.2 JNGFF2.49
SD_CD#: JCR.8 UR1.30
SD_CLK: CR8.1 JCR.6 RR4.2
SD_CLK_R: RR4.1 UR1.17
SD_CMD: JCR.3 RR5.2
SD_CMD_R: RR5.1 UR1.19
SD_D2: JCR.1 RR8.2
SD_D2_R: RR8.1 UR1.21
SD_D3: JCR.2 RR7.2
SD_D3_R: RR7.1 UR1.20
SD_LN0_M: JCR.14 UR1.25
SD_LN0_P: JCR.13 UR1.26
SD_LN1_M: JCR.17 UR1.23
SD_LN1_P: JCR.18 UR1.22
SD_RCLK_M: JCR.10 RR2.2
SD_RCLK_M_R: RR2.1 UR1.15
SD_RCLK_P: JCR.9 RR3.2
SD_RCLK_P_R: RR3.1 UR1.16
SD_REG2: CR16.1 UR1.24
SIO_EXT_SCI#: RH383.2 UE3.A33 UH2.AV29
SIO_EXT_SMI#: RE140.1 RH110.1 UE3.A6 UH2.AF41
SIO_EXT_WAKE#: RH523.2 UE3.B5 UH2.AN44
SIO_PWRBTN#: RH6.2 UE3.B58 UH2.AT13
SIO_RCIN#: RH518.1 UE3.A27 UH2.AT17
SIO_SLP_A#: JAPS.6 UE3.B28 UH2.BC15
SIO_SLP_S0#: DZ1.2 JAPS.15 RE125.1 RE144.1 RZ59.1 RZ61.1 UH2.BC26
SIO_SLP_S3#: JAPS.2 QT11.3 RE35.2 RZ81.1 UE3.A35 UH2.AW15 UZ20.2 UZ21.2
SIO_SLP_S3#_AR: QT11.1 RT433.2 UT1.D2
SIO_SLP_S4#: JAPS.5 RE38.2 UE3.B36 UH2.BD15 UZ22.2
SIO_SLP_S5#: DZ1.3 JAPS.4 RZ89.1 UE3.A18 UH2.BA13
SIO_SLP_SUS#: RE111.2 RZ1133.1 UH2.BB13
SIO_SLP_WLAN#: UE3.B45 UH2.AV13
SLEEVE: LA8.1 RA19.2 RA20.2 UA1.37
SLEEVE_L: CA44.1 DA4.1 JHP1.4 LA8.2
SM_PG_CTRL: PR608.1 RH525.2 UC1.4
SMBALERT#: RH505.2 UH2.BB41
SMBCLK: QH4.6 RH458.2 UH2.AW44
SMBDATA: QH4.3 RH459.2 UH2.BB43
SML0_SMBCLK: RH501.2 UH2.AY44
SML0_SMBDATA: RH502.2 UH2.BB39
SML0ALERT#: RH503.2 UH2.BA40
SML1_SMBCLK: RH460.2 UE3.B6 UH2.AW42
SML1_SMBDAT: RH461.2 UE3.A5 UH2.AW45
SML1ALERT#: RH504.2 UH2.AT27
SNB_0.95V: PC801.1 PR802.2
SNB_1V: PC501.1 PR502.2
SNB_1VSP: PC901.1 PR903.2
SNUB_1.2V: PC611.1 PR602.2
SNUB_3V: PC414.1 PR413.2
SNUB_5V: PC417.1 PR414.2
SP7_SDWP: QR1.1 UR1.29
SP7_SDWP_C: JCR.11 QR1.3
SPK_DET#: JAUDIO.6 RE139.1 RH572.1 UH2.BD21
SPK_DET#_EC: RE139.2 UE3.B42
SPKR: RA7.1 RH82.2 UH2.BD26
SRCCLKREQ1#: RH549.2 UH2.AW24
SRCCLKREQ2#: RH550.2 UH2.AT24
SRCCLKREQ8#: RP22.7 UH2.BD32
SRCCLKREQ9#: RP22.6 UH2.BC32
SRCCLKREQ10#: RP22.8 UH2.BB31
SRCCLKREQ11#: RP23.8 UH2.BC33
SRCCLKREQ12#: RP23.5 UH2.BA33
SRCCLKREQ13#: RP23.6 UH2.AW33
SRCCLKREQ14#: RP23.7 UH2.BB33
SRCCLKREQ15#: RP22.5 UH2.BD33
SSD_CLK_REQ#: JNGFF2.52 RP2.8 UH2.AT33
SSD_PCIE_WAKE#: JNGFF2.54 RD8.1 RD59.1
SSD_PWR_EN: RZ74.1 RZ75.1 UH2.M44
STRAP0: RV645.1 RV651.2 UV18.J2
STRAP1: RV646.1 RV652.2 UV18.J7
STRAP2: RV647.1 RV653.2 UV18.J6
STRAP3: RV648.1 RV654.2 UV18.J5
STRAP4: RV649.1 RV655.2 UV18.J3
STRAP5: RV650.1 RV656.2 RV1072.2
SUS_ON: RE39.2 UE3.A9
SUS_ON_EC: RE30.1 RE38.1 RE39.1 RT240.1 UZ22.1
SUS_ON_EC_P: PR606.1 PR1801.1 RZ87.1 RZ91.1 UZ18.1 UZ22.4 UZ23.1
SUS_ON_EC_ST: RZ88.1 RZ91.2 UZ15.4 UZ23.4
SUS_ON_P: RZ72.1 RZ80.1 UZ18.4
SUSACK#: UE3.B7 UH2.BB19
SUSCLK: RD9.2 RN1.2 UH2.AN15
SUSCLK_R: JNGFF1.42 RN1.1
SW_1.2V: PC600.1 PL600.2 PQ600.1 PQ600.2 PQ600.3 PQ601.5 PR602.1 PU600.16
SW_+1.35VRUN: PC714.1 PL701.1 PR705.2 PR755.1 PU700.6 PU700.7 PU700.8 PU700.9 PU700.10 PU700.11
SYS_PEX_RST_MON#: RV557.1 RV583.2 RV1107.2 RV1121.2 UV21.1
SYS_PEX_RST_MON#_L: RV583.1 RV587.1 UV19.4
SYS_RESET#: JAPS.13 RH8.2 RH571.1 UH2.AW1
TB_HDMI_HPLUG: QV14.3 RV122.1 UT1.G1
TBT_BATLOW#: RT25.2 UT1.F2
TBT_CIO_PLUG_EVENT#: RT23.2 UH2.U41 UT1.W2
TBT_CLK_REQ#: QT12.3 RP2.7 RT21.2 UH2.BE25
TBT_CLK_REQ#_AR: QT12.1 RT434.2 UT1.AC5
TBT_CONFIG: RT183.1 RT1093.2 UT4.H6
TBT_DDC_CLK: QX1.1 RT33.2 UT1.Y2
TBT_DDC_DATA: QX1.4 RT34.2 UT1.Y1
TBT_FORCE_PWR: RT38.2 UH2.P43 UT1.H4
TBT_I2C_CLK: RT36.2 UT1.U2 UT4.D2
TBT_I2C_DATA: RT35.2 UT1.U1 UT4.D1
TBT_JTAG_TCK: RT7.2 T198.1(TP-1) UT1.T4
TBT_JTAG_TDI: RT9.2 T196.1(TP-1) UT1.Y4
TBT_JTAG_TDO: RT6.2 T199.1(TP-1) UT1.W4
TBT_JTAG_TMS: RT8.2 T197.1(TP-1) UT1.V4
TBT_LSRX: RT45.2 RT232.1 UT1.A4 UT4.K4
TBT_LSTX: RT44.2 RT233.1 UT1.A5 UT4.L4
TBT_ML0_N: CV172.2 UT1.R1
TBT_ML0_P: CV173.2 UT1.R2
TBT_ML1_N: CV174.2 UT1.N1
TBT_ML1_P: CV175.2 UT1.N2
TBT_ML2_N: CV176.2 UT1.L1
TBT_ML2_P: CV177.2 UT1.L2
TBT_ML3_N: CV170.2 UT1.J1
TBT_ML3_P: CV171.2 UT1.J2
TBT_PCIE_WAKE#: RE120.1 RT22.2 UT1.W1
TBT_POC_RST#: DT29.2 RT202.2 RT244.2 UT1.F4
TBT_PWR_EN: RH556.2 UH2.AU43
TBT_RBIAS: RT10.1 UT1.H6
TBT_ROM_CLK: RT231.1 UT1.AB4 UT2.6
TBT_ROM_CLK_R: RT210.1 RT231.2
TBT_ROM_CS#: RT18.2 RT230.1 UT1.AC3 UT2.1
TBT_ROM_CS#_R: RT213.1 RT230.2
TBT_ROM_DI: RT228.1 UT1.AB3 UT2.5
TBT_ROM_DI_R: RT211.1 RT228.2
TBT_ROM_DO: RT16.2 RT229.1 UT1.AC4 UT2.2
TBT_ROM_DO_R: RT212.1 RT229.2
TBT_ROM_HOLD#: RT15.2 UT2.7
TBT_ROM_WP#: RT17.2 UT1.V1 UT2.3
TBT_RSENSE: RT10.2 UT1.J6
TBT_SRC_CFG1: RT107.2 UT1.AA1
TBT_SVR_IND: LT1.1 UT1.C1 UT1.C2 UT1.D1
TBT_TEST_EN: RT3.2 UT1.E1
TBT_TEST_PWRG: RT4.2 UT1.AB5
TBT_TMU_CLK_OUT: RT37.2 UT1.V2
TBT_USB2_D+: UT1.E20 UT4.L5
TBT_USB2_D-: UT1.D20 UT4.K5
TBT_USB3_RX0_N: DT21.1 JUSBC1.B10 UT1.A21
TBT_USB3_RX0_P: DT20.1 JUSBC1.B11 UT1.B21
TBT_USB3_RX1_N: DT18.1 JUSBC1.A10 UT1.B15
TBT_USB3_RX1_P: DT19.1 JUSBC1.A11 UT1.A15
TBT_USB3_TX0_N: CT40.2 DT13.1 JUSBC1.A3
TBT_USB3_TX0_N_C: CT40.1 UT1.B19
TBT_USB3_TX0_P: CT39.2 DT12.1 JUSBC1.A2
TBT_USB3_TX0_P_C: CT39.1 UT1.A19
TBT_USB3_TX1_N: CT38.2 DT26.1 JUSBC1.B3
TBT_USB3_TX1_N_C: CT38.1 UT1.B17
TBT_USB3_TX1_P: CT37.2 DT27.1 JUSBC1.B2
TBT_USB3_TX1_P_C: CT37.1 UT1.A17
TBTA_AUX_N: CT42.2 RT432.2 UT4.J2
TBTA_AUX_N_C: CT42.1 UT1.W15
TBTA_AUX_P: CT41.2 RT431.2 UT4.J1
TBTA_AUX_P_C: CT41.1 UT1.Y15
TBTA_CC1: CT160.1 DT14.1 JUSBC1.A5 UT4.K9 UT4.L9
TBTA_CC2: CT159.1 DT25.1 JUSBC1.B5 UT4.K10 UT4.L10
TBTA_DEBUG1: RT184.2 UT4.L2
TBTA_DEBUG2: RT185.2 UT4.K2
TBTA_DEBUG3_LSTX: RT187.2 RT233.2 UT4.L3
TBTA_DEBUG4_LSRX: RT188.2 RT232.2 UT4.K3
TBTA_HPD: RT43.2 RT181.2 UT1.M4
TBTA_HRESET: RT429.1 UT4.D6
TBTA_I2C_C_N: DT23.1 JUSBC1.B7 LT13.3
TBTA_I2C_C_P: DT24.1 JUSBC1.B6 LT13.2
TBTA_I2C_D_N: LT13.4 UT4.L7
TBTA_I2C_D_P: LT13.1 UT4.K7
TBTA_I2C_INT#: RT167.2 UT1.J4 UT4.C1
TBTA_LDO_BMC: CT144.1 UT4.E1
TBTA_PD_SBU1: RT176.1 UT4.K8
TBTA_PD_SBU2: RT177.1 UT4.L8
TBTA_RESET_N: DT29.1 UT4.F11
TBTA_SBU1: DT17.1 JUSBC1.A8 RT176.2
TBTA_SBU2: DT22.1 JUSBC1.B8 RT177.2
TBTA_USB2_D_N_C: DT16.1 JUSBC1.A7 LT12.2
TBTA_USB2_D_N_R: LT12.1 UT4.L6
TBTA_USB2_D_P_C: DT15.1 JUSBC1.A6 LT12.3
TBTA_USB2_D_P_R: LT12.4 UT4.K6
TBTA_VBUS_L: CT157.1 LT11.1 UT4.A10 UT4.B10 UT4.H11 UT4.J10 UT4.J11 UT4.K11
TESTMODE: RV592.1 UV18.AK11
THERMAL_ALERT#: RV553.1 RV1102.2
THERMATRIP2#: CE52.1 QE10.1 RE66.2 UE3.B34
THERMATRIP3#: RE25.1 RV1083.2 UE3.A2
THERMATRIP_GPU#: RV594.1 RV1082.1 UV18.M1
THERMDA: UT1.AB23 UT1.AC23
THSEL_STRAP: RE57.1 UE3.B29
TMDS_L_TX0N: DV5.5 DV5.6 JHDMI1.3 RV532.2 RV539.1
TMDS_L_TX0P: DV5.4 DV5.7 JHDMI1.1 RV533.2 RV539.2
TMDS_L_TX1N: DV5.2 DV5.8 JHDMI1.6 RV534.2 RV540.1
TMDS_L_TX1P: DV5.1 DV5.9 JHDMI1.4 RV535.2 RV540.2
TMDS_L_TX2N: DV4.4 DV4.7 JHDMI1.9 RV536.2 RV541.1
TMDS_L_TX2P: DV4.5 DV4.6 JHDMI1.7 RV537.2 RV541.2
TMDS_L_TXCN: DV4.1 DV4.9 JHDMI1.12 RV530.2 RV538.1
TMDS_L_TXCP: DV4.2 DV4.8 JHDMI1.10 RV531.2 RV538.2
TMDS_TX0N: CV172.1 RV517.1 RV532.1
TMDS_TX0P: CV173.1 RV516.1 RV533.1
TMDS_TX1N: CV174.1 RV515.1 RV534.1
TMDS_TX1P: CV175.1 RV514.1 RV535.1
TMDS_TX2N: CV176.1 RV513.1 RV536.1
TMDS_TX2P: CV177.1 RV512.1 RV537.1
TMDS_TXCN: CV170.1 RV519.1 RV530.1
TMDS_TXCP: CV171.1 RV518.1 RV531.1
TOUCH_SCREEN_PD#: DI1.1 RH510.1 UH2.AE44
TOUCHPAD_INTR#: DH1.2 RH547.1 UH2.BC23
TP_PW_EN: RZ32.2 UE4.24 UE6.3
TPM_GPIO4: RE126.2 RE134.2 UE1.13
TPM_LPM#: RE144.2 UE1.3
TPM_PIRQ#: RE86.2 UE1.18 UH2.AN38
TPM_VDD: CE75.1 CE76.1 RE128.2 RE129.2 UE1.8
UART2_RXD: JUART.3 RH562.2 UH2.AR45
UART2_TXD: JUART.2 RH561.2 UH2.AR39
UARTT0_TX: JDEG1.9 UH2.AV44
UG_3V: PQ400.4 PU400.10
UG_5V: PQ401.4 PU400.16
UMA_DIS: RH588.1 RH589.1 UH2.AL44
UPD_GPU_SMBCLK: QE18.3 QV21.6 RE95.1 RT201.1 UE3.B49
UPD_GPU_SMBDAT: QE18.6 QV21.3 RE94.1 RT200.1 UE3.B48
UPD_MRESET: RT244.1 RT245.2 RZ41.1 UE3.A4
UPD_SMBCLK: RT201.2 UT4.B5
UPD_SMBDAT: RT200.2 UT4.A5
USB3RN1: CI8.1 UH2.B7
USB3RN1_C: CI8.2 UI3.23
USB3RN1_D-: DI9.1 DI9.9 JUSB2.5 RI40.2
USB3RN1_RE: RI40.1 UI3.8
USB3RN2: RI44.1 UH2.C8
USB3RN2_D-: DI7.1 DI7.9 JUSB1.5 RI44.2
USB3RP1: CI7.1 UH2.A7
USB3RP1_C: CI7.2 UI3.22
USB3RP1_D+: DI9.2 DI9.8 JUSB2.6 RI39.2
USB3RP1_RE: RI39.1 UI3.9
USB3RP2: RI43.1 UH2.B8
USB3RP2_D+: DI7.2 DI7.8 JUSB1.6 RI43.2
USB3T_N1: CI16.2 RI37.1
USB3T_N2: CI9.2 RI41.1
USB3T_P1: CI20.2 RI38.1
USB3T_P2: CI10.2 RI42.1
USB3TN1: CI6.1 UH2.C11
USB3TN1_C: CI6.2 UI3.20
USB3TN1_D-: DI9.4 DI9.7 JUSB2.8 RI37.2
USB3TN1_RE: CI16.1 UI3.11
USB3TN2: CI9.1 UH2.B12
USB3TN2_D-: DI7.4 DI7.7 JUSB1.8 RI41.2
USB3TP1: CI5.1 UH2.B11
USB3TP1_C: CI5.2 UI3.19
USB3TP1_D+: DI9.5 DI9.6 JUSB2.9 RI38.2
USB3TP1_RE: CI20.1 UI3.12
USB3TP2: CI10.1 UH2.A12
USB3TP2_D+: DI7.5 DI7.6 JUSB1.9 RI42.2
USB20_FP_N1_CONN: DI13.2 JFP.4 ML17.2
USB20_FP_P1_CONN: DI13.3 JFP.3 ML17.3
USB20_N1: UH2.AF5 UI2.2
USB20_N2: UH2.AD5 UI1.2
USB20_N4: LN1.1 UH2.AE1
USB20_N4_R: JNGFF1.5 LN1.2
USB20_N7: ML17.1 UH2.AB3
USB20_N9: LI1.1 UH2.AA1
USB20_N9_R: DI3.2 JTS.4 LI1.2
USB20_N12: LV22.1 UH2.AD3
USB20_N12_R: DV12.3 JEDP1.31 LV22.2
USB20_P1: UH2.AG7 UI2.3
USB20_P2: UH2.AD7 UI1.3
USB20_P4: LN1.4 UH2.AE2
USB20_P4_R: JNGFF1.3 LN1.3
USB20_P7: ML17.4 UH2.AB2
USB20_P9: LI1.4 UH2.AA2
USB20_P9_R: DI3.3 JTS.5 LI1.3
USB20_P12: LV22.4 UH2.AD2
USB20_P12_R: DV12.1 JEDP1.32 LV22.3
USB8723_TEST: RI24.1 UI3.14
USB_DET#_L: CE71.1 JUSB1.10 RE89.2
USB_DET#_R: CE37.1 JUSB2.10 QI10.2 RE54.2
USB_DET_EC#_L: CE70.1 RE89.1 RE90.2 UE3.B68
USB_DET_EC#_R: CE38.1 RE50.2 RE54.1 UE3.B63
USB_ILIM_SEL: DI12.1 RI35.1 UE4.3
USB_L_CTL: RI4.2 UI1.7 UI1.8
USB_OC0#: RH552.1 UH2.AD43 UI2.13
USB_OC1#: RH553.1 UH2.AD42 UI1.13
USB_OC2#: RH554.1 UH2.AD39
USB_OC3#: RH555.1 UH2.AC44
USB_OC4#: RP8.3 UH2.Y43
USB_OC5#: RP8.4 UH2.Y41
USB_OC6#: RP8.2 UH2.W44
USB_OC7#: RP8.1 UH2.W43
USB_PWR_EN: RH544.1 UH2.BC19 UI4.1 UI5.1
USB_PWR_EN_L: RI26.1 UI1.5 UI4.4
USB_PWR_EN_R: RI27.1 RI28.2 UI2.5 UI5.4
USB_PWR_SHR_EN_L#: RI5.2 UE3.A55 UI1.6
USB_PWR_SHR_EN_R#: RI10.2 UE4.19 UI2.6
USB_PWR_SHR_VBUS_EN_L: RI8.2 UE4.17 UI4.2
USB_PWR_SHR_VBUS_EN_R: DI11.1 RI13.2 RI28.1 UE4.18 UI5.2
USB_R_CTL: RI9.2 UI2.7 UI2.8
USB_STATUS#_L: RI32.2 UI1.9
USB_STATUS#_R: RI33.2 UI2.9
USBC_MCP23017_SMBCLK: RE21.1 RE109.2 UE3.B4 UE4.8
USBC_MCP23017_SMBDAT: RE20.1 RE108.2 UE3.A3 UE4.9
USBP1_D+: LI2.4 UI2.10
USBP1_D-: LI2.1 UI2.11
USBP1_R_D+: D123.1 JUSB2.3 LI2.3
USBP1_R_D-: D124.1 JUSB2.2 LI2.2
USBP2_D+: LI5.4 UI1.10
USBP2_D-: LI5.1 UI1.11
USBP2_R_D+: D125.1 JUSB1.3 LI5.3
USBP2_R_D-: D126.1 JUSB1.2 LI5.2
VCORE_B+: PC1210.1 PC1211.1 PC1212.1 PC1213.1 PC1214.1 PC1235.1 PC1236.1 PC1237.1 PC1238.1 PC1251.1 PC1252.1 PC1253.1 PC1254.1 PC1256.1 PC1277.1 PJP1200.2 PL1203.2 PL1204.2 PR1102.1 PU1200.6 PU1200.12 PU1201.6 PU1201.12 PU1202.6 PU1202.12
VFB_1.35V: PC755.2 PR704.2 PR722.2 PR724.1 PU700.1
VGA_CLK_REQ#: QV103.1 RH551.2 UH2.AR31
VGA_EDID_CLK: RV572.1 UV18.R2
VGA_EDID_DATA: RV573.1 UV18.R3
VGA_ID: RE112.1 UE3.A10
VR_ON: PR1118.1 RZ60.2 RZ71.1 UZ12.4
VR_SVID_ALERT#: PR1132.1 RH152.2 RH153.1
VR_SVID_ALERT#_C: PR1132.2 PU1100.44
VR_SVID_ALERT#_R: RH153.2 UH1.BH31
VR_SVID_CLK: PR1131.2 PR1319.1 UH1.BH32
VR_SVID_CLK_C: PR1319.2 PU1100.45
VR_SVID_DATA: PR1145.2 PR1318.1 RH151.2 UH1.BH29
VR_SVID_DATA_C: PR1318.2 PU1100.43
VREF_NVVDD: PC1005.1 PR1005.1 PU1001.8
VREF_NVVDDS: PC1501.1 PR1505.1 PU1501.8
VSET AUDIO: RA79.2 RA80.1 UA3.4
VSET_5085: CE41.1 RE58.1 UE3.A17
WLAN_CLK_REQ#: JNGFF1.45 RP2.5 UH2.BD25
WLAN_WIGIG60GHZ_DIS#: DN1.1 RE71.2 UE4.22
WLAN_WIGIG60GHZ_DIS#_R: DN1.2 JNGFF1.48
XDP_BPM#0: JXDP.21 UH1.BR27
XDP_BPM#1: JXDP.23 UH1.BT27
XDP_DBRESET#: CH175.1 JXDP.48 RH5.2 RH8.1
XDP_PLTRST#: JXDP.46 RH479.2 RH480.2 RH492.2
XDP_PRDY#: JXDP.5 UH1.BP27 UH2.AT4
XDP_PREQ#: JXDP.3 RH156.2 UH1.BL30 UH2.AT3
XDP_PWRGOOD: JXDP.39 RH481.2 RH482.2
XDP_TDI: JXDP.56 RH477.1 RH541.1
XDP_TDO: JXDP.52 RH478.1 RH540.1
XDP_TMS: JXDP.58 RH12.1 RH542.1
XDP_TRST#: JXDP.54 RH543.1
XTAL24_IN: RA96.2 UH2.A6
XTAL24_IN_R: CH47.1 RA96.1 RH72.1 YH2.1
XTAL24_OUT: RA97.2 UH2.A5
XTAL24_OUT_R: CH48.1 RA97.1 RH72.2 YH2.3
XTAL_25_IN: CT43.1 RA98.2 YT1.1
XTAL_25_IN_R: RA98.1 UT1.D22
XTAL_25_OUT: CT44.1 RA99.2 YT1.3
XTAL_25_OUT_R: RA99.1 UT1.D23
XTAL_OUT: CV858.2 RV585.2 UV18.H2 YV1.3
XTALIN: CV857.2 RV585.1 UV18.H3 YV1.1
XTALOUT: RV581.1 UV18.J4
XTALSSIN: RV579.1 UV18.H1
N06747: CA77.1 CA130.1 UA1.18
N06883: CA24.1 CA25.1 UA1.43
N07271: CA26.1 CA27.1 UA1.22
N09031: CA16.1 CA19.1 RA4.2 RA7.2 RA57.1
N09131: CA28.1 CA29.1 UA1.21
N09183: CA30.1 UA1.44
N09195: CA31.1 UA1.41
N09225: CA15.2 UA1.26
N09237: CA18.2 UA1.28
N09395: CA10.1 CA11.1 LA3.1 UA1.46
N09461: CA3.1 CA4.1 LA1.1 UA1.51
N16357: CA20.1 UA1.29
N16361: CA21.1 UA1.31
N16389: CA15.1 UA1.25
N16393: CA18.1 UA1.27
N35186: DA14.1 RA29.1
N35194: DA7.1 RA28.1
N48197: PC1103.2 PR1104.2 PU1100.2
N48329: PC1104.2 PR1111.2 PU1100.4
N48371: PC1105.2 PR1111.1
N48789: PC1114.1 PR1129.1 PU1100.28
N48933: PC1117.1 PR1126.2
N48941: PC1115.1 PR1126.1 PU1100.29
N48965: PC1116.1 PR1124.2
N48979: PR1124.1 PR1125.1 PR1128.1 PU1100.30
N49205: PC1113.2 PR1130.2 PU1100.8
N49217: PC1113.1 PR1127.2
N49289: PC1139.2 PR1105.2 PU1100.3
N49471: PC1108.1 PR1117.2
N49551: PC1108.2 PR1115.1 PU1100.33
N49667: PR1103.2 PU1100.46
N49815: PR1116.1 PU1100.36
N50153: PC1101.1 PR1101.2 PU1100.42
N50385: PC1129.1 PR1137.1 PU1100.14
N50425: PH1104.2 PR1138.2 PR1144.1
N50433: PR1144.2 PU1100.15
N50477: PR1110.1 PU1100.40
N50505: PR1109.1 PU1100.39
N50517: PR1108.1 PU1100.38
N50567: PR1107.1 PU1100.37
N50631: PC1134.2 PR1141.2
N50639: PC1131.1 PR1141.1 PU1100.16
N50651: PC1132.1 PR1139.2
N50739: PR1139.1 PR1140.1 PR1142.2 PU1100.17
N51003: PC1128.1 PR1133.1 PU1100.20
N51011: PC1128.2 PR1135.1
N57527: PR1209.1 PR1210.1 PR1222.2
N3514407: PR405.2 PU400.5
N3514423: PC400.1 PR400.2 PU400.3
N3514453: PC419.1 PU400.13
N13272409: PC800.1 PR800.1 PR801.1 PU800.1
N13272413: PC807.2 PR804.1 PR806.1 PU800.4
N13272497: PC813.1 PU800.5
N13272521: PC805.1 PR803.2
N13347359: PR1114.2 PR1119.2 PU1100.47
N13351923: PC1102.1 PR1102.2 PU1100.41
N13352071: PR1118.2 PU1100.48
N13353452: PR1112.2 PR1113.2 PR1143.1 PU1100.5
N17034077: PR406.1 PU400.1
N17034092: PC418.1 PR415.1 PU400.12
N19473413: PC1802.2 PR1803.2 PR1804.1 PU1800.4
N19473637: PC1802.1 PC1803.1 PR1803.1 PR1805.1 PU1800.1 PU1800.2 PU1800.3
N19912586: PL1003.1 PR1020.1 PU1002.5 PU1002.6 PU1002.7
N22956922: CV874.1 CV875.1 CV876.1 CV877.1 CV878.1 CV879.1 CV880.2 CV881.2 CV882.1 RV1067.1 RV1068.1 UV18.AG13 UV18.AG15 UV18.AG16 UV18.AG18 UV18.AG25 UV18.AH15 UV18.AH18 UV18.AH26 UV18.AH27 UV18.AJ27 UV18.AK27 UV18.AL27 UV18.AM28 UV18.AN28
N26813293: RV639.2 RV640.2 RV641.2 RV1080.2 RV1081.2
N35924928: RV600.2 UV18.J27
N35928308: RV601.2 UV18.H27
N35950826: RV602.2 UV18.H25
N48708347: PC600.2 PR600.1
N48708367: PC614.1 PR608.2 PR610.1 PU600.7
N48708425: PR605.2 PU600.9
N49570867: PC500.1 PR500.1 PR501.1 PU500.1
N49570895: PC507.2 PR504.2 PR508.1 PU500.4
N49571010: PC512.1 PU500.5
N49571039: PC505.1 PR503.2
N50817763: PC333.2 PR320.1 PU300.17
N50817876: PR311.2 PR312.2 PR316.1 PU300.5
N50817886: PC327.1 PR314.2 PU300.7
N50817889: PC328.1 PR317.2 PU300.8
N50817917: PR315.2 PU300.10
N50817928: PC313.2 PC314.1 PR302.2 PU300.1
N50817929: PR321.2 PR323.1 PU300.16
N50817930: PC311.2 PC313.1 PR301.2 PU300.2
N50817943: PC330.2 PC331.1 PR310.2 PU300.20
N50817947: PC331.2 PC332.1 PR310.3 PU300.19
N50817961: PR322.2 PU300.15
N50817990: PR319.1 PU300.18
N52699143: PC329.1 PR313.1
N52997531: PD100.1 PL104.1 PR102.2
N52999986: PL104.2 PQ100.1 PR100.1 PR103.1
N55155823: CV168.2 QV11.3 RV119.2 RV120.1
N55155843: QV12.1 RV120.2
N80922351: PC1400.2 PJ1401.2 PL1444.2 PU1400.3
N80922387: PC1407.1 PR1401.2
N100297089: PR1400.2 PU1400.2
N101473498: TV3.1(TP-1) UV23.A10 UV23.U10
N101473516: RV617.1 UV23.J1
N101473793: RV619.1 UV23.J13
N101484102: TV4.1(TP-1) UV24.A10 UV24.U10
N101484120: RV618.1 UV24.J1
N101484397: RV620.1 UV24.J13
N101908883: TV5.1(TP-1) UV26.A10 UV26.U10
N101908901: RV630.1 UV26.J1
N101909174: RV632.1 UV26.J13
N101910014: TV6.1(TP-1) UV25.A10 UV25.U10
N101910032: RV631.1 UV25.J1
N101910312: RV633.1 UV25.J13
N108873638: PR409.1 PU400.20
N109970739: PR410.1 PU400.19
N110703687: PC1024.1 PR1009.2
N110833423: PL1002.1 PR1009.1 PU1000.5 PU1000.6 PU1000.7
N111796536: RZ13.1 UZ1.13 UZ1.14
N111796622: RZ15.1 UZ1.8 UZ1.9
N111798152: CZ4.1 UZ1.12
N111798158: CZ6.1 UZ1.10
N116140097: JEDP1.36 RV110.2
N116496514: PC1056.1 PR1020.2
N118983880: PR318.1 PU300.21
N119186848: RI23.1 UI3.7
N119186852: RI36.1 UI3.5
N119942216: ADP100.5 ADP100.6 ADP100.7 PC106.1 PL105.1 PL106.1
N119944306: PR303.2 PU300.3
N119944438: PC319.1 PR304.2 PU300.28
N119944456: PC322.2 PQ304.1 PR305.1 PR308.1 PU300.6
N120139517: RH71.2 UH2.E1
N120174690: T20.1(TP-1) UH2.AV15
N120176772: T2.1(TP-1) UH2.V44
N120176782: T4.1(TP-1) UH2.L43
N120176822: T8.1(TP-1) UH2.BD36
N120177456: T17.1(TP-1) UH2.BD17
N120264964: RT1.1 UT1.N16
N120290495: RT2.1 UT1.N6
N120293690: QV13.2 RV121.2
N120361079: JNGFF2.60 RD9.1
N120361841: RZ18.1 UZ4.7 UZ4.8
N120361881: CZ20.1 UZ4.6
N120533729: CE53.1 PJP1206.1 RZ1134.2 RZ1135.2
N120533764: RE76.2 UE4.14
N120533798: RE75.2 UE4.13
N120533808: RE74.2 UE4.12
N120533818: RE73.2 UE4.11
N120553340: RE43.1 RE44.1 UE3.A59
N120553378: CE22.1 PJP1205.1 RZ1136.2 RZ1137.2
N120553518: RE111.1 UE3.B52
N120553639: RE55.1 UE3.B61
N120554151: QE10.2 RE69.2
N120554627: CE48.1 RE62.2
N120918225: PD303.1 PD304.1 PR303.1 PR305.2 PR399.1
N120970730: PC1209.1 PR1200.2
N120971346: PC1234.1 PR1204.2
N120971480: PC1255.1 PR1208.2
N120977227: PL1202.1 PR1208.1 PR1222.1 PU1202.8
N120977691: PL1201.1 PR1204.1 PR1220.1 PU1201.8
N121029055: RH108.1 UH2.B18
N121029061: RH108.2 UH2.C17
N121033373: PR408.2 PU400.6
N121033408: PR407.2 PR428.2 PU400.7
N121070696: RH109.1 UH2.AG3
N121163993: RH150.2 UH1.J2
N121163994: RH149.2 UH1.H1
N121163995: RH148.2 UH1.G1
N121388945: RH189.1 UH2.AJ4
N121479122: RH465.1 RH466.1 UH1.AG38
N121480352: RH469.1 RH470.1 UH1.M37
N121480355: RH201.1 RH202.1 UH1.M38
N121480375: RH473.2 UH1.Y12
N121507165: RH57.2 UH1.BR25
N121507167: RH58.2 UH1.BP25
N121507169: RH166.2 UH1.BT29
N121616264: RE93.1 UE6.7 UE6.8
N121616283: CE65.1 UE6.6
N121617744: CZ37.1 UZ7.12
N121617748: CZ39.1 UZ7.10
N121617759: RZ34.1 UZ7.13 UZ7.14
N121617766: RZ36.1 UZ7.8 UZ7.9
N121673930: PC1106.2 PR1112.1
N121674134: PC1130.1 PR1140.2
N121674335: PC1118.1 PR1125.2
N121710332: RH197.2 RH198.1 UH1.AG37
N121712022: RH203.2 RH204.1 UH1.AH38
N121718437: DE7.1 JFAN1.3 RE82.2
N121718548: DE8.1 JFAN2.3 RE84.2
N121775507: PR324.2 PR325.1 PU300.9
N121795600: PL1200.1 PR1200.1 PR1218.1 PU1200.8
N121981266: PH1100.2 PR1105.1 PR1106.2
N121981305: PH1102.1 PR1122.2
N121981509: PH1101.2 PR1121.1
N121981539: PH1103.2 PR1136.1
N122282431: RR9.1 UR1.28
N122314333: RH471.1 RH472.1 UH1.AH37
N122397475: RH145.1 UH1.G29
N122409296: RE13.1 RE14.2 UE1.4
N122409328: RE77.2 UE1.28
N122409465: RE114.2 UE1.21
N122409468: RE113.2 UE1.24
N122409512: RE85.2 UE1.27
N122409618: CE8.1 RE11.2
N122463812: JXDP.1 RH474.1 RH475.1
N122476680: PR1201.1 PR1202.1 PR1218.2
N122477585: PR1205.1 PR1206.1 PR1220.2
N122517438: RH536.2 SW4.1
N122528028: QF1.5 QF1.6 RF3.2
N122563835: RH519.2 UH1.BR33
N122630698: D122.1 RH67.1
N122631012: D122.2 RH590.1
N122687725: RZ58.1 RZ85.1 UZ11.1 UZ20.4
N122698769: T49.1(TP-1) UH1.BL34
N122698770: T39.1(TP-1) UH1.D1
N122698771: T44.1(TP-1) UH1.BT2
N122698772: T42.1(TP-1) UH1.E2
N122698773: T51.1(TP-1) UH1.R14
N122698774: T47.1(TP-1) UH1.H24
N122698775: T45.1(TP-1) UH1.BN35
N122698776: T50.1(TP-1) UH1.N29
N122698777: T53.1(TP-1) UH1.AA14
N122698778: T40.1(TP-1) UH1.E1
N122698779: T43.1(TP-1) UH1.BR1
N122698780: T41.1(TP-1) UH1.E3
N122698781: T48.1(TP-1) UH1.BN33
N122698782: T52.1(TP-1) UH1.AE29
N122698783: T46.1(TP-1) UH1.J24
N122698814: T58.1(TP-1) UH1.E30
N122698815: T63.1(TP-1) UH1.BR35
N122698816: T65.1(TP-1) UH1.BH30
N122698817: T62.1(TP-1) UH1.J3
N122698818: T59.1(TP-1) UH1.B30
N122698819: T64.1(TP-1) UH1.BR31
N122698820: T61.1(TP-1) UH1.G3
N122698821: T57.1(TP-1) UH1.F30
N122698822: T60.1(TP-1) UH1.C30
N122698841: T82.1(TP-1) UH1.BJ33
N122698842: T90.1(TP-1) UH1.C38
N122698843: T85.1(TP-1) UH1.B2
N122698844: T83.1(TP-1) UH1.G13
N122698845: T88.1(TP-1) UH1.BR2
N122698846: T81.1(TP-1) UH1.BJ34
N122698847: T86.1(TP-1) UH1.B38
N122698848: T89.1(TP-1) UH1.C1
N122698849: T84.1(TP-1) UH1.AJ8
N122698850: T87.1(TP-1) UH1.BP1
N122698871: T77.1(TP-1) UH1.BK21
N122698872: T73.1(TP-1) UH1.BJ16
N122698873: T74.1(TP-1) UH1.BK16
N122698874: T80.1(TP-1) UH1.BR17
N122698875: T75.1(TP-1) UH1.BK24
N122698876: T78.1(TP-1) UH1.BJ21
N122698877: T76.1(TP-1) UH1.BJ24
N122698878: T79.1(TP-1) UH1.BT17
N122698895: T66.1(TP-1) UH1.BM33
N122698896: T68.1(TP-1) UH1.BJ14
N122698897: T71.1(TP-1) UH1.BJ28
N122698898: T69.1(TP-1) UH1.BJ13
N122698899: T67.1(TP-1) UH1.BL33
N122698900: T70.1(TP-1) UH1.BK28
N122706757: PR806.2 PR809.1 PR810.2
N122739033: RZ59.2 UZ11.2
N122739099: RZ60.1 RZ86.1 UZ12.1 UZ21.4
N122739340: RZ61.2 UZ12.2
N122754331: RZ67.1 UZ16.7 UZ16.8
N122754354: CZ57.1 UZ16.6
N122755391: CZ82.1 RZ48.2 UZ9.6
N122774125: PR804.2 PR808.1 PR813.2
N122912247: CZ28.1 RZ66.1 UZ15.6
N123346527: QV13.1 RV512.2 RV513.2 RV514.2 RV515.2 RV516.2 RV517.2 RV518.2 RV519.2
N123360127: RT12.1 UT1.H19
N123360144: RT5.1 UT1.Y18
N123628000: DI1.2 JTS.2
N123983992: PL1301.1 PR1307.1 PR1314.1 PU1301.8
N123984002: PR1305.1 PR1306.1 PR1314.2
N123984012: PC1355.1 PC1356.1 PC1357.1 PC1358.1 PJP1301.1 PL1305.2 PQ1300.2 PQ1300.3 PQ1300.4 PQ1300.10
N123984055: PR1311.1 PU1302.2
N123984061: PC1313.1 PL1306.1 PQ1300.9 PR1308.1 PU1302.8
N123984063: PQ1300.1 PU1302.1
N123984071: PC1313.2 PR1311.2
N123984081: PR1301.1 PR1303.1 PR1312.2
N123984161: PC1365.1 PR1308.2
N123984213: PR1304.1 PR1315.2
N123984281: PL1306.2 PR1309.1
N123984351: PQ1300.8 PU1302.5
N123984423: PC1347.1 PR1307.2
N123984459: PC1318.1 PR1300.2
N123984461: PL1300.1 PR1300.1 PR1312.1 PU1300.8
N123985122: PR1302.2 PR1313.2
N124211085: RT164.2 UT1.F19
N124494273: RT181.1 UT4.C10
N124494447: RT1094.2 RT1095.2 UT4.B1 UT4.H1
N124494860: CT158.1 UT4.H7
N124494892: RT191.1 UT4.G2
N124539694: T187.1(TP-1) UT4.G11
N124539765: RT182.1 UT4.D7
N124607348: QV89.1 RT195.1
N124730498: RT178.1 UT4.C2
N124730527: T185.1(TP-1) UT4.B2
N124730838: JXDP.60 RH573.1
N124752685: CH101.2 RH211.1
N124753277: CH100.2 RH212.1
N124754324: RT189.1 RT199.1 RT246.1 UT4.F10
N124755309: RT430.1 UT4.F2
N124755351: T193.1(TP-1) UT4.G4
N124755352: T194.1(TP-1) UT4.F4
N124759625: RT226.2 UT4.E4
N124759627: RT227.2 UT4.D5
N124817422: RH580.1 UH2.AD10
N124817429: RH581.1 UH2.AG2
N125046794: RZ75.2 RZ76.2 UZ7.5
N125173025: RT190.1 UT4.F1
N125233563: PC1138.2 PR1143.2
N125273664: T195.1(TP-1) UT1.E2
N125742089: RH586.1 RH587.1 UH7.5
N125743729: RE125.2 UE1.29
N125814267: RN34.1 UN3.7 UN3.8
N125814346: CN22.1 UN3.6
N125836022: RZ72.2 RZ90.2 UZ16.3
N125846238: RT186.1 RT245.1 UT4.E11
N125857121: RZ35.1 UZ8.1
N125861425: QZ9.1 RZ37.1
N125925558: CT106.1 UT3.6
N125927628: RT240.2 UT3.3
N125960908: RZ81.2 UZ19.2
N126729390: DZ1.1 RZ89.2 UZ18.2
N126843005: LED6.2 RE3.2
N126911279: QE2.1 QE19.1
N127291407: CZ31.1 UZ5.6
N127291517: RZ26.1 UZ5.7 UZ5.8
N127715891: RV547.2 UV17.8
N127994048: T200.1(TP-1) UT4.E10
N128723303: PL1500.1 PR1512.1 PU1502.5 PU1502.6 PU1502.7
N128723349: PC1521.1 PR1512.2
N128725561: PC1054.1 PR1016.2 PR1018.2 PU1001.10
N128725563: PC1022.1 PR1010.2
N128725569: PC1047.2 PR1015.2
N128725595: PC1055.1 PR1022.1 PU1001.12
N128725605: PC1041.1 PR1013.1 PR1014.2
N128725802: PR1000.2 PR1001.1 PR1002.1 PU1001.4
N128726001: PC1018.1 PR1005.2 PR1006.2 PR1007.1
N128726023: PR1013.2 PU1001.9
N128726031: PC1030.1 PR1012.1 PU1001.18
N128726049: PR1008.2 PR1011.1
N128726112: PC1054.2 PR1021.2 PR1023.2 PU1001.11
N128727405: PC1519.1 PR1510.2
N128727409: PC1532.1 PR1519.1 PU1501.12
N128727430: PC1517.1 PR1505.2 PR1507.1 PR1508.2
N128727456: PR1509.2 PR1511.1
N128727528: PC1522.1 PR1514.2 PR1515.1
N128727776: PC1531.1 PR1516.2 PR1517.2 PU1501.10
N128727796: PC1531.2 PR1520.2 PR1521.2 PU1501.11
N128727911: PR1515.2 PU1501.9
N128727995: PC1520.1 PR1513.1 PU1501.18
N128735760: CA125.1 UA4.10
N128735764: CA124.1 UA4.12
N128735809: RA83.1 UA4.13 UA4.14
N128735813: RA84.1 UA4.8 UA4.9
N128735920: CA137.2 RA77.2 UA3.3
N128737170: JFP.1 R1054.1
N128737185: C2974.1 D2.1 F1.1 JFP.5 JFP.6
N128760761: PR702.2 PU700.21
N128763343: PR703.2 PU700.20
N128763348: PR701.2 PU700.22
N128763482: PC700.1 PR700.2 PU700.19
N128764878: PC701.2 PU700.18
N128783349: PC1534.1 PR706.2 PU700.2
N128783984: PC714.2 PR708.2
N128849465: PC1201.2 PU1200.5
N128849469: PC1201.1 PR1224.1
N128849471: PR1224.2 PU1200.3
N128855110: PC1228.2 PU1201.5
N128855114: PC1228.1 PR1225.1
N128855116: PR1225.2 PU1201.3
N128856156: PC1250.2 PU1202.5
N128856160: PC1250.1 PR1226.1
N128856162: PR1226.2 PU1202.3
N128861659: PC1308.2 PU1300.5
N128861671: PC1308.1 PR1320.1
N128861673: PR1320.2 PU1300.3
N128862470: PC1337.2 PU1301.5
N128862480: PC1337.1 PR1321.1
N128862482: PR1321.2 PU1301.3
N128955515: PQ205.1 PR203.2
N128955517: PC200.2 PQ200.4 PR201.2 PR205.1
N128955519: PC220.2 PQ201.4 PQ204.1 PR200.2 PR203.1
N128955532: PQ205.2 PR209.2
N128955534: PQ220.1 PR232.2
N128955539: PC222.2 PC289.2 PQ213.4 PQ217.1 PR224.2 PR226.1
N128955543: PQ219.1 PR226.2
N128955551: PC208.2 PC288.2 PQ212.4 PR222.2 PR227.2 PR232.1
N128955561: PQ219.2 PR267.2
