# Allegro board Dell XPS 9560 LA-E331P R10.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_SPI_HOLD#_R: length 171.9
  TOP w0.14: RH576.2 61.48,4.78 v2(61.02,4.33) ; v2(66.49,3.82) 66.68,3.62 67.18,3.62 67.46,3.34 69.44,3.34 69.49,3.29 72.16,3.29 72.8,2.64 73.64,2.64 RH78.2 74.68,2.17 74.74,2.23 75.31,2.23 75.38,2.17 76.26,2.17 RH455.2 76.37,2.38 v2(76.84,2.85)
  IN1 w0.076: v2(76.84,2.85) 77.74,3.76 79.28,3.76 79.85,3.18 81.85,3.18 81.98,3.31 83.8,3.31 84.47,2.64 v2(84.92,2.64)
  IN1 w0.099: v2(66.49,3.82) 66.17,3.82 65.69,4.29 65.69,4.68 65.32,5.05 61.75,5.05 v2(61.02,4.33)
  IN3 w0.089: v2(84.92,2.64) 84.92,3.04 85.96,4.08 86.55,4.08 86.89,3.74 88.1,3.74 88.65,4.29 89.97,4.29 90.03,4.35 91.33,4.35 91.46,4.22 92.21,4.22 92.46,4.47 94.66,4.47 95.39,3.74 95.73,3.74 95.81,3.66 97.14,3.66 97.8,3.01 98.75,3.01 99.33,3.59 99.33,5.45 100.13,6.24 101.98,6.24
  IN3 w0.091: 101.98,6.24 105.58,6.24 106.8,7.46 107.72,7.46 107.93,7.67 110.03,7.67 110.61,7.09 110.61,6.95 110.89,6.68 111.95,6.68 112.38,6.25 115.42,6.25 117.42,8.25 118.21,8.25 119.07,9.11 119.59,9.11 122.2,11.73 146.35,11.73 147.55,10.52 149.94,10.52 150.6,9.87 150.6,9.53 151.53,8.6 154,8.6 154.69,7.91 159,7.91 159.19,8.1 161.81,8.1 162.24,8.54 167.83,8.54 169.31,10.01 178.16,10.01 179.04,9.14 184,9.14 184.2,9.34 188.6,9.34 191.12,6.82 195.39,6.82 195.84,6.38 199.02,6.38 v2(199.05,6.35)
  BOTTOM w0.089: UH2.BD30 85.2,4.48 84.96,4.24 84.96,4.24 84.96,2.68 v2(84.92,2.64)
  BOTTOM w0.14: 207.79,12.79 207.43,12.79 207.29,12.92 JSPI1.7 ; 207.79,12.79 207.79,10.89 207.34,10.44 204.59,10.44 203.92,9.77 203.92,8.89 201.42,6.38 v3(200.08,6.38) 199.08,6.38 v2(199.05,6.35) ; 207.79,12.79 JSPI1.8
PCH_SPI_SI: length 11.2
  BOTTOM w0.14: RP4.2 67.88,2.36 68.26,1.98 68.26,1.47 68.07,1.28 66.01,1.28 65.11,2.18 64.81,2.18 v3(64.17,2.82) 64.17,3.25 63.47,3.95 62.62,3.95 62.04,4.53 62.04,5.18 61.88,5.34 UH8.5
PCH_SPI_SI_R: length 173.6
  TOP w0.14: RH578.2 67.27,2.29 69.52,2.29 v2(69.53,2.28) 71.11,2.28 v3(71.18,2.21)
  IN1 w0.099: v2(69.53,2.28) 69.71,2.28 70.2,2.77 70.2,2.77 70.24,2.77 70.45,2.99 73.39,2.99 74.36,2.01 75.31,2.01 75.5,1.82 84.09,1.82 84.27,1.65 84.27,1.53 84.46,1.34 84.89,1.34 v2(85.28,1.74)
  IN3 w0.089: v2(85.28,1.74) 85.28,2 85.94,2.66 87.03,2.66 87.34,2.96 87.82,2.96 88.8,3.93 90.12,3.93 90.18,3.99 91.19,3.99 91.32,3.86 92.35,3.86 92.61,4.11 94.51,4.11 94.77,3.86 94.77,3.41 95.57,2.6 98.84,2.6 99.7,3.45 99.7,4.68 99.93,4.92 101.91,4.92 101.91,4.92 101.98,4.92
  IN3 w0.091: v2(203.39,6.37) 202.45,5.43 193.01,5.43 192.66,5.78 191.21,5.78 190.87,5.43 189.02,5.43 186.86,7.59 162.64,7.59 161.4,6.36 157.18,6.36 156.71,6.83 154.68,6.83 154.58,6.72 151.96,6.72 151.55,7.13 149.61,7.13 145.96,10.78 122.6,10.78 118.88,7.07 118.58,7.07 118.47,6.97 117.89,6.97 117.42,6.49 117.42,5.91 116.81,5.3 111.99,5.3 111.57,5.72 109.84,5.72 109.23,6.33 108.66,6.33 108.66,6.34 107.61,6.34 107.24,5.97 106.64,5.97 105.59,4.92 101.98,4.92
  BOTTOM w0.089: v2(85.28,1.74) 85.47,1.92 85.47,2.92 85.34,3.04 85.34,3.91 85.43,3.99 85.43,4.87 85.53,4.96 85.53,5.15 85.74,5.36 UH2.BB29
  BOTTOM w0.14: RP4.7 69.45,2.36 v2(69.53,2.28) 69.55,2.29 69.84,2.29 70.09,2.54 70.09,3.01 RH489.1 ; 212.36,12.85 212.29,12.91 JSPI1.17 ; 212.36,12.85 212.36,9.32 211.39,8.35 206.71,8.35 204.28,5.92 203.79,5.92 203.39,6.32 v2(203.39,6.37) ; 212.36,12.85 212.38,12.83 212.69,12.83 212.79,12.93 JSPI1.18
PCH_SPI_SO: length 8.9
  BOTTOM w0.14: UH8.2 66.87,7.88 66.55,7.57 66.55,5.34 66.55,5.02 66.43,4.9 66.11,4.9 65.84,4.63 65.84,3.56 v3(65.87,3.52) 66.54,2.86 RP4.3
PCH_SPI_SO_R: length 168.9
  TOP w0.14: v2(69.53,2.86) 69.49,2.82 67.17,2.82 RH577.2
  IN1 w0.076: v2(84.71,1.72) 84.42,2.01 80.68,2.01 80.64,2.05 75.7,2.05 75.26,2.49 75.06,2.49
  IN1 w0.099: v2(69.53,2.86) 69.92,3.25 70.04,3.25 70.26,3.47 73.58,3.47 74.53,2.52 74.83,2.52 74.86,2.49 75.06,2.49
  IN3 w0.089: 101.98,5.76 99.9,5.76 99.52,5.38 99.52,3.53 98.82,2.83 97.72,2.83 97.07,3.48 95.73,3.48 95.66,3.56 95.32,3.56 94.59,4.29 92.53,4.29 92.28,4.04 91.39,4.04 91.26,4.17 90.1,4.17 90.04,4.11 88.72,4.11 88.17,3.56 86.81,3.56 86.47,3.9 86.03,3.9 85.57,3.44 85.57,2.65 84.71,1.79 v2(84.71,1.72)
  IN3 w0.091: 101.98,5.76 105.77,5.76 106.45,6.44 107.05,6.44 107.42,6.81 108.85,6.81 108.86,6.8 110.09,6.8 110.69,6.2 111.75,6.2 112.18,5.77 115.61,5.77 117.61,7.77 118.4,7.77 119.27,8.64 119.79,8.64 122.4,11.25 146.15,11.25 147.36,10.05 149.74,10.05 150.12,9.67 150.12,8.41 150.67,7.86 154.07,7.86 154.49,7.44 159.2,7.44 159.39,7.63 162,7.63 162.44,8.07 173.09,8.07 173.86,8.84 177.68,8.84 178.45,8.07 187.06,8.07 189.22,5.91 190.67,5.91 191.02,6.25 192.85,6.25 193.2,5.91 202.23,5.91 203.16,6.84 203.49,6.84 v2(203.99,6.35)
  BOTTOM w0.089: v2(84.71,1.72) 85.29,2.3 85.29,2.85 85.14,3 85.14,4 85.2,4.05 UH2.BE30
  BOTTOM w0.14: 211.36,13.04 211.29,13.1 JSPI1.15 ; 211.36,13.04 211.62,13.04 211.79,13.21 JSPI1.16 ; 211.36,13.04 211.36,9.59 210.64,8.87 206.4,8.87 203.99,6.46 v2(203.99,6.35) ; v2(69.53,2.86) RP4.6
PCH_SPI_WP#: length 5.4
  BOTTOM w0.14: UH8.3 67.32,6.61 67.07,6.36 67.07,5.23 67.51,4.79 67.67,4.79 67.99,4.47 67.99,3.5 67.85,3.36 RP4.4
PCH_SPI_WP#_R: length 168.5
  TOP w0.14: RH573.2 69.23,3.86 v2(68.51,3.86) ; RH75.2 81.03,2.74 v2(81.1,2.82)
  IN1 w0.076: v2(85.8,1.51) 85.8,1.91 85.42,2.28 84.6,2.28 83.73,3.15 82.64,3.15 82.31,2.82 v2(81.1,2.82) 80.13,2.82 79.69,2.38 76.08,2.38 75.22,3.24 75.22,4.02 75.06,4.19
  IN1 w0.099: v2(68.51,3.86) 68.89,3.86 69.77,4.73 72.05,4.73 72.14,4.82 73.8,4.82 74.27,4.35 74.9,4.35 75.06,4.19
  IN3 w0.089: 101.98,4.17 101.55,4.17 101.51,4.12 100.62,4.12 98.92,2.42 95.5,2.42 94.59,3.33 94.59,3.79 94.44,3.94 92.68,3.94 92.43,3.68 91.86,3.68 90.55,2.37 90.11,2.37 89.78,2.05 87.33,2.05 87.17,1.88 86.17,1.88 v2(85.8,1.51)
  IN3 w0.091: 101.98,4.17 105.51,4.17 106.84,5.5 107.44,5.5 107.81,5.87 108.58,5.87 109.69,4.76 112.52,4.76 112.93,4.35 116.53,4.35 118.78,6.6 119.08,6.6 121.85,9.36 134.37,9.36 135.15,10.15 145.69,10.15 149.34,6.5 151.44,6.5 151.68,6.25 154.77,6.25 154.88,6.36 156.51,6.36 156.98,5.89 161.6,5.89 162.83,7.12 186.67,7.12 188.83,4.96 191.06,4.96 191.41,5.31 192.46,5.31 192.81,4.96 203.18,4.96 205.18,6.96 v2(205.18,9.13)
  BOTTOM w0.089: UH2.BC29 85.76,4.79 85.61,4.64 85.61,3.92 85.52,3.83 85.52,3.12 85.64,3 85.64,1.93 85.8,1.78 v2(85.8,1.51)
  BOTTOM w0.14: v2(68.51,3.86) 68.51,3.85 68.51,3.5 68.65,3.36 RP4.5 ; 208.79,12.85 208.42,12.85 208.29,12.98 JSPI1.9 ; 208.79,12.85 JSPI1.10 ; 208.79,12.85 208.79,10.55 208.15,9.91 205.97,9.91 v2(205.18,9.13)
PCH_SRTCRST#: length 3.5
  TOP w0.089: RH83.2 93.22,4.33 CH52.1 94.11,5.47 94.71,6.08 v2(95.1,6.08)
  BOTTOM w0.089: UH2.BB10 94.83,5.81 v2(95.1,6.08)
PCH_SYS_PWROK_XDP: length 189.1
  TOP w0.14: v2(63.69,3.12) 63.69,3.31 63.12,3.88 62.77,3.88 62.23,4.42 62.23,5.09 61.88,5.44 61.88,6.3 61.02,7.16 61.02,7.85 60.65,8.22 60.65,9.18 60.42,9.42 59.14,9.42 58.91,9.64 58.91,9.96 59.14,10.19 59.44,10.49 59.59,10.49 60.22,11.12 60.22,11.41 v3(60.84,12.03) 61.51,12.69 61.51,13.89 64.12,16.51 64.12,17.8 65.08,18.75 65.08,20.34 64.64,20.77 64.64,21.6 64.2,22.04 63.25,22.04 61.85,23.44 61.85,27.51 62.17,27.83 v2(62.17,28.36) ; v2(125.65,95.61) 125.65,95.77 126.51,96.62 126.73,96.62 127.13,97.01 JXDP.47
  IN2 w0.099: v2(63.69,3.12) 64.26,3.69 64.92,3.69 65.62,2.99 69.09,2.99 69.37,3.27 69.7,3.27 70.39,2.58 v2(72.07,2.58) ; v2(131.66,93.19) 131.64,93.21 130.39,93.21 127,96.61 126.51,96.61 125.65,95.75 v2(125.65,95.61) ; v2(104.84,34.24) 104.84,35.12 104.52,35.44 100.17,35.44 97.77,33.05 88.88,33.05 84.99,29.16 81.34,29.16 79.67,27.48 73.98,27.48 71.44,24.94 66.64,24.94 63.22,28.36 v2(62.17,28.36)
  IN6 w0.099: v2(104.84,34.24) 104.9,34.3 104.9,36.97 105.47,37.54 108.33,37.54 116.25,45.46 116.25,52.57 116.82,53.13 116.82,55.29 117.95,56.42 117.95,60.75 120.84,63.64 120.84,64.32 121.82,65.31 124.26,65.31 125.11,66.15 125.11,69.11 127.09,71.09 127.09,76.21 130,79.12 130,83.94 129.69,84.25 129.25,84.25 127.95,85.54 127.95,92.17 126.71,93.42 123.98,93.42 123.72,93.67 123.72,95.18 124.16,95.61 v2(125.65,95.61)
  BOTTOM w0.14: RH489.2 72.07,2.82 v2(72.07,2.58) ; v2(131.66,93.19) 129.21,93.19 RH490.2 RH493.2
PCH_TPM_CLK: length 100.6
  TOP w0.14: RE115.1 148.79,9.15 148.66,9.15 148.34,9.47 v2(148.34,9.47) ; RH579.1 65.88,1.77 65.61,2.04 v1(65.28,2.04) 64.36,2.96 64.36,3.53 62.31,5.58 v2(62.31,5.67)
  IN2 w0.089: 75.06,2.78 75.34,2.78 75.73,2.38 81.66,2.38 82.88,3.59 83.65,3.59 84.22,4.16 85.28,4.16 85.73,4.61 88.15,4.61 88.27,4.74 92.12,4.74 92.51,5.13 95.19,5.13 95.89,5.83 96.2,5.83 96.62,6.24 97.77,6.24 98.14,6.61 99.15,6.61 99.7,7.15 100.21,7.15 100.91,7.85 101.98,7.85
  IN2 w0.099: v2(62.31,5.67) 68.61,5.67 69.52,4.75 71.5,4.75 72.29,3.96 73.55,3.96 74.73,2.78 75.06,2.78 ; 101.98,7.85 108.11,7.85 108.4,8.14 110.43,8.14 110.79,7.77 114.7,7.77 117.4,10.47 146.19,10.47 147.26,9.41 148.27,9.41 v2(148.34,9.47)
PCH_TPM_CLK_C: length 2.7
  TOP w0.14: UE1.19 151.21,7.93 150.88,8.26 v2(150.84,8.26) 150.28,7.71 RE11.1 149.33,7.71 RE115.2
PCH_TPM_SI: length 96.2
  TOP w0.14: RE114.1 148.4,6.65 146.92,8.13 v2(146.92,8.26) ; RH578.1 65.8,2.27 65.41,2.66 65.41,3.13 64.93,3.61 64.93,4.21 65.15,4.43 v2(65.15,4.64) 64.94,4.86 64.44,4.86 v1(64.26,4.68)
  IN2 w0.089: 101.98,6.78 99.93,6.78 98.26,5.11 97.36,5.11 97.03,4.78 92.66,4.78 92.26,4.38 88.42,4.38 88.29,4.26 85.9,4.26 85.45,3.81 84.37,3.81 83.8,3.24 83.03,3.24 81.81,2.02 75.47,2.02 75.12,2.37 75.06,2.37
  IN2 w0.099: 75.06,2.37 74.4,2.37 73.59,3.18 72.5,3.18 71.34,4.34 69.51,4.34 68.91,3.74 68.91,3.69 68.62,3.39 66.27,3.39 65.91,3.76 65.91,4.07 65.34,4.64 v2(65.15,4.64) ; 101.98,6.78 104.15,6.78 104.82,7.45 107.52,7.45 108.39,6.59 113.14,6.59 113.92,7.37 115.85,7.37 117.76,9.28 127.66,9.28 127.77,9.17 135.53,9.17 135.88,9.53 146.33,9.53 146.92,8.94 v2(146.92,8.26)
PCH_TPM_SO: length 98.5
  TOP w0.14: RE113.1 150.99,2.22 148.35,2.22 147.62,2.95 v1(147.62,5.04) 147.62,6.09 146.14,7.57 v2(146.14,9.04) ; v2(65.36,4.03) 65.79,4.03 65.93,3.89 RH577.1
  IN2 w0.089: 101.98,6.58 99.99,6.58 98.33,4.93 97.43,4.93 97.1,4.6 92.74,4.6 92.34,4.2 88.49,4.2 88.37,4.08 85.97,4.08 85.52,3.63 84.44,3.63 82.66,1.84 75.39,1.84 75.06,2.17
  IN2 w0.099: 75.06,2.17 74.27,2.17 74.02,2.42 72.97,2.42 71.26,4.14 69.6,4.14 69.11,3.65 69.11,3.61 68.7,3.19 66.19,3.19 v2(65.36,4.03) ; v2(146.14,9.04) 145.95,9.23 135.87,9.23 135.61,8.97 127.63,8.97 127.52,9.08 117.84,9.08 115.93,7.17 114.03,7.17 113.25,6.39 108.31,6.39 107.44,7.25 104.91,7.25 104.24,6.58 101.98,6.58
PCH_TRIGGER: length 141.4
  TOP w0.14: RH167.1 182.39,62.29 v2(183.39,61.29)
  IN5 w0.099: v2(176.37,23.86) 176.63,23.6 176.63,20.66 175.76,19.79 175.76,19.32 174.55,18.12 133.13,18.12 132.83,18.42 106.71,18.42 v2(105.72,19.42)
  IN6 w0.099: v2(183.39,61.29) 185.79,61.29 189.23,57.84 189.23,44.58 177.27,32.61 177.27,27.66 176.33,26.71 175.91,26.71 175.52,26.32 175.52,24.39 176.05,23.86 v2(176.37,23.86)
  BOTTOM w0.089: 101.96,11.22 101.63,10.89 99.12,10.89 99.02,10.99 UH2.AL2
  BOTTOM w0.127: 101.96,11.22 103.9,11.22 104.34,11.67 105.34,11.67 106.33,12.66 v1(106.33,13.32) 106.33,15.87 106.26,15.93 106.26,17.69 105.72,18.23 v2(105.72,19.42)
PCH_TRIGGER_R: length 21.6
  TOP w0.14: RH167.2 181.9,63.2 v2(182.22,63.52) 182.44,63.74 v3(182.44,64.32)
  IN6 w0.089: 181.1,64.05 179.58,64.05 177.78,65.86 177.78,67.86 177.47,68.17 177.47,75.62 177.23,75.87 174.25,75.87 v2(173.86,75.47)
  IN6 w0.099: 181.1,64.05 181.69,64.05 v2(182.22,63.52)
  BOTTOM w0.076: v2(173.86,75.47) 173.48,75.84 UH1.H23
PCH_XDP_CLK_N: length 98.8
  TOP w0.152: v2(125.83,94.98) 125.73,94.88 124.93,94.88 124.38,95.42 123.74,95.42 123.65,95.51 JXDP.42
  IN6 w0.107: v2(100.72,20.47) 100.67,20.52 100.67,21.87 99.47,23.07 99.47,24.46 99.14,24.79 99.14,28.17 102.38,31.41 104.57,31.41 116.94,43.78 116.94,51.83 117.57,52.46 117.57,54.97 118.63,56.03 118.63,59.96 122.12,63.45 123.32,63.45 125.86,65.99 125.86,68.79 127.77,70.7 127.77,75.93 131.03,79.18 131.03,84.79 129.08,86.73 129.08,92.9 127.31,94.67 126.14,94.67 v2(125.83,94.98)
  BOTTOM w0.102: UH2.L1 99.51,20.7 99.71,20.51 99.71,20.35 100.01,20.05 100.31,20.05 v2(100.72,20.47)
PCH_XDP_CLK_P: length 98.3
  TOP w0.152: JXDP.40 123.63,95.01 123.71,95.09 124.25,95.09 124.79,94.55 125.67,94.55 v2(125.83,94.38)
  IN6 w0.107: v2(125.83,94.38) 125.92,94.47 127.22,94.47 128.88,92.81 128.88,86.65 130.82,84.71 130.82,79.27 127.57,76.01 127.57,70.78 125.66,68.87 125.66,66.07 123.23,63.65 122.04,63.65 118.43,60.04 118.43,56.12 117.36,55.05 117.36,52.54 116.74,51.92 116.74,43.87 104.49,31.62 102.3,31.62 98.93,28.26 98.93,24.71 99.26,24.38 99.26,22.99 100.47,21.78 100.47,20.75 v2(100.17,20.44)
  BOTTOM w0.102: v2(100.17,20.44) 99.82,20.79 99.82,20.79 99.63,20.98 99.21,20.98 98.93,20.7 UH2.L2
PCI_CLK_LPC1: length 216.3
  TOP w0.14: v3(283.31,21.62) 283.3,21.61 v2(283.3,20.74)
  IN3 w0.091: v2(283.3,20.74) 283.3,20.42 281.94,19.06 281.94,18.42 281.73,18.2 281.73,17.38 275.55,11.2 274.42,11.2 271.22,7.99 267.93,7.99 267.45,8.47 258.35,8.47 256.66,6.78 246.7,6.78 246.29,6.37 244.33,6.37 242.58,8.12 235.72,8.12 235.38,7.78 235.03,7.43 235.03,7.43 234.1,6.5 211.93,6.5 210.6,7.83 206.9,7.83 203.43,4.36 192.56,4.36 192.21,4.71 191.66,4.71 191.31,4.36 187.31,4.36 186.68,4.99 181.01,4.99 180.19,5.81 178.8,5.81 178.35,6.25 174.82,6.25 174.73,6.17 172.72,6.17 172.38,5.82 162.38,5.82 161.85,5.29 156.73,5.29 156.57,5.45 155.41,5.45 155.26,5.6 153.16,5.6 153.01,5.45 152.68,5.45 152.53,5.6 151.49,5.6 151.19,5.9 148.63,5.9 144.98,9.55 135.4,9.55 134.62,8.76 122.1,8.76 119.33,6 119.02,6 116.78,3.76 112.68,3.76 112.27,4.16 109.34,4.16 108.88,4.62 108.44,4.62 v2(107.79,5.27)
  BOTTOM w0.14: CH199.1 109.11,4.86 108.2,4.86 v2(107.79,5.27) 107.59,5.47 106.63,5.47 RH428.2 ; v2(283.3,20.74) 284.48,20.74 287.86,24.11 289.34,24.11 290,24.77 290.66,24.77 290.73,24.84 292.73,24.84 293.36,25.47 293.94,25.47 294.2,25.73 294.2,26.19 295.03,27.02 295.03,28.5 295.83,29.29 295.83,29.83 296.2,30.21 JLPDE1.10
PCIE_PRX_CARDTX_N2: length 264
  IN2 w0.107: v2(328.33,29.83) 328.6,29.56 328.6,29.37 328.08,28.85 326.34,28.85 313.44,15.95 313.44,12.76 310.01,9.33 303.35,9.33 302.87,9.82 296.94,9.82 295.9,8.77 295.9,8.63 295.1,7.83 293.61,7.83 292.98,8.46 288.35,8.46 287.97,8.85 283.09,8.85 280.77,11.16 272.56,11.16 271.59,12.14 262.66,12.14 261.95,11.42 249.1,11.42 248.98,11.54 243.38,11.54 243.18,11.74 236.8,11.74 236.48,11.42 234.76,11.42 234.75,11.44 220.24,11.44 219.57,12.11 215.25,12.11 214.29,13.08 185.78,13.08 185.67,12.97 179.69,12.97 178.8,13.85 156.57,13.85 154.59,15.83 151.91,15.83 151.52,16.22 151.52,17.09 151.1,17.51 130.37,17.51 128.65,19.23 108.37,19.23 107.35,18.21 94.73,18.21 94.36,18.57 94.36,22.71 93.75,23.33 92.55,23.33 92.29,23.07 92.05,23.07 91.9,23.22 v2(91.9,23.43)
  BOTTOM w0.089: v2(91.9,23.43) 91.56,23.77 UH2.E17
  BOTTOM w0.152: CR13.1 330.56,31.4 329.4,31.4 328.41,30.41 328.41,29.9 v2(328.33,29.83)
PCIE_PRX_CARDTX_N2_C: length 10.4
  BOTTOM w0.152: UR1.8 338.58,34.36 338.53,34.31 338.53,32.91 336.65,31.03 v5(335.41,31.03) 331.69,31.03 331.53,31.19 331.53,31.45 CR13.2
PCIE_PRX_CARDTX_P2: length 264
  IN2 w0.107: v2(328.92,29.83) 328.8,29.71 328.8,29.28 328.17,28.65 326.43,28.65 313.64,15.86 313.64,12.68 310.09,9.13 303.27,9.13 302.78,9.62 297.03,9.62 296.1,8.69 296.1,8.55 295.18,7.63 293.53,7.63 292.89,8.26 288.27,8.26 287.89,8.65 283,8.65 280.69,10.96 272.48,10.96 271.51,11.93 262.75,11.93 262.03,11.22 249.01,11.22 248.89,11.34 243.3,11.34 243.1,11.54 236.88,11.54 236.56,11.22 234.68,11.22 234.67,11.23 220.16,11.23 219.48,11.91 215.17,11.91 214.2,12.87 185.87,12.87 185.75,12.76 179.6,12.76 178.72,13.65 156.48,13.65 154.5,15.63 151.83,15.63 151.32,16.14 151.32,17.01 151.02,17.31 130.28,17.31 128.57,19.02 108.46,19.02 107.44,18 94.64,18 94.16,18.49 94.16,22.63 93.66,23.12 92.63,23.12 92.38,22.87 92.11,22.87 v2(91.94,22.69)
  BOTTOM w0.089: v2(91.94,22.69) 91.62,23.01 UH2.G17
  BOTTOM w0.152: CR10.1 330.77,30.59 330.77,30.94 330.65,31.07 329.53,31.07 328.74,30.28 328.74,30.01 v2(328.92,29.83)
PCIE_PRX_CARDTX_P2_C: length 10.4
  BOTTOM w0.152: UR1.7 338.98,34.51 338.91,34.44 338.91,34.22 338.86,34.17 338.86,32.78 336.79,30.7 v5(333,30.7) 331.8,30.7 CR10.2
PCIE_PRX_SSDTX_N10: length 187.1
  IN1 w0.119: v2(258.75,15.54) 258.9,15.39 259.21,15.39 259.47,15.13 259.47,14.54 258.98,14.05 257.69,14.05 256.58,12.94 252.36,12.94 251.41,13.9 244.86,13.9 244.02,14.74 231.78,14.74 231.59,14.55 216.22,14.55 215.95,14.82 155.79,14.82 154.4,16.21 152.11,16.21 151.68,16.64 151.68,17.18 151.23,17.64 130.49,17.64 129.5,18.63 108.86,18.63 108.85,18.62 103.51,18.62 102.22,19.9 102.22,20.79 99.86,23.15 99.86,23.92 98.32,25.46 94.22,25.46 93.9,25.14 89.53,25.14 88.4,24.01 86.23,24.01 85.88,23.66 85.88,23.23 85.53,22.88 85.15,22.88 v2(85.02,22.75)
  BOTTOM w0.089: v2(85.02,22.75) 85.38,23.11 UH2.G29
  BOTTOM w0.17: JNGFF2.29 259.41,15.54 259.34,15.48 258.81,15.48 v2(258.75,15.54)
PCIE_PRX_SSDTX_N11: length 195.1
  IN1 w0.119: v2(259.22,18.68) 259.05,18.68 258.78,18.41 258.52,18.15 258.52,16.58 255.82,13.88 252.93,13.88 251.79,15.03 245.36,15.03 244.62,15.76 156.28,15.76 155.31,16.72 155.31,17.31 154,18.62 147.3,18.62 147.01,18.91 144.69,18.91 130.75,18.9 129.83,19.82 114.48,19.82 113.51,20.79 113.51,24.55 112.72,25.34 110.69,25.34 107.48,28.54 105.58,28.54 104.99,29.13 104,29.13 102.89,28.02 90.73,28.02 88.13,25.43 86.18,25.43 85.03,24.28 84.5,24.28 83.32,23.1 83.32,21.76 83.21,21.65 83.21,21.04 83.56,20.69 83.78,20.69 v2(83.92,20.54)
  BOTTOM w0.089: v2(83.92,20.54) 84.17,20.8 UH2.L31
  BOTTOM w0.17: JNGFF2.17 259.71,18.54 259.57,18.68 v2(259.22,18.68)
PCIE_PRX_SSDTX_N12: length 198.2
  IN1 w0.119: v2(258.8,21.62) 259.01,21.41 259.15,21.41 259.47,21.1 259.47,20.47 259.04,20.05 258.18,20.05 257.94,19.81 257.94,16.6 256.06,14.72 254.36,14.72 253.64,15.45 249.38,15.45 248.65,16.18 157.07,16.18 156.65,16.6 156.65,17.09 156.21,17.53 155.87,17.53 154.16,19.25 152.06,19.25 151.49,19.82 150.27,19.82 149.83,20.26 149.83,23.47 148.97,24.33 145.19,24.33 144.53,24.99 114.19,24.99 112.88,26.29 111.31,26.29 110.66,26.94 110.66,28.06 109.75,28.97 105.75,28.97 105.17,29.55 102.82,29.55 101.72,28.44 90.08,28.44 87.68,26.04 85.06,26.04 82.49,23.47 82.49,22.5 82.59,22.4 82.72,22.4 82.92,22.6 v2(82.92,22.68)
  BOTTOM w0.089: UH2.G33 83.17,22.93 v2(82.92,22.68)
  BOTTOM w0.17: v2(258.8,21.62) 258.88,21.54 JNGFF2.5
PCIE_PRX_SSDTX_P10: length 187
  IN1 w0.119: v2(258.75,14.96) 258.92,15.13 259.1,15.13 259.21,15.02 259.21,14.65 258.87,14.31 257.58,14.31 256.47,13.2 252.47,13.2 251.51,14.16 244.97,14.16 244.13,15 231.67,15 231.48,14.81 216.33,14.81 216.06,15.08 155.9,15.08 154.51,16.47 152.22,16.47 151.94,16.74 151.94,17.29 151.34,17.9 130.6,17.9 129.6,18.89 108.76,18.89 108.74,18.88 103.61,18.88 102.48,20.01 102.48,20.89 100.12,23.26 100.12,24.03 98.43,25.72 94.11,25.72 93.79,25.4 89.42,25.4 88.3,24.27 86.13,24.27 85.62,23.76 85.62,23.33 85.42,23.14 84.81,23.14 84.71,23.24 84.71,23.38 84.85,23.51 v2(85.02,23.51)
  BOTTOM w0.089: v2(85.02,23.51) 85.21,23.51 UH2.E29
  BOTTOM w0.17: v2(258.75,14.96) 258.84,15.04 JNGFF2.31
PCIE_PRX_SSDTX_P11: length 195.2
  IN1 w0.119: v2(83.92,21.34) 84.18,21.34 84.27,21.25 84.27,21.08 84.14,20.95 83.67,20.95 83.47,21.15 83.47,21.54 83.58,21.65 83.58,23 84.61,24.02 85.14,24.02 86.28,25.17 88.24,25.17 90.83,27.76 103,27.76 104.11,28.87 104.89,28.87 105.47,28.29 107.37,28.29 110.58,25.08 112.61,25.08 113.25,24.44 113.25,20.68 114.37,19.56 129.72,19.56 130.65,18.64 144.69,18.65 146.91,18.65 147.19,18.37 153.89,18.37 155.05,17.2 155.05,16.62 156.17,15.5 244.51,15.5 245.25,14.77 251.68,14.77 252.82,13.62 255.93,13.62 258.78,16.47 258.78,18.04 258.88,18.15 258.95,18.22 259.1,18.22 v2(259.22,18.1)
  BOTTOM w0.089: UH2.K31 84.21,21.34 v2(83.92,21.34)
  BOTTOM w0.17: v2(259.22,18.1) 259.37,18.25 259.41,18.25 259.62,18.04 JNGFF2.19
PCIE_PRX_SSDTX_P12: length 198.1
  IN1 w0.119: v2(258.8,21.04) 258.92,21.15 259.04,21.15 259.21,20.99 259.21,20.58 258.94,20.31 258.07,20.31 257.68,19.92 257.68,16.7 255.96,14.98 254.47,14.98 253.74,15.71 249.49,15.71 248.75,16.44 157.17,16.44 156.91,16.71 156.91,17.2 156.32,17.79 155.98,17.79 154.26,19.51 152.17,19.51 151.6,20.07 150.38,20.07 150.09,20.37 150.09,23.58 149.08,24.59 145.3,24.59 144.64,25.25 114.29,25.25 112.99,26.55 111.42,26.55 110.92,27.05 110.92,28.16 109.86,29.23 105.86,29.23 105.28,29.81 102.72,29.81 101.61,28.7 89.97,28.7 87.57,26.3 84.95,26.3 82.23,23.58 82.23,22.39 82.48,22.14 82.66,22.14 v2(82.89,21.9)
  BOTTOM w0.089: v2(82.89,21.9) 83.15,22.16 UH2.H33
  BOTTOM w0.17: v2(258.8,21.04) 258.88,21.11 259.34,21.11 259.41,21.04 JNGFF2.7
PCIE_PRX_TBTX_N15: length 57.2
  IN6 w0.107: v2(80.16,23.77) 80,23.77 79.86,23.91 79.86,24.25 79.65,24.46 79.52,24.46 79.11,24.86 75.38,24.86 74.39,25.85 66.75,25.85 63.63,28.97 60.63,28.97 59.67,29.93 50.98,29.93 49.48,31.42 45.74,31.42 42.61,34.55 35.45,34.55 32.53,31.63 31.18,31.63 30.98,31.84 30.98,32.39 v2(31.2,32.62)
  BOTTOM w0.089: UH2.F41 79.91,23.52 v2(80.16,23.77)
  BOTTOM w0.152: v2(31.2,32.62) 31.05,32.76 31.05,33.05 CT3.1
PCIE_PRX_TBTX_N15_C: length 3
  BOTTOM w0.089: UT1.V22 30.02,35.84 30.02,35.84 30.03,35.83 30.03,35.29 30.28,35.05 30.52,35.05 31.07,34.5 31.07,34.3
  BOTTOM w0.152: CT3.2 31.07,33.88 31.07,34.3
PCIE_PRX_TBTX_N16: length 58.8
  IN6 w0.107: v2(78.17,23.87) 78.32,23.87 78.41,23.77 78.41,23.63 78.25,23.46 75.9,23.46 74.18,25.18 66.55,25.18 63.84,27.89 60.83,27.89 59.41,29.31 50.72,29.31 49.23,30.81 45.49,30.81 42.37,33.93 35.7,33.93 32.79,31.02 30.69,31.02 30.01,31.7 28.68,31.7 28.29,32.09 28.29,32.29 28.45,32.45 28.45,32.51 28.51,32.57 v2(28.63,32.57)
  BOTTOM w0.089: UH2.D43 78.54,24.1 78.54,23.95 78.47,23.89 78.18,23.89 v2(78.17,23.87)
  BOTTOM w0.152: CT7.1 28.53,33.07 28.53,32.67 v2(28.63,32.57)
PCIE_PRX_TBTX_N16_C: length 2.6
  BOTTOM w0.089: UT1.P22 28.18,35.84 28.18,35.84 28.19,35.83 28.19,35.27 28.24,35.23 28.24,34.53 28.45,34.31
  BOTTOM w0.152: 28.45,34.31 28.45,34.21 28.64,34.02 CT7.2
PCIE_PRX_TBTX_P15: length 57.3
  IN6 w0.107: v2(79.36,23.72) 79.58,23.72 79.66,23.8 79.66,24.16 79.57,24.25 79.43,24.25 79.02,24.66 75.3,24.66 74.31,25.65 66.66,25.65 63.55,28.76 60.55,28.76 59.59,29.72 50.89,29.72 49.4,31.22 45.66,31.22 42.52,34.35 35.54,34.35 32.61,31.43 31.1,31.43 30.77,31.75 30.77,32.39 30.77,32.39 30.77,32.46 v2(30.61,32.62)
  BOTTOM w0.089: UH2.E41 79.66,24.03 v2(79.36,23.72)
  BOTTOM w0.152: CT1.1 30.72,33.07 30.72,32.72 v2(30.61,32.62)
PCIE_PRX_TBTX_P15_C: length 3
  BOTTOM w0.089: UT1.V23 29.79,35.69 29.72,35.76 29.63,35.76 29.56,35.68 29.56,35.37 30.15,34.78 30.41,34.78 30.77,34.42 30.77,34.34 30.74,34.31 30.74,34.3
  BOTTOM w0.152: 30.74,34.3 30.74,33.88 30.62,33.77 CT1.2
PCIE_PRX_TBTX_P16: length 58.8
  IN6 w0.107: v2(78.73,23.41) 78.5,23.41 78.35,23.26 75.81,23.26 74.09,24.98 66.46,24.98 63.76,27.68 60.75,27.68 59.32,29.11 50.64,29.11 49.14,30.6 45.4,30.6 42.28,33.72 35.78,33.72 32.87,30.81 30.6,30.81 29.92,31.49 28.6,31.49 28.08,32.01 28.08,32.57 v2(28.04,32.62)
  BOTTOM w0.089: UH2.E42 78.92,23.59 v2(78.73,23.41)
  BOTTOM w0.152: v2(28.04,32.62) 28.2,32.78 28.2,33.05 CT5.1
PCIE_PRX_TBTX_P16_C: length 2.5
  BOTTOM w0.089: 28.16,34.14 28.16,34.32 27.97,34.5 27.97,35.14 27.72,35.39 27.72,35.68 27.79,35.76 27.88,35.76 27.95,35.69 UT1.P23
  BOTTOM w0.152: 28.16,34.14 28.07,34.05 CT5.2
PCIE_PRX_WLANTX_N1: length 330
  IN2 w0.119: v2(338.99,85.35) 338.8,85.17 338.8,84.81 334.96,80.97 334.96,67.05 341.54,60.47 341.54,35.9 335.98,30.33 327.31,30.33 326.33,29.34 326.14,29.34 312.78,15.99 312.78,12.83 309.82,9.86 303.52,9.86 303.07,10.31 296.66,10.31 296.08,9.74 292.64,9.74 292.14,10.23 289.33,10.23 288.44,9.34 286.15,9.34 285.05,10.44 285.05,11.39 284.29,12.16 284.29,13.36 283.58,14.07 265.79,14.07 265.03,14.84 265.03,15.53 264.64,15.92 264.35,15.92 v2(264.22,15.79)
  IN3 w0.112: v2(93.09,21.88) 93.21,22 93.43,22 93.58,21.85 93.58,18.75 94.39,17.94 103.54,17.94 104.22,17.26 122.73,17.26 124.7,15.29 161.06,15.29 162.69,13.66 231.91,13.66 232.39,13.18 249.99,13.18 253.52,16.71 257.78,16.71 258.53,15.96 264.06,15.96 v2(264.22,15.79)
  BOTTOM w0.089: v2(93.09,21.88) 92.73,22.24 UH2.H15
  BOTTOM w0.17: JNGFF1.35 339.05,84.73 338.86,84.92 338.86,85.23 v2(338.99,85.35)
PCIE_PRX_WLANTX_P1: length 330
  IN2 w0.119: v2(264.22,16.38) 264.42,16.18 264.75,16.18 265.28,15.64 265.28,14.94 265.9,14.33 283.69,14.33 284.54,13.47 284.54,12.26 285.31,11.5 285.31,10.55 286.25,9.6 288.34,9.6 289.22,10.49 292.25,10.49 292.74,9.99 295.98,9.99 296.55,10.57 303.18,10.57 303.63,10.12 309.71,10.12 312.52,12.93 312.52,16.09 326.03,29.6 326.22,29.6 327.21,30.59 335.87,30.59 341.28,36.01 341.28,60.36 334.7,66.94 334.7,81.08 338.54,84.92 338.54,85.21 v2(338.41,85.35)
  IN3 w0.112: v2(93.05,22.65) 92.94,22.54 92.94,22.34 93.02,22.26 93.54,22.26 93.83,21.97 93.83,18.85 94.49,18.19 103.64,18.19 104.32,17.51 122.84,17.51 124.81,15.54 161.16,15.54 162.79,13.91 232.01,13.91 232.5,13.43 249.89,13.43 253.42,16.96 257.88,16.96 258.63,16.21 264.06,16.21 v2(264.22,16.38)
  BOTTOM w0.089: UH2.G15 92.78,23.01 93.05,22.73 v2(93.05,22.65)
  BOTTOM w0.17: JNGFF1.33 338.55,84.62 338.43,84.74 338.43,85.3 338.41,85.32 v2(338.41,85.35)
PCIE_PTX_CARDRX_N2: length 262.1
  IN2 w0.107: v2(326.77,28.08) 326.62,27.92 326.28,27.92 315.59,17.23 314.21,13.57 314.21,12.67 310.22,8.67 308.17,8.67 307.14,7.64 295.77,7.64 295.35,7.21 293.1,7.21 292.56,7.76 288.19,7.76 287.71,8.23 282.77,8.23 281.95,9.05 278.87,10.55 263.45,10.55 263.18,10.82 262.35,10.82 262.2,10.66 248.62,10.66 248.47,10.82 236.92,10.82 236.7,10.59 215.68,10.59 213.95,12.32 201.35,12.32 201.34,12.31 200,12.31 199.16,11.46 196.67,11.46 196.54,11.34 188.81,11.34 188.65,11.5 186.24,11.5 185.86,11.88 178.87,11.88 178.15,12.59 156.86,12.59 155.14,14.31 150.71,14.31 149.22,15.79 130.37,15.79 127.63,18.53 108.56,18.53 107.58,17.55 94.41,17.55 93.73,18.23 93.73,20.51 92.95,21.29 92.15,21.29 91.5,21.94 91.5,23.59 90.83,24.26 90.83,25.79 90.48,26.14 90.21,26.14 v2(89.98,26.36)
  BOTTOM w0.089: UH2.B19 90.7,25.48 90.53,25.65 90.53,25.82 v2(89.98,26.36)
  BOTTOM w0.152: v2(326.77,28.08) 326.95,27.9 327.13,27.9 CR9.1
PCIE_PTX_CARDRX_N2_C: length 17.3
  BOTTOM w0.152: CR9.2 328.22,28.08 328.22,27.83 328.35,27.71 328.86,27.71 329.42,28.27 329.95,28.27 330.82,29.14 v5(334.86,29.14) 337.36,29.14 340.26,32.04 340.26,34.01 340.25,34.02 340.25,34.41 340.18,34.48 UR1.4
PCIE_PTX_CARDRX_P2: length 262.1
  IN2 w0.107: v2(90.02,25.8) 90.15,25.93 90.4,25.93 90.63,25.71 90.63,24.18 91.3,23.5 91.3,21.86 92.07,21.09 92.87,21.09 93.53,20.43 93.53,18.14 94.33,17.34 107.67,17.34 108.65,18.32 127.55,18.32 130.29,15.59 149.14,15.59 150.62,14.11 155.06,14.11 156.77,12.39 178.07,12.39 178.78,11.68 185.78,11.68 186.16,11.3 188.56,11.3 188.73,11.13 196.62,11.13 196.75,11.26 199.24,11.26 200.09,12.11 201.43,12.11 201.43,12.11 213.87,12.11 215.6,10.38 236.78,10.38 237.01,10.61 248.39,10.61 248.54,10.46 262.28,10.46 262.43,10.61 263.1,10.61 263.37,10.35 278.82,10.35 281.83,8.88 282.68,8.03 287.62,8.03 288.1,7.55 292.48,7.55 293.02,7.01 295.44,7.01 295.86,7.43 307.22,7.43 308.26,8.47 310.3,8.47 314.41,12.58 314.41,13.53 315.76,17.11 326.37,27.72 326.57,27.72 326.77,27.52 v2(326.77,27.49)
  BOTTOM w0.089: v2(90.02,25.8) 90.08,25.8 90.43,25.45 90.43,25.06 90.7,24.79 UH2.C19
  BOTTOM w0.152: v2(326.77,27.49) 326.85,27.57 327.05,27.57 CR7.1
PCIE_PTX_CARDRX_P2_C: length 17.3
  BOTTOM w0.152: UR1.3 340.58,34.16 340.59,34.15 340.59,31.9 337.5,28.81 v5(332,28.81) 330.96,28.81 330.08,27.94 329.56,27.94 329,27.38 328.54,27.38 CR7.2
PCIE_PTX_SSDRX_N10: length 188.6
  IN1 w0.119: v2(255.31,16.06) 255.11,15.86 254.57,15.86 252.78,17.65 157.63,17.65 156.63,18.66 156.41,18.66 154.31,20.76 154.31,24.45 152.98,25.78 145.3,25.78 144.86,26.21 114.85,26.21 114.02,27.05 114.02,28.42 112.26,30.18 105.88,30.18 105.56,30.5 102.38,30.5 101.42,29.54 89.79,29.54 87.35,27.1 84.76,27.1 84.68,27.17 83.89,27.17 v2(83.78,27.28)
  BOTTOM w0.089: v2(83.78,27.28) 83.38,26.87 83.38,26.55 83.4,26.53 83.4,25.66 83.61,25.46 83.61,24.93 UH2.C32
  BOTTOM w0.17: CD45.1 256.87,14 256.59,14 256.46,14.13 256.46,15.34 255.82,15.99 255.38,15.99 v2(255.31,16.06)
PCIE_PTX_SSDRX_N10_C: length 2.7
  BOTTOM w0.17: CD45.2 258.33,13.92 259.26,13.92 259.39,14.04 JNGFF2.35
PCIE_PTX_SSDRX_N11: length 190.7
  IN1 w0.119: v2(256.47,18.1) 256.46,18.09 256.46,17.48 256.19,17.2 255.27,17.2 254.4,18.08 158.08,18.08 157.04,19.13 156.55,19.13 156.47,19.21 155.63,20.04 155.63,24.21 153.61,26.24 145.49,26.24 145.01,26.71 116.39,26.71 115.63,27.47 115.63,29.01 113.72,30.92 101.9,30.92 101.02,30.04 89.57,30.04 87.63,28.1 83.9,28.1 83.41,27.61 83.41,27.29 83.08,26.97 83.03,26.97 82.8,26.73 v2(82.8,26.73)
  BOTTOM w0.089: UH2.C33 83.36,24.82 83.25,24.82 83.16,24.91 83.16,25.18 83,25.35 83,26.22 82.89,26.32 82.74,26.32 82.65,26.41 82.65,26.59 82.79,26.73 v2(82.8,26.73)
  BOTTOM w0.17: CD43.1 256.86,17.4 256.71,17.4 256.62,17.31 256.62,16.93 256.53,16.84 256.25,16.84 256.15,16.94 256.15,17.97 256.28,18.1 v2(256.47,18.1)
PCIE_PTX_SSDRX_N11_C: length 2.6
  BOTTOM w0.17: JNGFF2.23 259.3,17.04 259.15,16.9 258.27,16.9 CD43.2
PCIE_PTX_SSDRX_N12: length 190
  IN1 w0.119: v2(255.9,20.09) 255.98,20.01 256.46,20.01 256.7,19.78 256.7,19.14 256.32,18.76 159.26,18.76 157.54,20.49 157.54,24.12 156.24,25.42 155.95,25.42 154.45,26.92 146.04,26.92 142.55,30.41 115.55,30.41 114.36,31.6 101.58,31.6 100.78,30.79 89.22,30.79 87.19,28.76 83.34,28.76 82.25,27.67 82.25,27.33 82.34,27.24 82.34,26.59 81.95,26.2 v2(81.95,26.14)
  BOTTOM w0.089: v2(81.95,26.14) 82.02,26.14 82.42,25.74 82.42,25.19 82.52,25.1 82.65,25.1 82.75,25.19 UH2.B35
  BOTTOM w0.17: v2(255.9,20.09) 256.03,19.96 256.86,19.96 CD37.1
PCIE_PTX_SSDRX_N12_C: length 2.6
  BOTTOM w0.17: CD37.2 258.24,19.97 259.33,19.97 259.4,20.04 JNGFF2.11
PCIE_PTX_SSDRX_P10: length 188.6
  IN1 w0.119: v2(255.31,15.48) 255.18,15.6 254.46,15.6 252.67,17.39 157.52,17.39 156.52,18.4 156.3,18.4 154.05,20.65 154.05,24.35 152.87,25.52 145.19,25.52 144.76,25.95 114.75,25.95 113.76,26.94 113.76,28.31 112.16,29.92 105.77,29.92 105.45,30.24 102.49,30.24 101.53,29.28 89.9,29.28 87.46,26.84 84.65,26.84 84.58,26.91 83.97,26.91 v2(83.74,26.69)
  BOTTOM w0.089: UH2.B32 83.88,25.01 83.98,24.9 84.05,24.9 84.11,24.96 84.11,25.35 83.98,25.48 83.88,25.48 83.62,25.74 83.62,26.17 83.67,26.22 83.94,26.22 84.02,26.31 84.02,26.56 83.9,26.69 v2(83.74,26.69)
  BOTTOM w0.17: CD46.1 256.95,13.49 256.49,13.49 256.03,13.95 256.03,15.16 255.64,15.55 255.38,15.55 v2(255.31,15.48)
PCIE_PTX_SSDRX_P10_C: length 2.5
  BOTTOM w0.17: JNGFF2.37 259.5,13.54 259.44,13.48 258.15,13.48 CD46.2
PCIE_PTX_SSDRX_P11: length 190.7
  IN1 w0.119: v2(255.72,18.11) 255.86,18.11 256.21,17.76 256.21,17.59 256.08,17.46 255.38,17.46 254.5,18.34 158.19,18.34 157.14,19.39 156.66,19.39 155.89,20.15 155.89,24.32 153.71,26.5 145.6,26.5 145.12,26.97 116.5,26.97 115.89,27.58 115.89,29.12 113.83,31.18 101.8,31.18 100.91,30.3 89.46,30.3 87.52,28.36 83.79,28.36 83.15,27.72 83.15,27.4 82.97,27.22 82.82,27.22 82.72,27.33 v2(82.72,27.48)
  BOTTOM w0.089: 82.88,27.31 83.16,27.03 83.16,26.49 83.2,26.45 83.2,25.59 83.36,25.42 UH2.B33
  BOTTOM w0.17: 82.88,27.31 v2(82.72,27.48) ; v2(255.72,18.11) 255.72,16.76 256.07,16.4 256.96,16.4 CD44.1
PCIE_PTX_SSDRX_P11_C: length 2.6
  BOTTOM w0.17: CD44.2 258.22,16.47 259.33,16.47 259.41,16.54 JNGFF2.25
PCIE_PTX_SSDRX_P12: length 190
  IN1 w0.119: v2(255.9,19.5) 256.15,19.75 256.36,19.75 256.44,19.67 256.44,19.25 256.22,19.02 159.37,19.02 157.8,20.6 157.8,24.23 156.35,25.68 156.06,25.68 154.55,27.18 146.15,27.18 142.66,30.67 115.66,30.67 115.51,30.82 114.47,31.86 101.48,31.86 100.67,31.05 89.11,31.05 87.08,29.02 83.23,29.02 83.1,28.89 81.99,27.78 81.99,27.22 82.08,27.13 82.08,26.7 81.92,26.54 81.58,26.54 81.47,26.64 81.47,26.82 81.6,26.96 v2(81.69,26.96)
  BOTTOM w0.089: UH2.A35 82.32,26.17 82.32,26.31 81.68,26.96 v2(81.69,26.96)
  BOTTOM w0.17: CD42.1 256.88,19.53 255.93,19.53 v2(255.9,19.5)
PCIE_PTX_SSDRX_P12_C: length 2.6
  BOTTOM w0.17: CD42.2 258.24,19.54 259.51,19.54 259.51,19.54 JNGFF2.13
PCIE_PTX_TBRX_N15: length 57.5
  IN6 w0.107: v2(80.77,26.23) 81.04,26.23 81.15,26.12 81.15,25.97 80.97,25.78 80.66,25.78 80.21,25.33 75.52,25.33 74.52,26.32 68.29,26.32 65.22,29.4 60.94,29.4 59.31,31.02 53.71,31.02 52.9,31.83 45.91,31.83 42.78,34.97 35.02,34.97 34.03,33.98 32.81,33.98 32.27,33.43 32.27,32.83 v2(32.48,32.62)
  BOTTOM w0.089: v2(80.77,26.23) 80.67,26.34 80.51,26.34 80.36,26.19 80.36,25.61 80.52,25.46 80.52,25.46 80.58,25.4 UH2.B39
  BOTTOM w0.152: CT4.2 32.35,33.09 32.35,32.74 v2(32.48,32.62)
PCIE_PTX_TBRX_N15_C: length 3.2
  BOTTOM w0.089: UT1.Y22 30.94,35.84 30.94,35.44 31.74,34.64 32.03,34.64 32.31,34.36 32.31,34.3
  BOTTOM w0.152: 32.31,34.3 32.31,33.91 CT4.1
PCIE_PTX_TBRX_N16: length 58.2
  IN6 w0.107: v2(79.29,26.22) 79.36,26.15 79.46,26.15 79.62,26.3 79.62,26.6 79.49,26.73 76.1,26.73 75.1,27.73 67.77,27.73 65.2,30.3 61.02,30.3 59.96,31.37 59.96,31.99 59.5,32.45 46.17,32.45 43.03,35.58 34.12,35.58 33.16,34.62 32.5,34.62 31.23,33.35 29.57,33.35 29.45,33.22 29.45,32.99 29.83,32.6 v2(29.94,32.6)
  BOTTOM w0.089: v2(79.29,26.22) 79.62,25.89 79.62,25.81 79.62,25.81 UH2.A41
  BOTTOM w0.152: v2(29.94,32.6) 29.76,32.79 29.76,33.09 CT8.2
PCIE_PTX_TBRX_N16_C: length 2.7
  BOTTOM w0.089: UT1.T22 29.1,35.84 29.1,35.84 29.11,35.83 29.11,35.28 29.59,34.8 29.59,34.37 29.66,34.31 29.66,34.3
  BOTTOM w0.152: 29.66,34.3 29.66,33.96 CT8.1
PCIE_PTX_TBRX_P15: length 57.5
  IN6 w0.107: v2(80.71,26.82) 80.38,26.48 80.38,25.79 80.12,25.53 75.6,25.53 74.61,26.53 68.38,26.53 65.3,29.6 61.02,29.6 59.4,31.23 53.79,31.23 52.98,32.04 46,32.04 42.86,35.17 34.94,35.17 33.95,34.18 32.73,34.18 32.07,33.52 32.07,32.79 v2(31.9,32.62)
  BOTTOM w0.089: UH2.A39 80.82,25.75 81.14,26.07 81.14,26.39 v2(80.71,26.82)
  BOTTOM w0.152: CT2.2 32.02,33.04 32.02,32.74 v2(31.9,32.62)
PCIE_PTX_TBRX_P15_C: length 3.2
  BOTTOM w0.089: UT1.Y23 30.71,35.69 30.64,35.76 30.55,35.76 30.48,35.68 30.48,35.33 30.55,35.25 30.81,35.25 31.6,34.46
  BOTTOM w0.152: CT2.1 31.98,33.87 31.98,34.3 31.9,34.38 31.69,34.38 31.6,34.46
PCIE_PTX_TBRX_P16: length 58.2
  IN6 w0.107: v2(79.99,26.22) 79.82,26.38 79.82,26.69 79.58,26.93 76.18,26.93 75.18,27.93 67.86,27.93 65.29,30.5 61.11,30.5 60.16,31.45 60.16,32.08 59.59,32.65 46.25,32.65 43.12,35.78 34.03,35.78 33.07,34.82 32.41,34.82 31.14,33.55 29.49,33.55 29.24,33.3 v2(29.24,32.62)
  BOTTOM w0.089: v2(79.99,26.22) 79.9,26.13 79.9,25.91 UH2.A40
  BOTTOM w0.152: v2(29.24,32.62) 29.43,32.8 29.43,33.03 CT6.2
PCIE_PTX_TBRX_P16_C: length 2.6
  BOTTOM w0.089: 29.33,34.3 29.33,34.69 28.64,35.38 28.64,35.68 28.72,35.76 28.83,35.76 28.87,35.72 UT1.T23
  BOTTOM w0.152: 29.33,34.3 29.33,33.82 CT6.1
PCIE_PTX_WLANRX_N1: length 317.6
  IN2 w0.119: v2(332.8,79.24) 332.97,79.41 332.98,79.41 333.13,79.57 333.46,79.57 334.02,79.01 334.02,66.66 335.34,65.34 335.34,63.95 339.18,60.12 339.18,46.98 338.06,45.86 338.06,33.9 336.36,32.2 332.04,32.2 331.12,31.28 326.92,31.28 326.02,30.37 323.23,30.37 320.61,27.74 320.61,25.89 315.77,21.05 304.07,21.05 303.41,20.38 295.71,20.38 295.24,19.91 294.9,19.91 293.37,18.39 293.17,18.39 292.51,17.73 291,17.73 290.84,17.89 289.26,17.89 288.84,17.48 287.94,17.48 286.79,16.32 284.59,16.32 283.33,15.06 268.16,15.06 266.95,16.27 265.99,16.27 v2(265.77,16.49)
  IN3 w0.112: v2(265.77,16.49) 265.59,16.3 265.41,16.3 264.34,17.37 258.74,17.37 258.42,17.69 253.22,17.69 250,14.47 243.62,14.47 243.1,14.99 232,14.99 231.59,14.57 163.17,14.57 161.55,16.2 125.79,16.2 123.7,18.29 104.47,18.29 102.79,19.98 96.88,19.98 95.49,21.36 95.49,21.61 92.63,24.47 92.63,25.04 91.99,25.68 91.99,26.28 92.21,26.5 92.39,26.5 92.52,26.37 92.52,26.17 v2(92.46,26.11)
  BOTTOM w0.089: UH2.A16 91.98,25.88 91.98,26.08 92.07,26.17 92.39,26.17 v2(92.46,26.11)
  BOTTOM w0.17: v2(332.8,79.24) 331.86,79.24 331.12,79.99 331.12,80.5 CN20.1
PCIE_PTX_WLANRX_P1: length 317.7
  IN2 w0.119: v2(332.8,79.83) 333.57,79.83 334.28,79.11 334.28,66.77 335.6,65.44 335.6,64.06 339.44,60.22 339.44,46.87 338.32,45.75 338.32,33.8 336.47,31.94 332.15,31.94 331.22,31.02 327.03,31.02 326.12,30.11 323.34,30.11 320.87,27.63 320.87,25.78 315.88,20.79 304.18,20.79 303.51,20.12 295.82,20.12 295.35,19.65 295,19.65 293.48,18.13 293.28,18.13 292.62,17.47 290.9,17.47 290.74,17.63 289.36,17.63 288.95,17.22 288.05,17.22 286.89,16.06 284.7,16.06 283.43,14.8 268.05,14.8 266.84,16.01 265.88,16.01 v2(265.77,15.91)
  IN3 w0.112: v2(91.62,26.13) 91.75,26.01 91.75,25.58 92.39,24.94 92.39,24.37 95.25,21.51 95.25,21.26 96.78,19.73 102.69,19.73 104.37,18.05 123.6,18.05 125.69,15.96 161.44,15.96 163.07,14.33 231.69,14.33 232.1,14.74 243,14.74 243.52,14.22 250.1,14.22 253.32,17.44 258.32,17.44 258.64,17.12 264.24,17.12 265.3,16.06 265.62,16.06 v2(265.77,15.91)
  BOTTOM w0.089: UH2.B16 91.84,25.31 91.57,25.58 91.57,26.08 v2(91.62,26.13)
  BOTTOM w0.17: CN21.1 331.97,80.79 331.73,80.79 331.55,80.61 331.55,80.17 332.04,79.68 332.65,79.68 v2(332.8,79.83)
PCIE_PTX_WLANRX_RE_N1: length 11.9
  BOTTOM w0.17: CN20.2 330.96,84.24 332.97,86.24 336.76,86.24 337.55,85.44 JNGFF1.29
PCIE_PTX_WLANRX_RE_P1: length 11.9
  BOTTOM w0.17: CN21.2 332.11,81.29 331.94,81.12 331.64,81.12 331.56,81.2 331.47,81.29 331.47,82.05 331.39,82.13 v1(331.39,82.55) 331.39,84.06 333.15,85.81 336.58,85.81 337.12,85.27 337.12,84.84 337.05,84.78 JNGFF1.27
PCIE_WAKE#: length 156.7
  TOP w0.14: RD59.2 268.55,8.2 269.69,8.2 270.12,8.64 v1(271.15,8.64) 271.58,8.64 271.89,8.94 v2(271.89,9.29) ; RE120.2 302.69,3.6 302.04,2.95 301.25,2.95 300.86,3.34 RE19.1 300.55,3.82 v2(300.15,3.43) ; UE3.B8 v2(298.52,11.47)
  IN3 w0.091: v2(300.15,3.43) 299.76,3.82 299.76,7.26 299.16,7.86 299.16,9.81 298.52,10.45 v2(298.52,11.47)
  IN6 w0.099: v2(271.89,9.29) 273.67,9.29 275.44,11.06 281.34,11.06 282.33,12.06 284.22,12.06 284.36,11.92 285.6,11.92 286.14,12.47 286.14,13.47 287.12,14.45 288.75,14.45 289.26,13.94 289.73,13.94 290.47,13.19 297.2,13.19 297.99,12.4 297.99,12 v2(298.52,11.47) 298.97,11.92 298.97,12.34 299.33,12.7 301.22,12.7 301.45,12.47 303.21,12.47 304.9,14.16 307.1,14.16 307.63,14.69 311.66,14.69 313.18,16.22 313.18,16.85 317.16,20.82 317.16,24.95 317.64,25.43 317.64,26.89 321.08,30.33 321.08,34.58 322.31,35.81 322.31,37.4 323.72,38.81 323.72,42.36 324.52,43.16 324.52,44.36 326.85,46.69 326.85,47.98 330.74,51.86 330.74,53.43 332.79,55.48 332.79,59.93 332.44,60.28 332.44,61.71 333.4,62.67 333.4,84.82 336.09,87.51 v2(336.45,87.51)
  BOTTOM w0.14: JNGFF1.47 342.05,84.77 342.15,84.87 342.15,87.49 341.44,88.2 337.14,88.2 v2(336.45,87.51)
PD_EE_CLK: length 26.3
  IN6 w0.099: v2(20.92,52.14) 20.54,51.76 19.53,51.76 17.59,53.71 17.59,63.01 17.22,63.37 v2(17.22,68.45)
  BOTTOM w0.081: UT4.A3 21.87,55.85 21.49,55.47
  BOTTOM w0.14: v2(20.92,52.14) 21.04,52.14 21.43,52.53 21.43,53.51 21.33,53.61 21.33,55.31 21.49,55.47 ; v2(17.22,68.45) 17.1,68.45 RT210.2 16.74,67.89 UT5.6
PD_EE_CS#: length 34.5
  TOP w0.14: v2(19.95,71.83) 19.95,72.32 v1(19.76,72.51)
  IN2 w0.099: v2(19.95,71.83) 20.52,72.4 23.37,72.4 24.29,71.47 24.92,71.47 v2(25.4,71.95)
  IN6 w0.099: v2(19.95,71.83) 19.95,71.31 18.94,70.3 18.94,66.38 19.95,65.37 19.95,64.38 19.03,63.45 19.03,58.81 19.02,58.81 19.02,57.06 19.24,56.84 20.29,56.84 21.76,55.38 v2(21.76,54.94)
  BOTTOM w0.081: 22.05,55.47 22.05,55.89 22.12,55.97 22.12,56.65 UT4.B3
  BOTTOM w0.14: 22.05,55.47 22.05,55.45 21.76,55.16 v2(21.76,54.94) 21.76,54.75 21.88,54.62 RT168.2 ; UT5.1 26.34,70.43 26.48,70.57 26.48,71.24 26.34,71.38 25.97,71.38 v2(25.4,71.95) 25.55,72.11 RT213.2
PD_EE_DI: length 17
  TOP w0.14: v2(21.06,68.26) v1(21.06,67.45) ; v2(21.85,57.48) 21.85,57.6 21.5,57.95 RT211.2
  IN5 w0.099: v2(21.06,68.26) 21.5,67.82 21.5,57.83 v2(21.85,57.48)
  BOTTOM w0.081: v2(21.85,57.48) 21.85,57.41 UT4.B4
  BOTTOM w0.14: UT5.5 19.07,66.62 20.7,68.26 v2(21.06,68.26)
PD_EE_DO: length 32.5
  TOP w0.14: v2(20.54,71.83) 21.27,71.83 v1(21.3,71.85)
  IN2 w0.099: v2(20.54,71.83) 23.43,71.83 24.11,71.15 v2(25.4,71.15)
  IN6 w0.099: v2(22.4,55.75) 21.67,55.75 20.34,57.08 20.13,57.08 19.91,57.3 19.91,59.38 19.85,59.44 19.85,59.78 19.88,59.8 19.88,60.45 19.91,60.49 19.91,61.82 19.88,61.86 19.88,63.95 20.15,64.23 20.15,65.46 19.14,66.46 19.14,69.6 19.4,69.86 19.75,69.86 20.24,70.35 20.24,71.53 v2(20.54,71.83)
  BOTTOM w0.14: UT4.A4 22.37,55.78 v2(22.4,55.75) 22.39,55.74 22.39,54.75 22.52,54.62 RT169.2 ; RT212.2 26.58,69.06 26.48,69.16 UT5.2 24.51,69.16 24.26,69.41 24.26,70.81 24.6,71.15 v2(25.4,71.15)
PD_EE_WP#: length 5.5
  BOTTOM w0.14: v1(26.93,68.16) 26.66,67.89 UT5.3 24.52,67.89 23.72,67.09 RT170.2
PD_HOLD#: length 3
  TOP w0.14: v2(16.93,69.16) 16.99,69.22 RT171.2 17.62,68.73 v1(18.04,68.31)
  BOTTOM w0.14: UT5.7 v2(16.93,69.16)
PD_I2C_ALERT#: length 352.9
  TOP w0.14: UE3.A42 v2(298.27,21.55) ; v2(298.68,24.85) 299.09,25.26 RE99.1
  IN2 w0.099: v2(34.02,34.85) 34.48,35.31 38.61,35.31 39.91,34.01 44.74,34.01 47.82,30.94 49.94,30.94 50.7,31.7 52.76,31.7 53.78,30.68 70.09,30.68 71.04,29.72 73.61,29.72 74.32,30.44 77.29,30.44 78.24,31.39 84.6,31.39 88.26,35.05 96.77,35.05 99.95,38.23 111.21,38.23 116.26,33.18 140.43,33.18 144.48,29.14 152.23,29.14 152.85,28.52 152.85,27.38 153.16,27.06 153.99,27.06 155.79,25.26 157.15,25.26 157.68,24.72 157.68,19.88 158.91,18.65 173.02,18.65 173.22,18.45 175.57,18.45 176.05,17.97 254.29,17.97 254.95,18.63 257.46,18.63 258.11,19.28 262.47,19.28 263.12,19.93 264,19.93 v2(264.17,19.76) 264.44,19.49 267.28,19.49 268.36,20.57 274.86,20.57 275.21,20.22 278.14,20.22 278.96,21.04 279.67,21.04 280.63,22 289.99,22 290.67,22.68 290.67,22.86 293.42,25.61 293.94,25.61 295.64,27.32 296.88,27.32 297.62,28.06 299.66,28.06 299.9,27.82 v2(299.9,27.39)
  IN3 w0.091: v2(23,57.41) 21.85,56.26 21.85,55.57 22.8,54.62 22.8,52.27 21.43,50.9 21.43,48.34 20.31,47.22 20.31,46.92 17.82,44.43 17.82,40.25 19.31,38.77 19.31,35.65 18.75,35.1 18.75,33.42 19.34,32.83 19.34,32.39 20.57,31.16 20.57,30.05 21.67,28.95 24.95,28.95 26.03,27.87 26.03,26.36 26.24,26.15 27.42,26.15 28,26.73 28,27.81 28.79,28.6 v2(31.08,28.6)
  IN4 w0.091: v2(298.27,21.55) 298.68,21.95 v2(298.68,24.85) 298.89,25.06 298.89,26.31 299.46,26.87 299.46,27.25 299.59,27.39 v2(299.9,27.39)
  IN5 w0.099: v2(34.02,34.85) 34.02,31.54 v2(31.08,28.6)
  BOTTOM w0.081: UT4.B6 23.37,57.05 v2(23,57.41)
PEG_GTX_C_HRX_N0: length 20.1
  TOP w0.152: v2(186.63,63.01) 186.74,63.13 187.11,63.13 187.37,62.87 189.19,62.87 190.26,63.95 190.26,64.66 190.41,64.81 CV819.2
  IN1 w0.089: v2(175.81,65.24) 175.77,65.2 175.77,65.07 175.84,65 177.35,65 177.82,64.53 179.95,64.53
  IN1 w0.107: v2(186.63,63.01) 186.68,63.06 187.2,63.06 187.53,63.39 187.53,63.81 186.81,64.54 180,64.54 179.99,64.53 179.95,64.53
  BOTTOM w0.076: v2(175.81,65.24) 175.48,65.56 UH1.E10
PEG_GTX_C_HRX_N1: length 19.4
  TOP w0.152: CV821.2 192.36,65.96 190.43,65.96 190.2,65.72 189.95,65.72 189.47,65.25 189.47,64.57 189.13,64.22 188.85,64.22 v2(188.71,64.08)
  IN1 w0.089: v2(175.81,66.02) 175.96,65.87 175.96,65.62 176.16,65.42 177.57,65.42 178,64.99 179.93,64.99 179.94,64.98 179.95,64.98
  IN1 w0.107: v2(188.71,64.08) 188.59,64.21 187.77,64.21 187,64.98 179.95,64.98
  BOTTOM w0.076: v2(175.81,66.02) 175.48,66.35 UH1.E11
PEG_GTX_C_HRX_N2: length 17.8
  TOP w0.152: CV823.2 190.69,67.33 189.97,67.33 189.01,66.37 188.86,66.37 v2(188.74,66.49)
  IN1 w0.089: v2(175.16,67.6) 175.51,67.25 175.65,67.25 176.33,66.57 177.33,66.57 177.76,66.14 179.13,66.14 179.14,66.15 179.2,66.15 179.21,66.16 179.22,66.16
  IN1 w0.107: v2(188.74,66.49) 188.61,66.37 188.6,66.37 188.58,66.34 187.59,66.34 187.04,65.8 179.75,65.8 179.39,66.16 179.22,66.16
  BOTTOM w0.076: UH1.E12 175.16,67.53 v2(175.16,67.6)
PEG_GTX_C_HRX_N3: length 19
  TOP w0.152: v2(184.91,66.3) 185.14,66.3 185.6,65.85 187.44,65.85 189.46,67.86 CV825.2
  IN1 w0.089: 179.84,66.53 179.74,66.53 179.73,66.54 179.67,66.54 179.66,66.55 178,66.55 177.57,66.98 176.26,66.98 175.97,67.26 175.97,67.43 v2(175.81,67.6)
  IN1 w0.107: 179.84,66.53 183.4,66.53 183.49,66.62 184.68,66.62 184.91,66.39 v2(184.91,66.3)
  BOTTOM w0.076: v2(175.81,67.6) 175.48,67.92 UH1.E13
PEG_GTX_C_HRX_N4: length 19.1
  TOP w0.152: v2(186.66,67.66) 186.66,67.25 186.76,67.15 187.17,67.15 189.22,69.21 190.51,69.21 190.82,69.51 CV827.2
  IN1 w0.089: v2(175.16,68.39) 175.16,68.66 175.24,68.75 175.42,68.75 175.58,68.59 175.58,68.33 175.71,68.2 177.28,68.2 177.73,67.75 179.36,67.75 179.5,67.61 179.57,67.61
  IN1 w0.107: v2(186.66,67.66) 186.41,67.66 185.92,68.16 182.34,68.16 181.8,67.61 179.57,67.61
  BOTTOM w0.076: UH1.E14 175.38,68.78 175.16,68.55 v2(175.16,68.39)
PEG_GTX_C_HRX_N5: length 19.3
  TOP w0.152: CV829.2 192.41,69.97 189.17,69.97 188.16,68.96 187.73,68.96 187.48,69.21 v2(187.33,69.21)
  IN1 w0.089: v2(175.81,69.17) 175.96,69.01 175.96,68.84 176.19,68.61 177.46,68.61 177.84,68.23 179.87,68.23 179.88,68.22 179.9,68.22
  IN1 w0.107: 179.9,68.22 181.82,68.22 183.28,69.68 187.22,69.68 187.33,69.57 v2(187.33,69.21)
  BOTTOM w0.076: v2(175.81,69.17) 175.48,69.5 UH1.E15
PEG_GTX_C_HRX_N6: length 20
  TOP w0.152: v2(187.67,73.29) 187.67,72.84 189.27,71.24 190.51,71.24 190.82,71.54 CV831.2
  IN1 w0.089: 179.9,69.35 179.88,69.35 179.87,69.34 177.96,69.34 177.58,69.72 176.23,69.72 175.46,70.49 175.33,70.49 175.16,70.66 v2(175.16,70.75)
  IN1 w0.107: 179.9,69.35 181.77,69.35 186.02,73.61 187.11,73.61 187.42,73.29 v2(187.67,73.29)
  BOTTOM w0.076: UH1.E16 175.16,70.68 v2(175.16,70.75)
PEG_GTX_C_HRX_N7: length 21.1
  TOP w0.152: CV833.2 192.41,72 189.6,72 187.88,73.72 186.76,73.72 185.75,72.7 184.99,72.7 184.6,73.1 v2(184.53,73.1)
  IN1 w0.089: v2(175.81,70.75) 175.94,70.61 175.94,70.36 176.21,70.09 178.18,70.09 178.47,69.81 179.9,69.81
  IN1 w0.107: 179.9,69.81 180.61,69.81 184.34,73.54 184.49,73.54 184.6,73.43 184.6,73.16 v2(184.53,73.1)
  BOTTOM w0.076: UH1.E17 175.81,70.82 v2(175.81,70.75)
PEG_GTX_C_HRX_N8: length 20.2
  TOP w0.152: CV835.2 190.8,72.98 189.74,72.98 188.11,74.61 186.26,74.61 v2(185.61,75.26)
  IN1 w0.089: v2(174.51,71.54) 174.91,71.13 177.24,71.13 177.63,70.74 179.86,70.74 179.87,70.73 179.9,70.73
  IN1 w0.107: v2(185.61,75.26) 185.42,75.45 185.14,75.45 180.43,70.73 179.9,70.73
  BOTTOM w0.076: UH1.F18 174.83,71.86 v2(174.51,71.54)
PEG_GTX_C_HRX_N9: length 22.4
  TOP w0.152: CV837.2 192.23,74.34 192.21,74.34 192.16,74.29 191.94,74.29 191.9,74.32 189.98,74.32 188.33,75.97 187.49,75.97 186.79,76.66 186.79,76.75 186.8,76.75 186.8,77.06 186.92,77.19 v2(187.06,77.19)
  IN1 w0.089: v2(175.81,72.32) 175.81,72.04 176.01,71.84 177.81,71.84 178.08,71.57 178.98,71.57 179.12,71.71 179.91,71.71 179.92,71.72 179.94,71.72
  IN1 w0.107: 179.94,71.72 180.26,71.72 186.02,77.49 186.38,77.49 186.59,77.28 186.6,77.28 186.69,77.19 v2(187.06,77.19)
  BOTTOM w0.076: v2(175.81,72.32) 175.81,72.39 UH1.D19
PEG_GTX_C_HRX_N10: length 22.3
  TOP w0.152: v2(186.09,78.15) 186.58,77.66 188.21,77.66 188.34,77.53 188.34,76.6 189.97,74.97 CV839.2
  IN1 w0.089: 179.9,72.37 179.88,72.37 179.87,72.38 177.7,72.38 177.39,72.69 176.24,72.69 175.41,73.51 175.24,73.51 175.16,73.43 v2(175.16,73.11)
  IN1 w0.107: 179.9,72.37 180.33,72.37 185.24,77.29 185.24,78 185.84,78.59 185.99,78.59 186.09,78.49 v2(186.09,78.15)
  BOTTOM w0.076: UH1.F20 175.16,73.18 v2(175.16,73.11)
PEG_GTX_C_HRX_N11: length 24.8
  TOP w0.152: v2(187.33,79.89) 187.1,79.89 186.95,79.74 186.95,79.52 187.15,79.32 188.58,79.32 191.42,76.48 192.28,76.48 192.46,76.3 193.18,76.3 CV841.2
  IN1 w0.089: v2(176.46,73.9) 176.39,73.96 176.25,73.96 176.17,73.88 176.17,73.62 176.33,73.47 178.35,73.47 178.63,73.19 179.77,73.19 179.82,73.24 179.9,73.24
  IN1 w0.107: 179.9,73.24 180.04,73.24 184.39,77.59 184.39,78.54 186.26,80.41 186.73,80.41 187.25,79.89 v2(187.33,79.89)
  BOTTOM w0.076: UH1.D21 176.13,74.22 v2(176.46,73.9)
PEG_GTX_C_HRX_N12: length 27.1
  TOP w0.152: v2(186.92,82.82) 187.35,82.82 187.5,82.67 187.5,81.04 191.39,77.16 191.76,77.16 CV843.2
  IN1 w0.089: v2(175.16,74.69) 175.16,74.84 175.32,75 175.45,75 176.19,74.26 177.26,74.26 177.55,73.97 179.9,73.97
  IN1 w0.107: v2(186.92,82.82) 186.72,83.01 186.55,83.01 186.41,83.16 186.07,83.16 185.41,82.5 185.41,80.2 183.98,78.76 183.98,77.81 180.14,73.97 179.9,73.97
  BOTTOM w0.076: UH1.F22 175.16,74.75 v2(175.16,74.69)
PEG_GTX_C_HRX_N13: length 27.9
  TOP w0.152: CV845.2 193.23,78.44 191.68,78.44 188.85,81.28 188.85,83.07 188.53,83.38 v2(188.53,83.64)
  IN1 w0.089: v2(176.46,75.47) 176.33,75.47 176.19,75.33 176.19,75.17 176.32,75.04 178.08,75.04 178.43,74.69 178.89,74.69 178.89,74.69 178.92,74.69
  IN1 w0.107: 178.92,74.69 179.71,74.69 183.16,78.15 183.16,79.12 184.57,80.54 184.57,82.81 185.78,84.02 187.57,84.02 188.02,83.57 188.46,83.57 v2(188.53,83.64)
  BOTTOM w0.076: UH1.D23 176.13,75.8 v2(176.46,75.47)
PEG_GTX_C_HRX_N14: length 27
  TOP w0.152: v2(188.36,84.91) 188.36,84.76 188.52,84.6 189.08,84.6 190.14,83.54 190.14,81.1 v5(190.86,80.38) 191.67,79.57 191.88,79.57 CV847.2
  IN1 w0.089: 177.74,76.21 177.14,76.21 176.92,76.43 176.31,76.43 176.09,76.65 175.69,76.65 175.29,76.26 v2(175.16,76.26)
  IN1 w0.107: v2(188.36,84.91) 187.96,84.91 187.79,85.08 185.97,85.08 183.96,83.07 183.96,80.9 182.54,79.49 182.54,78.4 180.35,76.21 177.74,76.21
  BOTTOM w0.076: v2(175.16,76.26) 175.16,76.33 UH1.F24
PEG_GTX_C_HRX_N15: length 27.3
  TOP w0.152: v2(188.96,85.78) 189.24,85.49 189.3,85.49 190.93,83.87 190.93,81.74 192.19,80.48 193.29,80.48 CV849.2
  IN1 w0.107: v2(175.8,77.85) 176.03,77.62 177.53,77.62 177.69,77.47 180.74,77.47 181.93,78.66 181.93,79.76 183.34,81.18 183.34,83.32 185.71,85.69 188.42,85.69 188.52,85.59 188.77,85.59 v2(188.96,85.78)
  BOTTOM w0.076: v2(175.8,77.85) 175.8,77.77 UH1.D25
PEG_GTX_C_HRX_P0: length 20
  TOP w0.152: v2(186.75,63.59) 186.88,63.46 187.25,63.46 187.5,63.2 189.05,63.2 189.93,64.08 189.93,64.8 190.28,65.14 190.48,65.14 190.69,65.35 190.74,65.35 CV818.2
  IN1 w0.089: 179.95,64.33 179.87,64.33 179.86,64.33 179.78,64.33 179.77,64.34 177.74,64.34 177.27,64.81 175.72,64.81 175.29,65.24 v2(175.16,65.24)
  IN1 w0.107: 179.95,64.33 180.07,64.33 180.08,64.33 186.72,64.33 187.33,63.73 187.33,63.48 187.11,63.27 186.95,63.27 186.75,63.47 v2(186.75,63.59)
  BOTTOM w0.076: v2(175.16,65.24) 174.83,65.56 UH1.F10
PEG_GTX_C_HRX_P1: length 19.3
  TOP w0.152: CV820.2 192.31,66.29 190.3,66.29 190.06,66.05 189.81,66.05 189.14,65.39 189.14,64.7 188.99,64.55 188.83,64.55 v2(188.71,64.66)
  IN1 w0.089: v2(176.46,66.02) 176.27,66.02 176.15,65.9 176.15,65.69 176.24,65.6 177.64,65.6 178.07,65.18 179.91,65.18 179.92,65.19 179.95,65.19 179.95,65.18
  IN1 w0.107: v2(188.71,64.66) 188.71,64.65 188.47,64.41 187.86,64.41 187.08,65.19 179.96,65.19 179.95,65.18
  BOTTOM w0.076: v2(176.46,66.02) 176.13,66.35 UH1.D11
