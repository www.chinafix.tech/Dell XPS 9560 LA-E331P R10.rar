# Allegro board Dell XPS 9560 LA-E331P R10.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SLEEVE: length 16.4
  IN2 w1.016: 14.47,55.61 14.47,54.89 14.03,54.45 14.03,53.22 14.9,52.36 14.9,46.34 13.27,44.71 11.5,44.71 11.11,45.09 9.75,45.09
  BOTTOM w0.102: v2(14.85,56.3) 14.85,55.67 v1(14.86,55.66)
  vias: v2(9.27,44.24) v2(9.27,43.66) v2(14.85,56.93)
SLEEVE_L: length 4.5
  TOP w0.127: v3(5.46,42.93) 5.46,43.24 6.14,43.92 LA8.2
  TOP w1.016: JHP1.4 3.19,47.36 3.19,45.37 3.32,45.25
SM_PG_CTRL: length 203.9
  TOP w0.14: 121.98,54.5 121.75,54.74 120.95,54.74 RH525.2 ; 121.98,54.5 123.06,54.5 UC1.4 ; 121.98,54.5 v2(122.01,54.48)
  IN3 w0.091: v2(293.5,29.6) 292.59,28.69 292.59,27.52 290.85,25.78 289.1,25.78 288.32,25.01 281.56,25.01 279.55,23 277.25,23 276.74,22.48 267.79,22.48 266.15,20.84 260.96,20.84 260.69,21.11 260.69,21.11 260.64,21.16 259.05,22.75 258.72,22.75 257.84,21.88 254.87,21.88 253.16,20.16 252.55,20.16 251.05,18.66 231.57,18.66 231.02,18.11 229.87,18.11 229.11,17.35 177.29,17.35 176.25,18.38 174.6,18.38 173.53,19.46 173.53,22.47 174.12,23.06 174.12,28.14 173.33,28.93 162.81,28.93 143.81,47.93 v2(130.72,47.93)
  BOTTOM w0.127: v2(122.01,54.48) 128.56,47.93 v2(130.72,47.93)
  BOTTOM w0.254: v2(293.5,29.6) 293.24,29.35 PR608.1
SMBALERT#: length 3.2
  TOP w0.089: RH505.2 81.45,5.81 80.51,5.81 80.32,5.62 v2(79.78,5.62) 79.39,5.62 v1(79.26,5.5)
  BOTTOM w0.089: v2(79.78,5.62) UH2.BB41
SMBCLK: length 4.9
  TOP w0.14: v2(76.04,7.37) RH458.2 74.88,6.77 74.49,6.37 QH4.6
  BOTTOM w0.089: UH2.AW44 77.93,7.27 77.43,7.27 77.05,7.65 76.32,7.65 v2(76.04,7.37)
SMBDATA: length 9.9
  TOP w0.14: QH4.3 71.39,5.07 RH459.2 70.92,5.78 v2(71.38,6.24)
  IN5 w0.089: 75.06,6.17 75.4,6.17 75.42,6.19 77.81,6.19 v2(78.21,5.79)
  IN5 w0.099: v2(71.38,6.24) 71.46,6.17 75.06,6.17
  BOTTOM w0.089: UH2.BB43 78.38,5.64 78.23,5.79 v2(78.21,5.79)
SML0_SMBCLK: length 8
  BOTTOM w0.089: UH2.AY44 78.17,6.41 77.84,6.74 75.9,6.74
  BOTTOM w0.127: RH501.2 71.69,8.01 72.52,8.01 72.78,7.74 v1(72.9,7.74) 75.45,7.74 75.64,7.55 75.64,6.99 75.9,6.74
SML0_SMBDATA: length 11.3
  IN5 w0.089: v2(80.75,5.34) 80.67,5.26 79.25,5.26 78.14,6.37 75.06,6.37
  IN5 w0.099: v2(72.29,7.58) 72.29,7.16 73.08,6.37 75.06,6.37
  BOTTOM w0.089: v2(80.75,5.34) 80.59,5.5 UH2.BB39
  BOTTOM w0.14: v2(72.29,7.58) 71.59,6.88 RH502.2
SML0ALERT#: length 4.7
  TOP w0.089: v1(83.41,7.59) 83.27,7.73 RH503.2 82.51,7.67 v2(82.04,7.19)
  BOTTOM w0.089: v2(82.04,7.19) 82.04,7.18 82.04,6.42 81.79,6.17 UH2.BA40
SML1_SMBCLK: length 237.1
  TOP w0.089: RH460.2 78.32,7.22 78.5,7.05 v2(78.76,7.05)
  TOP w0.14: UE3.B6 v2(297.52,11.51)
  IN1 w0.076: 101.98,11.5 101.77,11.5 101.75,11.47 101.26,10.99 100.21,10.99 99.58,10.36 97.89,10.36 97.34,10.92 94.94,10.92 94.83,10.8 92.71,10.8 91.21,9.3 89.03,9.3 88.7,8.97 87.81,8.97 87.33,9.45 86.17,9.45 85.82,9.1 84.55,9.1 84.27,8.82 79.28,8.82 78.76,8.31 v2(78.76,7.05)
  IN1 w0.099: 101.98,11.5 103.92,11.5 104.23,11.82 114.79,11.82 115.81,10.79 146.07,10.79 147.99,8.87 151.09,8.87 151.23,8.73 155.68,8.73 156.11,8.3 161.2,8.3 161.66,7.84 172.44,7.84 172.76,7.53 204.61,7.53 206.01,8.93 211.03,8.93 213.11,6.85 227.03,6.85 227.65,6.23 238.35,6.23 239.55,7.43 251.96,7.43 253.15,6.24 257.69,6.24 258,6.55 258.01,6.55 258.88,7.42 266.86,7.42 267.27,7.82 272.13,7.82 276.47,12.15 282.25,12.15 282.64,12.55 282.64,12.98 283.55,13.89 285.28,13.89 286.72,15.33 286.72,16.06 287.37,16.71 290.53,16.71 290.82,16.42 290.82,15.44 291.66,14.6 293.61,14.6 295.05,13.17 296.44,13.17 297.1,12.51 297.1,11.93 v2(297.52,11.51)
  BOTTOM w0.089: UH2.AW42 78.83,7.12 v2(78.76,7.05)
SML1_SMBDAT: length 240.2
  TOP w0.089: RH461.2 77.09,7.07 v2(76.87,7.28)
  TOP w0.14: UE3.A5 297.27,9.27 v2(297.33,9.21) ; v2(282.12,12.84) v1(282.49,12.47)
  IN1 w0.076: v2(76.87,7.28) 77.81,7.28 78.42,7.9 78.42,8.2 79.21,8.99 84.2,8.99 84.41,9.19 84.41,9.58 84.76,9.94 85.74,9.94 86.07,9.62 87.4,9.62 87.87,9.14 88.63,9.14 88.96,9.47 91.03,9.47 91.6,10.04 91.6,10.99 92.16,11.54 94.84,11.54 95.19,11.2 97.32,11.2 97.99,10.53 99.42,10.53 100.05,11.15 101.19,11.15 101.74,11.7 101.98,11.7
  IN1 w0.099: 101.98,11.7 103.83,11.7 104.15,12.02 114.87,12.02 115.84,11.05 146.1,11.05 146.81,10.34 149.91,10.34 151.31,8.93 155.76,8.93 156.19,8.51 172.06,8.51 172.84,7.73 204.53,7.73 205.93,9.13 211.11,9.13 213.18,7.06 227.13,7.06 227.75,6.43 236.59,6.43 237.79,7.63 252.05,7.63 253.24,6.44 257.61,6.44 258.04,6.87 258.04,6.87 258.79,7.62 266.78,7.62 267.18,8.02 272.04,8.02 276.86,12.84 v2(282.12,12.84)
  BOTTOM w0.089: v2(76.87,7.28) 77.12,7.04 UH2.AW45
  BOTTOM w0.14: v2(282.12,12.84) 282.05,12.77 282.05,10.03 284.68,7.4 289.39,7.4 289.5,7.29 295.34,7.29 295.81,7.76 296.67,7.76 296.95,8.04 296.95,8.81 297.33,9.19 v2(297.33,9.21)
SML1ALERT#: length 2.5
  TOP w0.089: v2(86.23,8.52) 86.03,8.72 v1(86.03,9.23) 86.03,9.74 RH504.2
  BOTTOM w0.089: UH2.AT27 86.47,8.28 v2(86.23,8.52)
SNB_0.95V: length 2.3
  BOTTOM w0.14: PR802.2 111.51,58.8 111,59.31 v1(111,59.74)
SNB_1V: length 3.1
  BOTTOM w0.14: v3(127.42,10.59) 128.14,9.86 128.14,9.53 PR502.2
SNB_1VSP: length 1.4
  TOP w0.14: PC901.1 236.92,113.5 v1(236.75,113.33)
SNUB_1.2V: length 2.4
  BOTTOM w0.14: v1(263.3,26.73) 263.91,26.73 264.62,27.44 PC611.1
SNUB_3V: length 1.5
  TOP w0.14: PC414.1 v1(331.74,30.11)
SNUB_5V: length 2.7
  TOP w0.14: PR414.2 339.28,13.18 v3(341.05,11.41)
SP7_SDWP: length 19.4
  IN6 w0.099: v2(343.72,35.95) 343.72,38.59 338.4,43.91 v2(334.18,43.91)
  BOTTOM w0.14: UR1.29 342.59,36.89 342.67,36.81 343.47,36.81 343.72,36.57 v2(343.72,35.95) ; v3(334.71,44.44) v2(334.18,43.91) 333.59,43.32 QR1.1
SP7_SDWP_C: length 7.6
  TOP w0.14: JCR.11 331.46,39.3 332.58,40.43 332.58,41.32 v2(332.59,41.33)
  BOTTOM w0.14: v2(332.59,41.33) 332.59,41.75 331.85,42.49 331.85,43.63 331.52,43.97 QR1.3
SPK_DET#: length 348
  TOP w0.14: v2(302.54,4.55) 302.06,5.03 301.75,5.03 301.49,4.76 RE139.1 ; v2(59.61,2.7) 60.48,2.7 RH572.1 ; v2(5.78,12.77) 5.78,13.35 5.6,13.53 JAUDIO.6
  IN2 w0.089: 101.98,6.38 100.09,6.38 100.07,6.36 100.03,6.36 99.21,5.55 99.21,5.31 98.11,4.21 97.62,4.21 97.4,4.42 92.8,4.42 92.41,4.02 90.19,4.02 89.73,3.56 89.73,3.31 v2(89.37,2.95) 89.3,2.89 88.08,2.89 87.27,3.69 86.81,3.69 86.62,3.88 86.03,3.88 85.57,3.43 84.49,3.43 82.73,1.67 75.06,1.67
  IN2 w0.099: 101.98,6.38 104.89,6.38 105.09,6.18 113.33,6.18 114.11,6.97 116.02,6.97 117.82,8.77 135.69,8.77 135.91,8.99 145.25,8.99 147.58,6.66 150.82,6.66 152.34,5.14 155.91,5.14 156.41,5.64 159.41,5.64 159.61,5.43 162.98,5.43 163.45,4.96 171.37,4.96 171.52,4.81 175.15,4.81 175.99,5.66 177.04,5.66 178.11,4.59 182.07,4.59 182.81,5.33 186.76,5.33 189.24,2.85 202.22,2.85 206.75,7.37 209.9,7.37 213.16,4.12 225.88,4.12 226.55,3.44 239.42,3.44 239.51,3.35 245.74,3.35 247.11,4.73 250.86,4.73 251.83,3.76 261.8,3.76 262.91,4.86 267.62,4.86 269.46,3.03 269.48,3.02 269.81,3.02 269.81,3.03 296.21,3.03 297.01,3.83 302.21,3.83 302.54,4.16 v2(302.54,4.55) ; v2(59.61,2.7) 59.64,2.7 59.67,2.67 65.24,2.67 66.36,1.54 69.47,1.54 70.11,2.18 71.9,2.18 71.91,2.18 72.24,2.18 72.24,2.18 73.98,2.18 74.49,1.67 75.06,1.67
  IN6 w0.099: v2(59.61,2.7) 58.68,2.7 55.83,5.55 55.83,8.37 54.47,9.72 54.47,12.53 54.04,12.96 54.04,14.26 53.1,15.21 53.1,16.73 50.99,18.83 50.99,19.82 50.35,20.46 42.04,20.46 41.72,20.77 33.06,20.77 31.31,19.02 28.71,19.02 25.24,15.56 22.92,15.56 22.47,15.1 22.47,7.24 20.19,4.96 13.84,4.96 12.45,6.36 10.7,6.36 5.78,11.28 v2(5.78,12.77)
  BOTTOM w0.089: v2(89.37,2.95) 89.68,3.26 89.68,3.81 89.47,4.01 89.47,4.2 89.75,4.48 UH2.BD21
SPK_DET#_EC: length 24.2
  TOP w0.14: UE3.B42 299.52,19.23 v2(299.5,19.2) ; v2(300.23,6.6) 300.86,5.97 RE139.2 301.56,5.67 301.85,5.38 302.58,5.38 303.61,4.35 v3(305.2,4.35)
  BOTTOM w0.14: v2(299.5,19.2) 299.07,18.77 299.07,17.92 298.07,16.93 298.07,10.47 298.9,9.65 298.9,7.39 298.59,7.08 298.59,5.46 298.79,5.25 299.29,5.25 299.64,5.61 299.64,6.01 v2(300.23,6.6)
SPKR: length 145.9
  TOP w0.14: RH82.2 74.49,3.12 74.73,3.36 v2(74.73,3.95) ; v2(3.65,27.94) 3.35,27.94 2.88,27.48 RA7.1
  IN2 w0.099: v2(3.65,27.94) 3.81,28.1 4.75,28.1 7.89,24.96 7.89,22.8 7.28,21.33 5.98,20.03 5.98,18.22 3.81,16.06 3.81,13.1 3.81,13.1 3.81,12.93 3.81,12.9 4.58,12.13 6.54,12.13 9.58,15.16 11.34,15.16 13.02,16.84 13.02,18.12 15.25,20.35 17.41,20.35 19.39,22.34 22.44,22.34 23,22.89 24.89,22.89 26.09,24.09 26.88,24.09 27.69,24.9 30.42,24.9 31.5,25.98 31.93,25.98 32.74,26.79 32.74,28.21 33.88,29.35 35.95,29.35 36.41,28.89 36.41,28.39 37.14,27.66 38.99,27.66 40.12,26.52 43.49,26.52 45,25.01 47.09,25.01 47.73,24.38 50.13,24.38 50.91,23.59 53.89,23.59 56.24,21.24 56.76,21.24 58.68,19.33 58.68,17.07 58.1,16.5 58.1,15.17 57.84,14.9 57.84,12.73 57.14,12.03 57.14,6.56 56.83,6.26 56.83,4.83 57.03,4.64 57.03,3.83 58.2,2.66 59,2.66 59.5,3.16 61.6,3.16 61.75,3.01 62.43,3.01 62.66,3.23 62.66,4.19 v2(62.87,4.39)
  IN5 w0.089: v2(87.05,2.29) 86.92,2.29 86.51,2.7 86.19,2.7 85.36,3.53 82.79,3.53 81.63,2.38 76.05,2.38 75.06,3.37
  IN5 w0.099: v2(62.87,4.39) 63.63,5.15 65.53,5.15 65.76,4.92 65.76,3.65 66.21,3.2 67.65,3.2 68.1,3.66 68.1,4.48 68.49,4.87 69.22,4.87 69.46,4.63 71.74,4.63 72.41,3.95 v2(74.73,3.95) 74.89,3.78 74.89,3.54 75.06,3.37
  BOTTOM w0.089: v2(87.05,2.29) 87.26,2.51 87.26,2.89 87.33,2.96 87.33,3.31 87.01,3.63 87.01,3.95 86.86,4.1 UH2.BD26
SRCCLKREQ1#: length 21.2
  IN3 w0.089: v2(87.25,7.42) 86.53,8.14 85.65,8.14 85.1,7.59 83.72,7.59 83.52,7.79 83.52,8.3 83,8.82 75.35,8.82 75.11,8.58 75.06,8.58
  IN3 w0.091: v2(70.74,6.24) 71.23,6.72 73.69,6.72 73.81,6.85 73.81,7.88 74.51,8.58 75.06,8.58
  BOTTOM w0.089: UH2.AW24 87.59,7.02 87.59,7.08 v2(87.25,7.42)
  BOTTOM w0.14: RH549.2 70.54,6.04 70.74,6.24 70.74,6.24 v2(70.74,6.24)
SRCCLKREQ2#: length 19.9
  TOP w0.14: RH550.2 70.03,10.18 v2(70.23,9.98) v1(69.81,9.56)
  IN3 w0.089: v2(87.29,8.72) 86.91,9.1 84.64,9.1 84.54,9 79.59,9 78.88,9.71 75.06,9.71
  IN3 w0.091: v2(70.23,9.98) 70.47,10.21 71.68,10.21 72.18,9.71 75.06,9.71
  BOTTOM w0.089: v2(87.29,8.72) 87.32,8.72 87.76,8.28 UH2.AT24
SRCCLKREQ8#: length 12.9
  BOTTOM w0.089: UH2.BD32 84.17,4.6 84.17,4.34 84.2,4.31 84.2,3.39 83.24,2.43 83.24,2.02 82.7,1.48 75.73,1.48 75.06,2.15
  BOTTOM w0.14: RP22.7 74.68,2.53 75.06,2.15
SRCCLKREQ9#: length 13
  BOTTOM w0.089: 75.06,2.73 76.01,1.77 82.14,1.77 v1(82.73,2.36) 82.73,2.94 82.99,3.2 83.41,3.2 83.73,3.51 83.73,3.99 83.73,4.24 83.83,4.34 83.83,4.82 84.07,5.05 UH2.BC32
  BOTTOM w0.14: RP22.6 74.76,3.03 75.06,2.73
SRCCLKREQ10#: length 14.3
  BOTTOM w0.089: UH2.BB31 84.46,5.3 84.35,5.19 84.35,4.41 84.38,4.38 84.38,3.31 83.59,2.52 83.59,1.61 83.38,1.41
  BOTTOM w0.14: 83.38,1.41 83.13,1.15 v1(77.19,1.15) 75.49,1.15 74.61,2.03 RP22.8
SRCCLKREQ11#: length 12.6
  BOTTOM w0.089: 75.06,4.48 75.84,3.69 76.5,3.69 77.22,2.98 77.22,2.47 77.52,2.17 80.97,2.17 81.73,2.93 81.95,2.93 82.67,3.64 83.15,3.64 83.35,3.84 83.35,4.38 83.35,4.38 83.35,4.63 83.35,4.63 83.35,4.69 83.49,4.82 UH2.BC33
  BOTTOM w0.14: RP23.8 74.56,4.97 75.06,4.48
SRCCLKREQ12#: length 14.4
  TOP w0.14: v2(74.3,7.3) 74.3,7.32 v3(73.76,7.86)
  IN3 w0.089: v2(82.89,6.57) 83.3,6.57 83.45,6.73 83.45,7.3 82.91,7.84 78.75,7.84 77.95,8.64 75.76,8.64 75.22,8.11 75.06,8.11
  IN3 w0.091: v2(74.3,7.3) 74.45,7.45 74.45,7.85 74.71,8.11 75.06,8.11
  BOTTOM w0.089: UH2.BA33 83.32,6.15 v2(82.89,6.57)
  BOTTOM w0.14: v2(74.3,7.3) 73.8,6.8 73.8,6.56 73.89,6.47 RP23.5
SRCCLKREQ13#: length 11.6
  IN3 w0.089: v2(82.92,7.13) 82.4,7.65 78.7,7.65 77.89,8.45 75.93,8.45 75.06,7.58
  IN3 w0.091: v2(74.93,7.3) 74.93,7.45 75.06,7.58
  BOTTOM w0.089: UH2.AW33 83.14,6.91 v2(82.92,7.13)
  BOTTOM w0.14: v2(74.93,7.3) 74.93,6.43 74.47,5.97 RP23.6
SRCCLKREQ14#: length 12.9
  BOTTOM w0.089: 75.06,5.19 75.94,4.31 76.25,4.31 77.53,3.03 77.53,2.57 77.76,2.35 79.53,2.35 80.39,3.2 81.82,3.2 82.47,3.86 83.02,3.86 83.16,3.99 83.16,4.75 83.25,4.83 83.25,5.15 83.46,5.37 UH2.BB33
  BOTTOM w0.14: RP23.7 74.78,5.47 75.06,5.19
SRCCLKREQ15#: length 11.6
  BOTTOM w0.089: UH2.BD33 83.59,4.35 83.53,4.3 83.53,3.67 83.27,3.41 82.81,3.41 82.04,2.65 81.84,2.65 81.18,1.99 76.49,1.99 75.06,3.43
  BOTTOM w0.14: 75.06,3.43 74.61,3.43 74.51,3.53 RP22.5
SSD_CLK_REQ#: length 221.2
  TOP w0.14: RP2.8 68.35,6.64 68.45,6.74 68.45,6.97 67.98,7.44 67.4,7.44 66.59,8.25 66.59,9.22 66.57,9.24 66.57,9.72 v2(66.6,9.75)
  IN5 w0.089: v2(82.99,8.32) 82.29,7.63 79.27,7.63 79.13,7.77 78.47,7.77 77.99,7.29 77.43,7.29 77.06,7.65 76.77,7.65 76.01,8.42 75.06,8.42
  IN5 w0.099: 75.06,8.42 73.58,8.42 72.85,9.15 69.06,9.15 68.11,10.11 66.96,10.11 v2(66.6,9.75)
  IN6 w0.089: 101.98,10.36 99.56,10.36 99.33,10.12 97.91,10.12 97.38,10.65 96,10.65 94.31,8.96 92.78,8.96 92.31,9.42 91.76,9.42 91.54,9.2 90.48,9.2 90.29,9.01 89.29,9.01 88.87,8.59 88.11,8.59 87.59,9.11 86.15,9.11 85.37,8.33 84.6,8.33 84.53,8.41 83.07,8.41 v2(82.99,8.32)
  IN6 w0.099: 101.98,10.36 102.16,10.36 102.33,10.19 106.53,10.19 106.64,10.31 107.33,10.31 107.67,9.97 116.99,9.97 117.24,10.23 125.19,10.23 126.07,11.12 128,11.12 128.6,10.52 144.99,10.52 145.47,10.05 146.56,10.05 148.15,8.45 149.67,8.45 149.89,8.67 151.11,8.67 151.38,8.39 151.88,8.39 154.68,8.39 155.37,7.71 158.9,7.71 159.28,8.09 162.36,8.09 162.53,8.26 170.92,8.26 172.63,9.97 176.65,9.97 176.69,10.02 186.69,10.02 187.02,10.35 201.39,10.35 202.59,11.55 214.15,11.55 216.01,9.69 217.4,9.69 218.91,8.18 229.89,8.18 229.99,8.09 253.12,8.09 253.47,7.73 256.06,7.73 256.73,8.4 262.72,8.4 263.07,8.05 268.94,8.05 v2(269.88,8.99)
  BOTTOM w0.089: UH2.AT33 83.12,8.43 82.99,8.3 v2(82.99,8.32)
  BOTTOM w0.14: JNGFF2.52 269.07,9.79 v2(269.88,8.99)
SSD_PCIE_WAKE#: length 3.7
  TOP w0.127: v2(266.81,9.18) 266.91,9.28 RD8.1 RD59.1
  TOP w0.14: v1(266.54,8.56) 266.54,8.9 v2(266.81,9.18)
  BOTTOM w0.127: v2(266.81,9.18) 266.93,9.29 JNGFF2.54
SSD_PWR_EN: length 197.2
  TOP w0.14: RZ75.1 RZ74.1 244.06,2.09 244.06,2.47 243.94,2.59 243.94,3.92 v3(247.02,6.99) 247.78,7.76 v2(247.78,9.36)
  IN2 w0.089: 101.98,13.24 99.62,13.24 98.52,14.35 96.55,14.35 96,14.9 95.32,14.9 91.52,18.7 91.52,20 91.14,20.38 88.22,20.38 86.12,18.28 84.25,18.28 82.61,16.65 78.87,16.65 78.23,17.28 78.23,19.19 77.92,19.5 77.03,19.5 v2(76.71,19.82)
  IN2 w0.099: 101.98,13.24 103.11,13.24 103.92,14.05 105.63,14.05 106.53,14.95 120.06,14.95 120.31,15.2 129.2,15.2 129.46,14.93 148.65,14.93 150.04,13.54 153.8,13.54 155.4,11.95 177.94,11.95 178.84,11.05 183.92,11.05 184.08,10.89 187.96,10.89 188.26,10.59 196.89,10.59 196.94,10.64 199.63,10.64 199.89,10.91 200.85,10.91 201.62,11.68 213.67,11.68 215.8,9.55 226.62,9.55 228.59,7.58 235.97,7.58 235.99,7.57 238.97,7.57 240.34,8.94 247.36,8.94 v2(247.78,9.36)
  BOTTOM w0.089: UH2.M44 78.11,20.63 77.96,20.63 77.83,20.76 77.14,20.76 77.03,20.65 77.03,20.14 v2(76.71,19.82)
STRAP0: length 14.1
  TOP w0.14: v2(215.79,57.67) 215.84,57.72 217.69,57.72 218.76,56.65 219.84,56.65 v1(220.4,56.09) 222.97,53.51 222.97,51.77 RV651.2 223.45,50.87 223.46,50.85 RV645.1
  BOTTOM w0.107: UV18.J2 215.44,58.62 215.59,58.47 215.59,58.47 215.81,58.25 215.81,58.25 215.85,58.21 215.85,57.78 215.79,57.72 v2(215.79,57.67)
STRAP1: length 23
  TOP w0.14: RV646.1 v2(228.23,50.62) RV652.2
  IN6 w0.127: v2(215,62.58) 215.43,62.15 216.08,62.15 216.26,61.97 216.26,59.09 220.85,54.49 226.26,54.49 228.23,52.53 v2(228.23,50.62)
  BOTTOM w0.102: UV18.J7 215.42,63 v2(215,62.58)
STRAP2: length 21.6
  TOP w0.14: RV653.2 v2(227.34,50.62) RV647.1
  IN5 w0.099: v2(215.8,62.58) 216.26,62.12 216.26,58.85 216.79,58.31 216.79,56.23 221.02,52.01 225.96,52.01 v2(227.34,50.62)
  BOTTOM w0.102: UV18.J6 215.8,62.51 v2(215.8,62.58)
STRAP3: length 24.4
  TOP w0.14: RV654.2 v2(229.12,50.62) RV648.1 229.99,49.94 v1(230.14,50.08)
  IN5 w0.099: v2(215.83,61.7) 215.83,61.5 215.43,61.1 215.43,60.71 216.03,60.12 216.03,58.68 216.54,58.17 216.54,56.2 220.94,51.8 225.58,51.8 227.17,50.22 228.71,50.22 v2(229.12,50.62)
  BOTTOM w0.102: UV18.J5 v2(215.83,61.7)
STRAP4: length 15.7
  TOP w0.14: v2(215.02,59.3) 216.03,58.28 217.83,58.28 218.95,57.16 220.41,57.16 v1(221.91,55.66) 223.94,53.63 223.94,51.79 RV655.2 RV649.1
  BOTTOM w0.102: v2(215.02,59.3) 215.42,59.7 UV18.J3
STRAP5: length 4.6
  TOP w0.14: v1(221.11,53.34) 221.11,51.84 221.5,51.44 RV1072.2 222.44,51.44 RV656.2 222.44,50.94 222.57,50.81 RV650.1
SUS_ON: length 3.1
  TOP w0.14: UE3.A9 299.27,9.48 299.05,9.25 v1(299.05,8.75) 299.05,8.68 RE39.2
SUS_ON_EC: length 445.7
  TOP w0.14: v2(279.27,7.63) 279.59,7.31 279.59,5.01 278.09,3.51 271.27,3.51 271.02,3.77 v2(271.02,4.07) ; v2(123.34,64.36) 122.86,63.87 UZ22.1 ; v2(120.89,49.97) 120.89,41.95 108.21,29.27 108.21,25.64 109.08,24.77 109.08,20.09 109.91,19.27 113.97,19.27 114.37,19.27 116.5,17.14 116.5,16.15 117.6,15.05 122.15,15.05 123.32,13.88 123.32,12.98 117.81,7.47 117.81,7.36 v2(117.81,7.36) ; RE38.1 RE30.1 298.45,5.34 v2(298.01,5.78) 297.82,5.97 RE39.1
  IN2 w0.099: v2(123.34,64.36) 123.66,64.04 123.66,54.28 122.15,52.76 122.15,50.53 121.59,49.97 v2(120.89,49.97)
  IN3 w0.091: v2(271.02,4.07) 270.66,3.72 268.58,3.72 267.53,4.77 264.8,4.77 263.87,3.85 249.88,3.85 249.37,4.35 247.05,4.35 245.81,3.11 245.81,2.1 245.18,1.47 234.21,1.47 231.6,4.08 213.62,4.08 210.81,1.26 201.86,1.26 200.5,2.61 166.74,2.61 v2(165.86,3.49)
  IN5 w0.099: v2(22.35,3.5) 22.6,3.74 22.6,17.14 20.78,18.96 18.72,18.96 16.81,20.86 16.27,20.86 14.86,22.28 14.86,24.76 19.15,29.05 19.15,30.34 v2(19.56,30.74) ; v2(279.27,7.63) 279.71,7.19 289.17,7.19 291.83,9.84 292.34,9.84 293.44,10.94 294.29,10.94 296,9.23 296,8.02 298.01,6 v2(298.01,5.78)
  IN6 w0.089: 101.98,6.12 101.91,6.12 101.86,6.08 99.9,6.08 99.24,5.42 99.24,3.71 98.58,3.06 97.92,3.06 96.91,4.06 95.58,4.06 95.39,4.25 93,4.25 92.22,3.48 91.68,3.48 90.57,2.37 90.11,2.37 89.79,2.05 87.88,2.05 87.26,2.67 86.79,2.67 86.46,3 83.95,3 82.46,1.51 75.06,1.51
  IN6 w0.099: 101.98,6.12 104.54,6.12 104.88,5.78 106.71,5.78 107.69,4.8 109.42,4.8 110.35,5.73 115.68,5.73 117.31,7.36 v2(117.81,7.36) 118.81,7.36 118.93,7.48 127.25,7.48 127.32,7.41 130.05,7.41 130.67,6.79 134.95,6.79 135.97,7.81 144.54,7.81 147.2,5.14 149.77,5.14 150.32,4.59 156.36,4.59 157.64,3.31 161.84,3.31 162.46,3.93 165.42,3.93 v2(165.86,3.49) ; 75.06,1.51 74.85,1.51 72.68,3.68 71.2,3.68 69.53,5.34 63.25,5.34 60.19,2.29 58.8,2.29 55.63,5.47 55.63,8.28 54.27,9.64 54.27,12.45 53.84,12.88 53.84,14.18 52.9,15.12 52.9,16.65 50.79,18.75 50.79,19.74 50.27,20.26 41.95,20.26 41.64,20.57 33.14,20.57 31.39,18.82 28.79,18.82 25.32,15.36 23.01,15.36 22.67,15.02 22.67,3.82 v2(22.35,3.5)
  BOTTOM w0.14: v2(19.56,30.74) 19.65,30.83 RT240.1
SUS_ON_EC_P: length 309.2
  TOP w0.14: UZ18.1 125.76,69.33 128.67,69.33 129.16,68.84 129.91,68.84 v2(129.92,68.85) ; UZ23.1 v2(105.22,53.36) 104.9,53.68 104.9,54.24 105.09,54.43 RZ91.1 ; v2(119.13,65.99) 119.43,66.29 RZ87.1 120.59,66.04 UZ22.4 ; v2(178.8,30.53) v3(180.1,29.23) 181.23,28.1 181.23,24.71 181.04,24.52 181.04,23.15 181.37,22.82 181.37,18.93 182.68,17.62 182.68,16.88 184.76,14.8 184.76,9.95 183.63,8.82 PR1801.1
  IN1 w0.089: 134.62,67.36 134.85,67.59 136.93,67.59 137.68,66.85 138.56,66.85 139.07,67.36 v2(139.07,67.37)
  IN1 w0.099: v2(129.92,68.85) 130.88,67.89 130.88,65.2 131.41,64.67 131.93,64.67 134.62,67.36
  IN2 w0.099: v2(119.13,65.99) 119.19,66.05 123.52,66.05 124.13,66.66 128.37,66.66 129.36,67.65 129.36,68.3 v2(129.92,68.85) ; v2(291.54,27.82) 289.62,25.9 287.07,25.9 286.4,26.58 282.27,26.58 281.73,27.11 278.78,27.11 274.97,23.3 268.5,23.3 267.33,22.13 264.31,22.13 264.09,22.36 263.69,22.36 263.29,21.96 260.49,21.96 259.36,23.09 258.52,23.09 257.37,21.94 254.57,21.94 253.15,20.52 251.76,20.52 v2(251.56,20.71)
  IN3 w0.089: v2(139.07,67.37) 139.49,67.78 140.7,67.78 142.22,69.3 142.39,69.3 142.6,69.5 144.73,69.5 144.96,69.27 155.12,69.27 156.49,70.65 159.56,70.65 161.09,69.12 175.08,69.12 176,68.21 181.1,68.21
  IN3 w0.091: v2(182.59,67.52) 181.9,68.21 181.1,68.21
  IN5 w0.099: v2(178.8,30.53) 179.5,29.84 223.88,29.84 227.52,26.2 249.44,26.2 250.56,25.07 250.56,21.93 251.56,20.93 v2(251.56,20.71)
  IN6 w0.099: v2(178.8,30.53) 178.8,32.01 192.69,45.89 192.69,54.91 191.64,55.95 191.64,59.32 186.53,64.43 184.88,64.43 182.59,66.72 v2(182.59,67.52) ; v2(105.22,53.36) 105.36,53.22 113.04,53.22 116.73,56.91 116.73,62.27 119.13,64.66 v2(119.13,65.99)
  BOTTOM w0.254: v2(291.54,27.82) 292.39,27.82 292.75,28.18 PR606.1
SUS_ON_EC_ST: length 116.4
  TOP w0.14: RZ91.2 106.31,54.1 106.62,53.79 106.62,53.35 107.13,52.84 107.13,52.32 107.38,52.06 UZ23.4 108.84,52.06 RZ88.1 109.59,51.32 v1(111.96,51.32) 112.8,51.32 113.88,50.24 113.88,49.32 114.03,49.17 114.03,48.53 v2(113.67,48.17) ; v2(179.87,85.26) 179.87,85.13 179.62,84.89 UZ15.4
  IN2 w0.099: v2(113.67,48.17) 113.92,48.42 116.23,48.42 117.33,49.51 121.67,49.51 124.47,52.32 124.47,61.49 126.42,63.43 130.43,63.43 v2(130.9,63.9)
  IN3 w0.089: v2(140.4,68.97) 140.4,69.22 141.48,70.3 144.18,70.3 145.03,69.45 155.05,69.45 156.42,70.82 159.64,70.82 161.16,69.3 175.16,69.3 176.07,68.39 180.28,68.39 181.1,69.21 ; 179.9,84.99 179.87,85.03 v2(179.87,85.26)
  IN3 w0.091: 179.9,84.99 181.89,83 182.67,83 183.42,82.25 183.42,74.85 181.17,72.59 181.17,69.28 181.1,69.21
  IN6 w0.089: v2(140.4,68.97) 139.32,68.97 138.56,68.21 135.64,68.21 134.62,67.19
  IN6 w0.099: 134.62,67.19 131.33,63.9 v2(130.9,63.9)
SUS_ON_P: length 10.3
  TOP w0.14: v2(134.59,69.64) 134.17,70.05 RZ72.1 ; UZ18.4 127.88,67.56 RZ80.1 127.95,68.27 v2(127.64,68.27)
  BOTTOM w0.14: v2(127.64,68.27) 128.7,69.34 134.29,69.34 v2(134.59,69.64)
SUSACK#: length 238.7
  TOP w0.14: v3(185.23,3.87) 184.6,4.51 v2(184.6,4.59) ; v2(298.5,12.16) 298.02,11.68 UE3.B7
  IN2 w0.089: v2(90.42,2) 90.44,2 90.69,2.25 90.69,2.75 90.99,3.06 92.07,3.06 93.02,4.01 96.85,4.01 97.68,3.18 99.05,3.18 99.57,3.7 99.57,5.4 100.15,5.98 101.98,5.98
  IN2 w0.099: v2(184.6,4.59) 184.6,4.14 184.24,3.78 183.23,3.78 182.62,3.17 171.08,3.17 169.79,4.46 163.28,4.46 162.75,4.99 159.49,4.99 159.24,5.24 156.58,5.24 156.07,4.74 150.56,4.74 149.04,6.26 147.41,6.26 145.08,8.58 136.15,8.58 135.93,8.37 117.99,8.37 116.18,6.57 114.28,6.57 113.44,5.73 104.98,5.73 104.73,5.98 101.98,5.98
  IN3 w0.091: v2(298.5,12.16) 298.16,12.16 297.94,11.95 297.94,10.26 298.62,9.58 298.62,3.72 v2(298.91,3.43)
  IN5 w0.099: v2(184.6,4.59) 185.67,3.51 199.64,3.51 203.61,7.48 206.06,7.48 206.7,8.13 210.09,8.13 211.18,7.04 219.23,7.04 219.44,7.25 225.87,7.25 227.21,5.9 238.27,5.9 239.53,7.17 262.4,7.17 262.75,6.82 270.62,6.82 271.06,6.37 272.45,6.37 273.83,5 281.71,5 282.44,4.27 284.87,4.27 285.02,4.12 285.09,4.12 285.34,3.87 291.11,3.87 291.34,4.1 295.79,4.1 295.79,4.1 297.12,4.1 297.35,3.87 298.47,3.87 v2(298.91,3.43)
  BOTTOM w0.089: UH2.BB19 90.28,5.39 89.98,5.09 89.98,4.31 90.17,4.13 90.17,3.64 90.03,3.5 90.03,3.02 89.97,2.95 89.97,2.45 v2(90.42,2)
SUSCLK: length 335.3
  TOP w0.14: v2(266.17,9.18) 266.17,6.79 266.6,6.36 RD9.2 ; v1(339.4,99.44) 339.45,99.39 v2(340.35,99.39) 341.05,99.39 RN1.2
  IN1 w0.099: v2(340.35,99.39) 340.35,98.55 338.52,96.72 338.52,93.4 330.72,85.6 330.72,77.11 330.33,76.72 330.33,75.29 332.39,73.22 332.39,67.13 333.41,66.11 333.41,63.84 333.65,63.59 333.65,62.71 333.25,62.3 333.25,58.03 330.39,55.17 330.39,48.59 328.42,46.62 328.42,45.41 327.53,44.52 327.53,43.38 325.5,41.35 325.5,36.97 318.37,29.83 318.37,25.66 318.37,24.89 314.4,20.92 307.87,20.92 305.92,18.97 303.85,18.97 303.09,18.21 301.79,18.21 301.28,17.69 298.65,17.69 297.61,16.66 294.23,16.66 293.29,17.6 291.51,17.6 290.91,18.2 289.05,18.2 288.77,17.91 286.42,17.91 285.89,17.38 285.89,16.86 285.47,16.44 284.89,16.44 282.8,14.35 275.07,14.35 273.59,12.88 272.47,12.88 270.36,10.77 267.75,10.77 v2(266.17,9.18)
  IN6 w0.089: 99.26,10.32 99.5,10.56 101.98,10.56
  IN6 w0.099: 101.98,10.56 102.25,10.56 102.42,10.39 106.44,10.39 106.56,10.51 107.42,10.51 107.75,10.17 112.88,10.17 113.73,11.03 115.29,11.03 115.89,10.43 125.1,10.43 126.03,11.35 128.05,11.35 128.68,10.72 145.07,10.72 145.55,10.25 146.64,10.25 148.23,8.66 149.59,8.66 149.8,8.87 151.19,8.87 151.47,8.59 151.8,8.59 154.89,8.59 155.07,8.77 155.64,8.77 156.12,8.29 157.38,8.29 158.56,9.47 163.91,9.47 164.92,8.46 170.84,8.46 172.55,10.18 176.54,10.18 176.58,10.22 186.6,10.22 186.94,10.55 201.31,10.55 202.51,11.75 214.23,11.75 216.07,9.91 228.05,9.91 228.66,9.31 229.05,9.31 230.07,8.29 252.63,8.29 252.94,8.6 262.14,8.6 263.05,9.51 265.83,9.51 v2(266.17,9.18) ; 99.26,10.32 97.97,10.32 97.45,10.84 95.89,10.84 94.2,9.15 93.37,9.15 v2(93.01,9.51)
  BOTTOM w0.089: UH2.AN15 92.7,9.83 v2(93.01,9.51)
SUSCLK_R: length 9.8
  TOP w0.14: v2(340.82,92.74) 341.26,93.19 v1(341.26,98.75) 341.58,99.07 342.2,99.07 342.72,99.59 RN1.1
  BOTTOM w0.14: v2(340.82,92.74) 340.8,92.73 JNGFF1.42
SW_1.2V: length 13.1
  IN6 w1.016: v2(272.16,29.47) 272.48,29.79 280.04,29.79 282.03,27.8 284.35,27.8
  vias: v2(270.89,29.47) v2(285.69,27.95) v2(286.13,28.33)
SW_+1.35VRUN:
  vias: v1(199.52,115.52) v2(199.14,111.83) v2(199.77,111.83)
SYS_PEX_RST_MON#: length 14
  TOP w0.14: v1(229.93,46.82) 229.27,46.16 228.98,46.16 RV1121.2 229.55,45.31 v2(229.55,44.59) 229.14,44.18 RV583.2 229.34,43.76 RV1107.2 ; RV557.1 222.64,46.53 v2(222.64,46.17) 222.62,46.17 222.27,45.82 UV21.1
  BOTTOM w0.14: v2(222.64,46.17) 223.41,45.41 228.73,45.41 v2(229.55,44.59)
SYS_PEX_RST_MON#_L: length 8.6
  TOP w0.14: RV587.1 224.85,41.54 v1(226.09,41.54) 227.28,41.54 228.21,42.46 228.21,43.14 228.32,43.25 228.32,44.39 228.56,44.63 228.78,44.63 228.92,44.77 RV583.1 228.04,45.09 227.92,45.22 UV19.4
SYS_RESET#: length 203.8
  TOP w0.127: v2(115.25,47.39) 116.07,46.58 116.07,39.87 106.33,30.14 102.03,30.14 99.15,27.26 99.15,25.71 99.91,24.95 99.91,22.94 100.01,22.84 101.24,21.61 101.56,21.61 102.34,20.83 102.91,20.83 105.58,18.16 v3(106.55,18.16) 106.69,18.02 108.87,18.02 109.44,17.45 112.94,17.45 113.54,16.84 113.54,16.47 113.41,16.33 113.41,12.51 111.58,10.68 106.43,10.68 105.67,9.91 105.67,9.05 105.68,9.04 105.68,7.98 105.25,7.54 105.25,7.14 105.02,6.91 105.02,6.37 105.09,6.3 105.09,5.36 RH571.1 104.45,5.22 v2(104.34,5.32)
  IN4 w0.091: v2(124.8,93.87) 124.7,93.87 123.11,92.29 122.99,92.29 122.99,86.93 124.47,85.44 124.47,71.28 121.63,68.44 121.63,67.28 117.43,63.08 117.43,52.76 116.97,52.3 116.97,49.11 v2(115.25,47.39)
  IN6 w0.099: v2(104.34,5.32) 105.62,4.04 107.13,4.04 107.38,3.79 109.5,3.79 109.88,4.17 116.69,4.17 119.6,7.07 126.98,7.07 127.07,6.99 129.87,6.99 130.47,6.39 141.06,6.39 141.91,7.24 144.83,7.24 147.12,4.94 149.69,4.94 150.24,4.39 156.28,4.39 157.58,3.09 163.19,3.09 163.22,3.06 163.55,3.06 163.58,3.09 164.1,3.09 164.11,3.08 164.44,3.08 164.45,3.09 164.81,3.09 v2(165.25,3.53)
  BOTTOM w0.089: 101.88,5.44 101.6,5.72 101.37,5.72 100.08,7.01 99.43,7.01 99.41,7.04 UH2.AW1
  BOTTOM w0.127: 101.88,5.44 101.88,5.14 102.12,4.9 103.93,4.9 v2(104.34,5.32)
  BOTTOM w0.14: JAPS.13 172.62,6.87 172.66,6.83 172.66,6.17 172.21,5.72 167.45,5.72 v2(165.25,3.53) ; RH8.2 124.8,94.2 v2(124.8,93.87)
TB_HDMI_HPLUG: length 52.8
  IN5 w0.099: v2(25.22,46.64) 25.22,46.99 24.28,47.92 24.28,48.95 25.51,50.17 25.51,51.24 26.96,52.7 26.96,55.94 26.8,56.11 26.8,57.97 26.08,58.69 26.08,61.29 25.88,61.48 25.88,63.75 24.42,65.21 24.42,65.53 24.16,65.79 24.16,67.93 23,69.08 23,81.3 v2(23.81,82.11)
  BOTTOM w0.102: v2(25.22,46.64) 25.22,46.41 24.73,45.92 UT1.G1
  BOTTOM w0.127: RV122.1 17.82,88.3 18.23,87.89 21.27,87.89 22.04,87.13 22.04,83.81 23.73,82.11 v2(23.81,82.11)
  BOTTOM w0.14: QV14.3 17.56,90.04 17.82,89.78 RV122.1
TBT_BATLOW#: length 2.8
  TOP w0.089: v4(24.13,46.29) 23.89,46.53 23.89,47.07 23.94,47.13
  TOP w0.14: RT25.2 24.16,47.34 23.94,47.13
  BOTTOM w0.089: v4(24.13,46.29) 24.03,46.19 24.03,45.51 UT1.F2
TBT_CIO_PLUG_EVENT#: length 105.5
  TOP w0.089: v2(79.27,17.23) 79.87,16.64 v3(80.27,16.64)
  TOP w0.14: v2(32.47,47.44) 32.45,47.47 RT23.2
  IN6 w0.099: v2(79.27,17.23) 78.79,17.71 76.66,17.71 71.95,22.43 65.85,22.43 62.23,26.04 58.8,26.04 56.64,28.2 50.59,28.2 48.9,29.89 45.23,29.89 43.8,31.33 40.04,31.33 39.24,30.53 35.55,30.53 34.74,31.34 34.22,31.34 32.28,29.41 30.86,29.41 30.13,28.67 29.18,28.67 28.13,29.73 27.15,29.73 26.68,30.2 26.68,32 28.22,33.54 28.51,33.54 28.98,34.01 30.28,34.01 32.47,36.2 42.48,36.2 42.8,36.52 42.8,37.03 42.42,37.41 42.42,38.64 40.72,40.33 40.32,40.33 39.05,41.6 38.89,41.6 36.85,43.64 36.24,43.64 36.11,43.52 35.36,43.52 34.86,44.02 33.29,44.02 33.1,44.21 32.44,44.21 31.62,45.03 31.62,46.87 32.2,47.44 v2(32.47,47.44)
  BOTTOM w0.089: v2(79.27,17.23) 79.68,17.64 UH2.U41 ; UT1.W2 30.48,45.5 30.48,45.9 31.37,46.79 31.57,46.79 31.69,46.91 31.7,46.91 31.87,47.08 31.9,47.08 31.9,47.09 32.34,47.09
  BOTTOM w0.127: 32.34,47.09 32.46,47.21 32.46,47.43 v2(32.47,47.44)
TBT_CLK_REQ#: length 138.3
  TOP w0.14: RP2.7 68.35,6.14 68.59,5.9 68.59,4.89 67.57,3.86 v2(67.57,3.84)
  IN2 w0.099: v2(56.26,9.15) 54.74,9.15 54.47,9.42 54.47,11.05 56.43,13 56.43,14.85 56.91,15.33 56.91,18.41 54.93,20.39 54.93,21.19 53.49,22.63 48.12,22.63 46.69,24.06 44.6,24.06 43.13,25.54 37.28,25.54 36.54,24.8 31.68,24.8 30.82,23.94 28.89,23.94 26.87,21.93 23.57,21.93 v2(22.73,21.09)
  IN5 w0.089: 75.06,4.19 75.16,4.09 75.19,4.09 75.4,3.88 79.82,3.88 80.02,4.07 81.99,4.07 82.19,3.88 82.55,3.88 82.71,3.71 85.43,3.71 86.27,2.88 86.59,2.88 86.8,2.66 87.2,2.66 87.41,2.45 87.41,2.29 87.95,1.75 88.07,1.75 v2(88.13,1.69)
  IN5 w0.099: 75.06,4.19 74.42,4.83 69.55,4.83 69.3,5.07 68.4,5.07 68.07,4.74 67.9,4.57 67.9,4.18 v2(67.57,3.84) 67.12,3.4 66.3,3.4 65.96,3.73 65.96,5.01 64.7,6.27 59.19,6.27 57.18,8.28 57.18,8.53 56.55,9.15 v2(56.26,9.15) ; v2(19.86,50.24) 19.46,49.84 19.46,44.84 20.7,43.6 20.7,38.44 21.64,37.49 21.64,31.84 20.37,30.56 20.37,29.41 15.46,24.51 15.46,23.38 15.94,22.91 17.39,22.91 19.85,20.45 22.1,20.45 v2(22.73,21.09)
  BOTTOM w0.089: v2(88.13,1.69) 87.72,2.09 87.72,2.1 87.62,2.2 87.62,2.75 87.69,2.82 87.69,3.46 87.47,3.69 UH2.BE25
  BOTTOM w0.14: v2(19.86,50.24) 18.16,50.24 17.96,50.03 QT12.3 17.96,48.8 17.49,48.33 RT21.2
TBT_CLK_REQ#_AR: length 36
  IN6 w0.099: v2(19.86,51.08) 20.37,51.08 21.72,49.73 25.4,49.73 25.78,49.35 25.78,48.27 25.4,47.89 21.4,47.89 20.38,46.87 20.38,43.7 20.83,43.25 21.85,43.25 22.29,43.7 22.29,44.52 23.25,45.48 30.65,45.48 32.5,43.63 v2(32.87,43.63)
  BOTTOM w0.089: 33.66,44.08 33.53,44.08 33.08,43.63 v2(32.87,43.63) 32.61,43.63 32.36,43.89 UT1.AC5
  BOTTOM w0.14: RT434.2 33.66,44.08 ; v2(19.86,51.08) 19.86,51.39 v1(19.42,51.84) 18.76,51.84 18.61,51.69 QT12.1
TBT_CONFIG: length 4.2
  TOP w0.14: RT1093.2 24.26,62.86 v1(24.26,62.49) 24.26,62.04 23.86,61.65 RT183.1 23.37,60.79 v2(23.37,60.41)
  BOTTOM w0.081: UT4.H6 v2(23.37,60.41)
TBT_DDC_CLK: length 67.7
  IN6 w0.099: v2(34.16,47.06) 33.73,47.06 33.2,47.6 33.2,48.95 29.64,52.51 29.64,56.76 28.58,57.81 28.58,66.97 24.05,71.5 24.05,81.43 26.21,83.59 26.21,89.64 27.18,90.6 27.18,94.44 25.8,95.82 21.67,95.82 20.97,95.12 20.97,93.4 v2(20.85,93.29)
  BOTTOM w0.076: UT1.Y2 30.94,45.49 30.94,45.9 31.4,46.36 32.17,46.36 32.4,46.6 32.47,46.6 32.94,47.08 33.29,47.08
  BOTTOM w0.14: v2(34.16,47.06) 34.11,47.06 33.74,47.43 RT33.2 33.61,47.39 33.29,47.08 ; QX1.1 21.09,93.52 v2(20.85,93.29)
TBT_DDC_DATA: length 60.9
  IN6 w0.089: v2(32.02,46.72) 32.37,46.72 32.78,47.13
  IN6 w0.099: 32.78,47.13 33,47.34 33,48.87 29.42,52.44 29.42,56.69 28.38,57.73 28.38,66.87 23.85,71.4 23.85,81.52 26.01,83.68 26.01,89.72 26.12,89.84 26.12,89.85 26.14,89.85 26.98,90.69 26.98,94.36 25.93,95.4 v2(23.69,95.4)
  BOTTOM w0.076: 32.21,46.81 32.11,46.81 v2(32.02,46.72) 31.88,46.58 31.39,46.58 30.71,45.9 UT1.Y1
  BOTTOM w0.102: 32.21,46.81 32.42,46.81 33.02,47.41 RT34.2
  BOTTOM w0.14: v2(23.69,95.4) QX1.4
TBT_FORCE_PWR: length 96.9
  TOP w0.14: v1(21.5,33.02) 21.19,33.33 v2(21.08,33.33) 20.78,33.03 RT38.2
  IN2 w0.099: v2(21.08,33.33) 22.1,34.34 28.99,34.34 29.54,33.79 33.63,33.79 34.44,32.98 38.59,32.98 40.23,31.35 44.66,31.35 47.21,28.8 57.07,28.8 57.85,28.01 58.61,28.01 61.77,24.85 65.79,24.85 66.31,24.33 74.02,24.33 74.98,23.37 74.98,21.66 73.13,19.81 73.13,14.89 75.58,12.44 77.53,12.44 77.73,12.64 77.73,18.68 v2(77.34,19.06)
  IN3 w0.089: v2(24.77,44.26) 24.32,43.81 23.1,43.81 22.81,43.51 22.81,42.13 21.98,41.3 21.98,34.3
  IN3 w0.091: v2(21.08,33.33) 21.98,34.22 21.98,34.3
  BOTTOM w0.089: UT1.H4 25.08,44.57 v2(24.77,44.26) ; UH2.P43 78.68,19.38 78.49,19.19 78.45,19.19 78.41,19.15 78.16,19.15 78.12,19.19 78.03,19.19 77.9,19.06 77.73,19.06 77.6,18.93 77.47,18.93 v2(77.34,19.06)
TBT_I2C_CLK: length 26.3
  IN2 w0.099: v2(20.34,57.49) 20.34,57.48 20.26,57.41 20.26,57.1 19.49,56.32 19.49,53.73 19.74,53.47 22.18,53.47 22.76,52.9 22.76,48.5 23.74,47.51 23.74,46.06 23.89,45.91 28.09,45.91 29.08,46.91 v2(30.35,46.91)
  BOTTOM w0.081: UT4.D2 21.37,57.9 21.12,57.65 20.5,57.65 20.34,57.49 v2(20.34,57.49)
  BOTTOM w0.089: 30.67,47.13 30.46,46.91 v2(30.35,46.91) 30.29,46.85 29.88,46.85 29.57,46.53 29.57,45.5 UT1.U2
  BOTTOM w0.127: RT36.2 30.74,47.19 30.67,47.13
TBT_I2C_DATA: length 25.4
  TOP w0.089: v2(29.2,46.27) 28.78,45.86 v1(28.5,45.86)
  IN2 w0.099: v2(20.34,58.07) 20.34,58.06 19.9,57.63 19.9,57.12 19.66,56.88 19.66,56.88 19.29,56.5 19.29,53.65 19.66,53.27 22.09,53.27 22.55,52.81 22.55,48.42 23.54,47.43 23.54,46 23.81,45.73 28.65,45.73 v2(29.2,46.27)
  BOTTOM w0.081: UT4.D1 20.51,57.9 v2(20.34,58.07)
  BOTTOM w0.089: v2(29.2,46.27) 29.33,46.14 UT1.U1
  BOTTOM w0.127: RT35.2 30.1,47.25 29.9,47.05 29.76,47.05 29.2,46.49 v2(29.2,46.27)
TBT_JTAG_TCK: length 25.9
  TOP w0.089: v2(28.66,44.24) 29.07,44.66 29.07,44.99 29.87,45.79 31.85,45.79 32.48,46.42 32.8,46.42 32.98,46.24 33.52,46.24 33.66,46.1
  TOP w0.127: 33.66,46.1 33.81,45.94 RT7.2
  TOP w0.14: v2(40.22,39.87) 40.07,40.01 T198.1
  IN4 w0.091: v2(28.66,44.24) 29.01,44.59 29.01,44.78 29.81,45.58 30.89,45.58 32.46,44 32.46,42.1 34.34,40.22 35.31,40.22 37.52,38.01 39.03,38.01 39.82,38.8 39.82,39.47 v2(40.22,39.87)
  BOTTOM w0.102: v2(28.66,44.24) UT1.T4
TBT_JTAG_TDI: length 20.3
  TOP w0.089: 33.66,44.09 33.57,44.17 32.7,44.17 31.79,45.08 30.27,45.08 30.06,44.87 v4(29.95,44.87)
  TOP w0.127: RT9.2 33.66,44.08 33.66,44.09
  TOP w0.14: v2(39.88,36.97) 39.61,36.7 T196.1
  IN4 w0.089: v4(29.95,44.87) 30.65,44.87 31.88,43.63 31.88,42.03 33.66,40.25
  IN4 w0.091: v2(39.88,36.97) 37.58,36.97 34.84,39.71 34.2,39.71 33.66,40.25
  BOTTOM w0.089: v4(29.95,44.87) 30.56,44.87 30.85,44.57 UT1.Y4
TBT_JTAG_TDO: length 16.6
  TOP w0.089: v2(29.95,44.26) 30.33,44.64 31.98,44.64 32.62,44 33.25,44 33.66,43.6
  TOP w0.127: RT6.2 33.66,43.6
  TOP w0.14: T199.1 36.35,37.32 v2(36.35,37.28)
  IN5 w0.089: v2(29.95,44.26) 29.96,44.27 29.97,44.27 29.99,44.29 29.99,44.3 30.34,44.65 30.8,44.65 31.88,43.57 31.88,42.13 33.66,40.36
  IN5 w0.099: v2(36.35,37.28) 36.35,37.66 33.66,40.36
  BOTTOM w0.102: UT1.W4 30.26,44.57 v2(29.95,44.26)
TBT_JTAG_TMS: length 23.2
  TOP w0.089: 33.66,44.91 33.15,44.91 32.92,45.14 32.35,45.14 31.98,45.52 30.46,45.52 30.22,45.27 29.86,45.27 29.31,44.72 v4(29.31,44.26)
  TOP w0.14: T197.1 40.24,38.74 v2(40.46,38.96) ; RT8.2 33.76,44.91 33.66,44.91
  IN4 w0.091: v2(40.46,38.96) 40.45,38.96 39.24,37.75 37.22,37.75 34.99,39.99 34.19,39.99 32.13,42.05 32.13,44.08 30.98,45.23 29.78,45.23 29.31,44.76 v4(29.31,44.26)
  BOTTOM w0.102: v4(29.31,44.26) 29.31,44.27 29.61,44.57 UT1.V4
TBT_LSRX: length 34.3
  TOP w0.14: v2(22.01,62.14) 22.45,62.58 22.45,63.17 22.09,63.52 v2(22.09,65.04)
  IN2 w0.099: v2(22.01,62.14) 21.71,62.44 19.44,62.44 18.48,61.48 18.48,42.83 18.82,42.49 20.31,42.49 20.5,42.68 20.5,43.61 v2(21.15,44.25)
  BOTTOM w0.081: v2(22.01,62.14) 22.12,62.03 22.12,61.18 22.37,60.93 UT4.K4
  BOTTOM w0.089: 20.58,44.22 21.12,44.22 21.15,44.24 v2(21.15,44.25) 21.23,44.17 21.79,44.17 UT1.A4
  BOTTOM w0.14: 20.58,44.22 20.4,44.22 RT45.2 ; RT232.1 22.07,65.06 v2(22.09,65.04)
TBT_LSTX: length 31.7
  IN2 w0.099: v2(21.15,43.64) 21.08,43.71 20.9,43.71 20.71,43.52 20.71,42.59 20.4,42.27 18.73,42.27 18.27,42.74 18.27,61.57 19.35,62.65 21.88,62.65 v2(22.02,62.8)
  BOTTOM w0.081: v2(22.02,62.8) 22.42,62.4 22.42,61.97 22.37,61.92 UT4.L4
  BOTTOM w0.089: UT1.A5 21.39,43.89 v2(21.15,43.64) 20.88,43.91 20.58,43.91
  BOTTOM w0.14: RT44.2 20.37,43.91 20.58,43.91 ; v2(22.02,62.8) 22.38,63.15 RT233.1
TBT_ML0_N: length 2.8
  BOTTOM w0.089: UT1.R1 28.41,45.62 28.34,45.55 28.24,45.55 28.18,45.61 28.18,45.97 28.36,46.16 28.36,46.31 28.49,46.43 28.49,46.86
  BOTTOM w0.14: CV172.2 29,47.56 29,47.35 28.74,47.09 28.72,47.09 28.49,46.86
TBT_ML0_P: length 2.8
  BOTTOM w0.089: UT1.R2 28.64,45.5 28.64,46.19 28.78,46.33 28.78,46.54
  BOTTOM w0.102: 28.78,46.67 28.78,46.54
  BOTTOM w0.14: 28.78,46.67 29.33,47.22 29.33,47.52 CV173.2
TBT_ML1_N: length 2.7
  BOTTOM w0.089: UT1.N1 27.49,45.65 27.41,45.56 27.35,45.56 27.26,45.65 27.26,45.98 27.71,46.43 27.71,47.01 27.83,47.13
  BOTTOM w0.14: 27.83,47.13 27.88,47.18 27.88,47.53 CV174.2
TBT_ML1_P: length 2.7
  BOTTOM w0.089: UT1.N2 27.72,45.5 27.72,46.05 27.99,46.31 27.99,46.96 28.16,47.13
  BOTTOM w0.14: 28.16,47.13 28.21,47.18 28.21,47.54 CV175.2
TBT_ML2_N: length 2.3
  BOTTOM w0.089: UT1.L1 26.57,45.65 26.5,45.58 26.41,45.58 26.34,45.65 26.34,46.01 26.44,46.11 26.44,46.16 26.68,46.4
  BOTTOM w0.102: 26.68,46.4 26.68,46.81 26.72,46.85 26.72,47.09 26.73,47.09 26.71,47.11 26.71,47.13
  BOTTOM w0.14: CV176.2 26.71,47.33 26.71,47.13
TBT_ML2_P: length 2.4
  BOTTOM w0.089: 26.9,46.3 26.8,46.2 26.8,45.5 UT1.L2
  BOTTOM w0.102: 26.9,46.3 26.9,46.73 27.04,46.87 27.04,47.13
  BOTTOM w0.14: CV177.2 27.04,47.25 27.04,47.13
TBT_ML3_N: length 4.8
  BOTTOM w0.089: UT1.J1 25.65,45.65 25.58,45.58 25.49,45.58 25.42,45.65 25.42,45.96 25.95,46.49 25.95,46.97 25.92,47 25.92,47.09 25.9,47.11 25.9,47.13
  BOTTOM w0.14: 25.9,47.13 25.9,48.19 25.76,48.32 25.76,48.66 25.56,48.87 25.56,49.49 CV170.2
TBT_ML3_P: length 4.8
  BOTTOM w0.089: 26.23,47.13 26.23,46.38 25.88,46.03 25.88,45.5 UT1.J2
  BOTTOM w0.14: 26.23,47.13 26.23,48.33 26.09,48.46 26.09,48.8 25.89,49 25.89,49.53 CV171.2
TBT_PCIE_WAKE#: length 366.7
  TOP w0.14: RE120.1 305.42,3.82 v2(305.73,3.51) ; v2(61.09,20.65) 62.01,19.72 v3(62.5,19.72)
  IN1 w0.099: v2(32.49,48.07) 31.56,47.14 31.56,45.22 32.45,44.33 32.64,44.33 32.97,44 33.14,44 33.29,43.85 33.29,43.39 32.56,42.67 32.56,35.85 32.78,35.63 32.78,34.54 34.16,33.15 34.16,31.98 33.43,31.25 33.43,28.6 33.2,28.37 33.2,27.62 33.47,27.35 33.92,27.35 34.41,27.84 38.88,27.84 39.24,28.2 45.66,28.2 48.09,25.77 50.27,25.77 50.56,25.47 51.48,25.47 52.03,26.03 57.92,26.03 61.09,22.87 v2(61.09,20.65)
  IN5 w0.099: v2(61.09,20.65) 60.34,19.9 60.34,16.92 63.08,14.18 68.44,14.18 68.7,13.93 77.94,13.93 78.58,14.56 80.2,14.56 80.27,14.64 83.88,14.64 84.23,14.28 85.55,14.28 85.66,14.18 89.83,14.18 91.34,15.68 93.68,15.68 94.65,16.66 98.41,16.66 99.16,15.91 101.14,15.91 101.64,15.41 105.24,15.41 105.39,15.25 128.9,15.25 129,15.16 174.89,15.16 178.86,19.13 178.86,23.08 182.19,26.41 186.76,26.41 187.02,26.15 218.44,26.15 219.84,24.75 219.84,20.06 221.49,18.4 250.1,18.4 251.6,16.91 251.6,14.79 253.15,13.25 265.32,13.25 266.23,12.34 272.25,12.34 272.29,12.38 281.33,12.38 281.49,12.22 284.2,12.22 285.45,10.97 285.45,10.42 286.23,9.64 288.38,9.64 289.27,10.54 292.19,10.54 293.19,11.54 294.54,11.54 295.34,10.74 297.2,10.74 298.93,9 298.93,8.31 299.86,7.37 300.91,7.37 301.13,7.16 305.25,7.16 308.5,10.42 314.77,10.42 315.6,11.25 316.25,11.25 317.25,10.25 317.25,8.64 315.34,6.74 312.69,6.74 309.7,3.75 305.96,3.75 v2(305.73,3.51)
  BOTTOM w0.089: 31.62,47.13 31.5,47 31.33,47 30.25,45.92 UT1.W1
  BOTTOM w0.14: v2(32.49,48.07) 32.2,47.78 32.18,47.78 31.98,47.58 RT22.2 31.94,47.44 31.62,47.13
TBT_POC_RST#: length 9.7
  TOP w0.089: DT29.2 v2(24.12,44.26)
  TOP w0.14: RT244.2 25.66,49.76 RT202.2 25.5,49.44 v2(25.11,49.05) 25.43,49.05 v1(25.85,48.64)
  IN4 w0.089: 23.75,47.13 23.75,46.07 24.12,45.71 v2(24.12,44.26)
  IN4 w0.091: 23.75,47.13 23.75,48.32 24.49,49.05 v2(25.11,49.05)
  BOTTOM w0.089: UT1.F4 24.12,44.26 v2(24.12,44.26)
TBT_PWR_EN: length 8.7
  BOTTOM w0.089: UH2.AU43 78.67,8.02 78.42,8.26 77.97,8.26 77.69,8.54 75.06,8.54
  BOTTOM w0.127: RH556.2 71.01,8.43 71.2,8.24 72.8,8.24 72.94,8.1 73.48,8.1
  BOTTOM w0.14: 73.48,8.1 73.49,8.11 73.95,8.11 v3(74.3,8.45) 74.39,8.55 74.95,8.55 74.96,8.54 75.06,8.54
TBT_RBIAS: length 1.2
  TOP w0.508: RT10.1 25.02,42.49 24.76,42.76 v2(24.76,42.94)
  BOTTOM w0.203: v2(24.76,42.94) 25.08,43.26 UT1.H6
TBT_ROM_CLK: length 26.9
  IN1 w0.089: v2(33.26,45.31) 33.44,45.31 33.66,45.09
  IN1 w0.099: 33.66,45.09 34.05,44.7 34.05,43.42 34.8,42.66 34.8,40.58 37.53,37.86 37.53,31.12 36.7,30.3 36.7,29.21 v2(37.36,28.55)
  BOTTOM w0.089: v2(33.26,45.31) 32.97,45.02 32.97,44.61 32.73,44.37 32.46,44.37 32.26,44.57 31.85,44.57 UT1.AB4
  BOTTOM w0.14: v2(37.36,28.55) 38.2,28.55 39.51,29.85 UT2.6 41.21,29.85 41.63,29.43 RT231.1
TBT_ROM_CLK_R: length 89.6
  IN3 w0.091: v2(16.1,63.28) 15.69,62.86 15.69,62.24 16.77,61.16 16.77,45.06 15.89,44.18 15.89,43.42 14.99,42.52 14.99,36.67 14.27,35.96 14.27,35.68 14.23,35.63 14.23,35.53 13.76,35.07 13.76,34.06 14.15,33.66 14.57,33.66 14.83,33.41 14.83,30.52 14.35,30.04 14.35,26.21 13.37,25.22 13.37,24.25 14.77,22.84 14.77,21.91 15.46,21.22 16.9,21.22 18.35,22.67 19.68,22.67 19.85,22.84 22.1,22.84 23.42,24.16 28.21,24.16 29.04,24.99 32.73,24.99 v2(34.47,26.73)
  BOTTOM w0.14: v2(16.1,63.28) 16.34,63.28 16.64,63.57 RT210.1 ; v2(34.47,26.73) 37.92,26.73 38.8,25.85 44.26,25.85 44.52,26.11 v1(44.52,28.37) 44.52,29.72 43.5,30.74 42.1,30.74 41.91,30.55 RT231.2
TBT_ROM_CS#: length 29.8
  IN1 w0.089: 33.46,42.75 33.46,43.92 33.21,44.18 33.11,44.18 32.61,44.68 v2(32.61,44.77)
  IN1 w0.099: v2(34.78,28.58) 33.63,29.72 33.63,31.17 34.36,31.9 34.36,33.24 33.59,34.01 33.59,36.3 33.91,36.62 33.91,42.3 33.46,42.75
  BOTTOM w0.089: UT1.AC3 32.57,44.81 v2(32.61,44.77)
  BOTTOM w0.14: RT230.1 32.14,27.31 UT2.1 33.82,27.31 34.78,28.27 v2(34.78,28.58) 34.78,28.88 35.18,29.28 35.18,31.25 34.79,31.64 32.23,31.64 31.46,30.87 RT18.2
TBT_ROM_CS#_R: length 75.3
  IN2 w0.099: v2(25.4,72.69) 24.68,73.41 13.52,73.41 12.68,72.57 12.68,71.98 v2(12.89,71.76)
  IN6 w0.099: v2(31.1,27.19) 30.68,26.77 28.75,26.77 27.22,28.31 26.48,28.31 25.9,28.89 20.54,28.89 20.03,29.41 19.23,29.41 18.13,30.5 18.13,32.37 15.24,35.27 15.24,39.42 15.5,39.68 15.85,40.03 15.85,44.27 16.19,44.61 16.19,61.52 15.19,62.52 15.19,67.24 13.14,69.29 13.14,71.52 v2(12.89,71.76)
  BOTTOM w0.14: v2(25.4,72.69) v1(25.92,72.69) RT213.1 ; v2(31.1,27.19) 31.03,27.26 RT230.2
TBT_ROM_DI: length 31.2
  IN1 w0.089: v2(33.27,45.87) 32.89,45.5 32.89,45.09 33.06,44.93 33.51,44.93
  IN1 w0.099: v2(35.65,28.4) 35.65,31.14 34.77,32.02 34.77,34.96 34.31,35.42 34.31,42.58 33.85,43.05 33.85,44.58 33.51,44.93
  BOTTOM w0.076: UT1.AB3 31.85,45.03 32.23,45.03 32.33,45.13 32.75,45.13 32.89,45.27 32.89,45.5 v2(33.27,45.87)
  BOTTOM w0.14: v2(35.65,28.4) 35.65,28.54 36.89,29.78 37.71,29.78 39.05,31.12 UT2.5 41.21,31.12 41.43,31.34 RT228.1 43.53,31.34 v3(44.06,30.8)
TBT_ROM_DI_R: length 63
  TOP w0.14: v2(19.91,54.74) 19.7,54.95 19.7,56.73 19.88,56.9 20.38,56.9 20.92,57.44 RT211.1
  IN3 w0.091: v2(34.47,27.31) 32.51,27.31 32.24,27.59 28.94,27.59 28.8,27.45 28.8,26.39 27.73,25.32 25.93,25.32 25.23,26.02 25.23,27.53 24.62,28.14 20.95,28.14 19.11,29.98 19.11,31.31 18.54,31.89 18.54,32.5 16.06,34.98 16.06,42.18 16.56,42.68 17.02,42.68 17.59,43.25 17.59,44.47 18.66,45.55 18.66,53.83 19.58,54.74 v2(19.91,54.74)
  BOTTOM w0.14: v2(34.47,27.31) 35.22,28.07 35.22,28.73 36.66,30.17 37.59,30.17 39.35,31.92 RT228.2 42.66,31.92 v3(42.96,32.23)
TBT_ROM_DO: length 27.4
  TOP w0.14: v2(34.19,28.58) 33.75,28.58 33.19,28.03 v1(31.97,28.03)
  IN1 w0.099: v2(34.19,28.58) 34.63,28.14 35.08,28.14 35.24,28.3 35.24,31.26 34.57,31.94 34.57,34.88 34.11,35.33 34.11,42.5 33.65,42.96 33.65,44.21 v2(33.33,44.54)
  BOTTOM w0.089: UT1.AC4 32.23,44.35 32.41,44.17 32.96,44.17 v2(33.33,44.54)
  BOTTOM w0.14: v2(34.19,28.58) UT2.2 32.37,28.58 31.73,29.22 31.12,29.22 RT16.2 30.44,29.25 30.44,28.73 30.42,28.71 RT229.1
TBT_ROM_DO_R: length 77.4
  IN2 w0.099: v2(13.08,72.4) 13.7,73.01 23.66,73.01 v2(24.72,71.95)
  IN6 w0.099: v2(13.08,72.4) 13.34,72.14 13.34,69.38 15.39,67.33 15.39,62.6 16.39,61.6 16.39,44.53 16.05,44.19 16.05,39.95 15.75,39.65 15.44,39.34 15.44,35.35 19.48,31.31 20.03,31.31 22.25,29.09 25.98,29.09 26.56,28.51 27.3,28.51 28.15,27.66 30.05,27.66 v2(30.52,27.19)
  BOTTOM w0.14: v2(24.72,71.95) 24.77,72.01 24.77,72.91 25.08,73.22 27.05,73.22 27.24,73.03 v1(27.24,70.96) 27.24,70.56 26.86,70.18 RT212.1 ; RT229.2 30.42,27.29 v2(30.52,27.19)
TBT_ROM_HOLD#: length 3.2
  BOTTOM w0.14: v1(42.8,29.6) 42.32,29.12 42.32,28.82 RT15.2 42.09,28.58 UT2.7
TBT_ROM_WP#: length 24.6
  TOP w0.14: v2(29.98,46.43) 29.31,47.09 v1(29.31,47.64)
  IN1 w0.089: 32.07,44.33 29.98,46.42 v2(29.98,46.43)
  IN1 w0.099: 32.07,44.33 32.2,44.2 32.2,35.47 32.33,35.33 32.33,34.41 33.76,32.99 33.76,31.87 v2(31.75,29.85)
  BOTTOM w0.076: v2(29.98,46.43) 29.79,46.24 UT1.V1
  BOTTOM w0.14: UT2.3 v2(31.75,29.85) 31.62,29.85 30.48,31 RT17.2
TBT_RSENSE: length 1.3
  TOP w0.508: v2(25.41,42.94) 25.93,42.42 RT10.2
  BOTTOM w0.203: UT1.J6 25.73,43.26 v2(25.41,42.94)
TBT_SRC_CFG1: length 5.1
  TOP w0.14: v2(33.06,46.68) 33.02,46.72 RT107.2 33.15,47.41 33.6,47.86 33.6,48.62 v1(33.26,48.95)
  BOTTOM w0.089: v2(33.06,46.68) 32.81,46.43 32.46,46.43 32.23,46.19 31.47,46.19 31.17,45.9 UT1.AA1
TBT_SVR_IND: length 3.3
  BOTTOM w0.14: LT1.1 23.5,50.88 v1(22.26,52.12)
TBT_TEST_EN: length 3.5
  TOP w0.14: v1(25.99,47.08) 25.72,47.34 RT3.2 25.15,47.23 24.74,46.82 v2(24.26,46.82)
  BOTTOM w0.102: v2(24.26,46.82) 24.12,46.82 23.75,46.45 23.75,46.11 23.81,46.05 UT1.E1
TBT_TEST_PWRG: length 2.5
  BOTTOM w0.089: UT1.AB5 31.64,43.89 31.85,43.67 32.28,43.67 32.72,43.24 33.14,43.24 33.34,43.44 33.66,43.44
  BOTTOM w0.127: RT4.2 33.66,43.44
TBT_TMU_CLK_OUT: length 2.8
  BOTTOM w0.089: UT1.V2 30.02,45.5 30.02,45.96 31.19,47.13
  BOTTOM w0.127: 31.19,47.13 31.31,47.24 RT37.2
TBT_USB2_D+: length 37.9
  IN2 w0.099: v2(22.89,62.66) 22.69,62.85 22.69,63.06 22.28,63.48 19.02,63.48 17.45,61.91 17.45,41.38 19.85,38.98 20.42,38.98 23.03,36.37 23.81,36.37 23.91,36.48 v4(24.11,36.48)
  BOTTOM w0.081: UT4.L5 22.87,61.48 23.24,61.86 23.24,62.3 v2(22.89,62.66)
  BOTTOM w0.089: v4(24.11,36.48) 23.82,36.77 UT1.E20
TBT_USB2_D-: length 37.7
  IN2 w0.099: v2(23.46,37.09) 23.59,37.09 23.82,36.87 23.82,36.68 23.72,36.58 23.12,36.58 20.51,39.19 19.94,39.19 17.66,41.47 17.66,61.82 19.11,63.27 22.19,63.27 22.48,62.97 22.48,62.48 v2(22.89,62.07)
  BOTTOM w0.081: v2(22.89,62.07) 22.7,61.88 22.7,61.61 22.62,61.54 22.62,61.02 22.74,60.9 UT4.K5
  BOTTOM w0.089: UT1.D20 v2(23.46,37.09)
TBT_USB3_RX0_N: length 48.4
  TOP w0.089: 20.58,36.07 arc(20.71,36.03) 20.86,36.01 20.89,36.01 arc(21,35.97) v2(21.05,35.85)
  TOP w0.097: v2(10.19,69.97) arc(10.26,70.14) 10.44,70.21 12.59,70.21 arc(13.81,69.97) 14.84,69.28 16.79,67.33 arc(17.26,66.78) 17.63,66.18 arc(17.67,66) 17.69,65.82 17.69,64.84 arc(17.74,63.82) 17.91,62.81 arc(18.15,61.33) 18.23,59.83 arc(18.24,58.84) 18.29,57.85 arc(18.41,56.98) 18.69,56.13 arc(18.8,55.8) 18.84,55.44 18.88,53.22 18.88,52.84 18.88,52.84 18.89,46.4 arc(19.1,45.34) 19.7,44.44 arc(20.04,43.93) 20.16,43.32 20.16,36.71 arc(20.24,36.38) 20.47,36.13 arc(20.52,36.1) 20.58,36.07
  BOTTOM w0.097: UT1.A21 22.07,36.53 arc(22.19,36.41) 22.07,36.29 21.8,36.29 arc(21.71,36.27) 21.64,36.23 arc(21.52,36.14) 21.38,36.12 21.28,36.12 arc(21.12,36.05) 21.05,35.88 v2(21.05,35.85) ; v2(10.19,69.97) arc(10.12,70.14) 9.95,70.21 9.84,70.21 arc(9.7,70.18) 9.58,70.1 DT21.1 9.19,70.13 arc(9.11,70.19) 9,70.21 8.81,70.21 arc(8.7,70.19) 8.61,70.12 8.46,69.97 arc(8.39,69.87) 8.36,69.75 8.36,69.47 arc(8.31,69.22) 8.17,69.01 7.07,67.91 arc(6.86,67.77) 6.61,67.72 6.31,67.72 arc(6.03,67.64) JUSBC1.B10
TBT_USB3_RX0_P: length 48.4
  TOP w0.089: 20.58,36.29 arc(20.61,36.26) 20.65,36.24 20.67,36.24 20.67,36.23 20.71,36.21 arc(20.73,36.21) 20.75,36.2 20.82,36.2 arc(20.98,36.27) v2(21.05,36.44)
  TOP w0.097: v2(10.19,70.64) 10.33,70.5 arc(10.45,70.42) 10.58,70.4 12.59,70.4 arc(13.88,70.14) 14.97,69.41 16.92,67.46 arc(17.41,66.89) 17.8,66.25 17.8,66.25 arc(17.86,66.04) 17.87,65.82 17.87,64.84 arc(17.93,63.84) 18.09,62.85 arc(18.33,61.35) 18.41,59.83 18.47,57.86 arc(18.6,57.02) 18.86,56.21 arc(18.98,55.83) 19.02,55.45 19.07,53.23 arc(19.07,53.22) 19.07,53.22 19.06,52.84 19.07,46.4 arc(19.27,45.41) 19.83,44.57 19.83,44.57 arc(20.21,44) 20.35,43.32 20.35,36.71 arc(20.41,36.47) 20.58,36.29
  BOTTOM w0.097: UT1.B21 22.27,36.69 arc(22.2,36.74) 22.12,36.75 21.85,36.75 arc(21.8,36.75) 21.76,36.72 21.7,36.66 arc(21.68,36.62) 21.67,36.57 arc(21.66,36.52) 21.63,36.47 21.51,36.36 arc(21.45,36.32) 21.38,36.3 21.37,36.3 arc(21.2,36.34) v2(21.05,36.44) ; v2(10.19,70.64) arc(10.12,70.47) 9.95,70.4 9.78,70.4 arc(9.7,70.41) 9.62,70.46 DT20.1 9.18,70.47 arc(9.1,70.41) 9,70.39 8.81,70.39 arc(8.63,70.36) 8.48,70.26 8.32,70.1 arc(8.22,69.94) 8.18,69.75 8.18,69.47 arc(8.14,69.3) 8.04,69.15 6.94,68.04 arc(6.79,67.94) 6.61,67.91 6.31,67.91 arc(6.03,67.99) JUSBC1.B11
TBT_USB3_RX1_N: length 39.2
  TOP w0.097: JUSBC1.A10 8.45,64.06 arc(8.55,64.04) 8.62,63.99 8.64,63.97 arc(8.72,63.92) 8.81,63.9 9.73,63.9 arc(9.88,63.87) 10.01,63.79 10.07,63.73 arc(10.14,63.68) 10.22,63.67 10.86,63.67 arc(10.91,63.68) 10.95,63.7 DT18.1 arc(11.35,63.81) 11.56,63.77 12.94,63.77 arc(14,63.56) 14.89,62.96 16.44,61.41 arc(16.67,61.07) 16.74,60.68 16.74,56.84 arc(16.87,55.92) 17.22,55.07 arc(17.4,54.61) 17.47,54.12 17.47,40.22 arc(17.42,39.97) 17.27,39.76 arc(17.23,39.69) 17.21,39.61 17.21,38.81 arc(17.23,38.72) v2(17.28,38.64)
  BOTTOM w0.089: 20.58,39.42 20.59,39.42 20.6,39.42 20.65,39.42 20.65,39.42 21.3,39.42 arc(21.38,39.41) 21.44,39.36
  BOTTOM w0.097: 20.58,39.42 17.47,39.42 arc(17.24,39.37) 17.05,39.24 17.05,39.24 arc(17.01,39.19) 16.98,39.13 16.98,39.11 arc(17.01,38.95) 17.1,38.82 v2(17.28,38.64) ; UT1.B15 22.32,39.18 arc(22.19,39.09) 22.05,39.06 21.85,39.06 arc(21.71,39.09) 21.58,39.18 21.54,39.22 arc(21.53,39.23) 21.52,39.24 arc(21.5,39.31) 21.44,39.36
TBT_USB3_RX1_P: length 39.2
  TOP w0.097: JUSBC1.A11 8.45,63.56 arc(8.55,63.58) 8.62,63.63 8.64,63.65 arc(8.72,63.7) 8.81,63.72 9.73,63.72 arc(9.81,63.7) 9.88,63.65 9.94,63.6 arc(10.07,63.51) 10.22,63.48 10.8,63.48 arc(10.86,63.47) 10.91,63.44 DT19.1 arc(11.2,63.31) 11.26,63.43 arc(11.43,63.54) 11.62,63.58 12.94,63.58 arc(13.93,63.39) 14.76,62.83 16.31,61.28 arc(16.49,61) 16.56,60.68 16.56,56.84 arc(16.69,55.88) 17.06,54.98 arc(17.22,54.56) 17.28,54.12 17.28,40.22 arc(17.24,40.04) 17.14,39.89 arc(17.05,39.76) 17.02,39.61 17.02,39.25 arc(16.97,38.99) 16.82,38.77 v2(16.69,38.64)
  BOTTOM w0.089: 20.58,39.6 21.35,39.6 arc(21.4,39.6) 21.44,39.58
  BOTTOM w0.097: UT1.A15 22.01,39.29 arc(22.13,39.41) 22.01,39.53 21.58,39.53 arc(21.51,39.54) 21.44,39.58 ; 20.58,39.6 17.47,39.6 arc(17.17,39.54) 16.92,39.37 arc(16.85,39.28) 16.79,39.18 arc(16.77,39.09) 16.77,39 16.77,38.81 arc(16.75,38.72) v2(16.69,38.64)
