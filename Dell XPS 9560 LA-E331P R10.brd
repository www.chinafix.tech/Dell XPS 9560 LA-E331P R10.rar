# Allegro board Dell XPS 9560 LA-E331P R10.brd (continued)
## Nets (continued)
N128955562: PQ232.2 PR235.2
N128955571: PC202.2 PC203.2 PC204.2 PL202.1 PL203.1
N128955602: PQ206.1 PR206.2
N128955607: PQ216.2 PR220.2 PR229.1
N128955616: PQ216.1 PR227.1
N128955622: PQ204.2 PR202.2 PR206.1
N128955623: PQ219.3 PQ232.1
N128955625: PQ222.1 PR230.2
N128955629: PQ217.2 PR223.2 PR230.1
N128955637: PQ218.1 PR225.2
N128955643: PC221.2 PQ214.4 PR219.2 PR225.1
N128955656: PC214.2 PR259.1 PR261.2 PR263.1 PU202.5
N128955663: PR257.1 PR264.2 PU202.6
N128955690: PQ228.1 PR253.1
N128955696: PC215.2 PR258.1 PR260.2 PR273.1 PU202.3
N128955697: PR254.1 PR265.2 PU202.2
N128955727: PQ206.2 PR268.2
N128955733: PQ222.2 PR228.2
N128955736: PQ223.2 PR231.2
N128955741: PQ208.1 PR205.2
N128955744: PQ208.2 PQ211.1 PR213.2 PR217.1
N128955756: PC299.1 PQ225.1 PR271.1 PR272.1 PU203.4
N128955775: PQ218.2 PR290.2
N128955822: PQ223.1 PR229.2
N128955834: PC223.2 PQ221.2 PR275.2 PR276.1
N128955845: PQ231.2 PR277.2
N128955847: PQ231.1 PR276.2
N128955848: PQ224.2 PR278.2 PR279.1
N128955851: PQ233.1 PR279.2
N128955875: PD211.2 PQ220.2 PR234.2 PR282.2 PR283.2
N128955890: PR282.1 PU204.4
N128958040: PC709.2 PR705.1
N128958698: PC907.2 PR905.2 PR907.1 PU900.4
N128958708: PC900.1 PR902.1 PR986.2 PR987.2 PR988.2 PU900.1
N128958713: PC907.1 PC908.1 PC909.1 PC910.1 PC911.1 PJP900.1 PL901.2 PR905.1
N128958738: PC912.1 PU900.5
N128958750: PC905.1 PR904.2
N128967490: BAT100.5 PR106.1
N128967591: BAT100.6 PR108.1
N128967644: BAT100.7 PR111.1
N129647865: PQ700.2 PR725.2 PR728.2
N129647869: PQ700.1 PR724.2
N129673756: PR722.1 PR729.2 PR730.2
N129720076: QV86.1 RV511.1
N130300832: CV817.1 RV658.2 RV659.2 UZ24.1 UZ24.2
N130300854: CZ98.1 UZ24.6
N130402545: RV1072.1 RV1073.1 UV18.J1
N130469387: RV1077.1 UV18.E1
N130500830: QV21.2 QV21.5 RV1131.1 RV1132.1
N130673414: LV24.2 RV1078.1 RV1079.1
N130675629: QV91.3 RV1082.2
N130675694: QV91.2 RV1084.2
N130775721: RT430.2 UT4.E2
N130798734: QV91.1 RV1083.1
N130986130: RT437.1 UT4.D10
N131865475: PC755.1 PC756.1 PR755.2
N132121209: CV925.1 RV621.2 RV622.2
N132122697: CV928.1 RV626.2 RV627.2
N132123770: CV987.1 RV628.2 RV629.2
N132124417: CV990.1 RV637.2 RV638.2
N132190190: PR1800.1 PU1800.5
N132221893: RV1106.2 T209.1(TP-1)
N132908405: QZ14.5 QZ14.6 QZ18.2 RV103.2
N132908425: QZ14.3 RV1808.2
N132908471: QZ15.3 QZ16.5 RV1809.2
N132908541: QZ17.5 QZ17.6 RV111.2
N132908575: QZ16.3 RV1810.2
N132908582: QZ18.1 RV112.2
N132908588: QZ17.3 RV1811.2
N132951149: QZ6.6 RV8.2
N132951151: QZ6.2 QZ6.3 RV12.2
N132951302: QZ7.3 RV11.2
N132957909: CV1500.1 DA55.2 RV1522.1 RV1806.2
N132958139: RV1129.1 UV28.1
N132958145: CV918.1 RV1128.1 RV1807.2 UV28.4
N132961365: QV103.2 RV590.1
N133374229: QR104.1 RT1133.2
N133508832: JKB.3 RZ1138.2 RZ1139.2
N133541775: QV104.2 QV104.3 RV1140.2
N134346262: QV98.2 RV1112.2
N134700089: QI10.1 RI46.1
N1211736753: T91.1(TP-1) UH2.R44
N1211736754: T92.1(TP-1) UH2.R43
N1211736758: T94.1(TP-1) UH2.U42
N1257483751: QE2.4 QE19.4
N12017464511: T120.1(TP-1) UH2.AL42
N12017464512: T121.1(TP-1) UH2.AN42
N12017464513: T122.1(TP-1) UH2.AM43
N12017464514: T123.1(TP-1) UH2.AJ33
N12017464515: T124.1(TP-1) UH2.AH44
N12017464518: T127.1(TP-1) UH2.AJ42
N12117367569: T182.1(TP-1) UH2.AG35
N12117367571: T104.1(TP-1) UH2.AD35
N12117367572: T105.1(TP-1) UH2.AD31
N12117367573: T106.1(TP-1) UH2.AD38
N12117367574: T107.1(TP-1) UH2.AC43
N12117367575: T108.1(TP-1) UH2.AB44
N12449474450: T191.1(TP-1) UT4.B9
N12449474451: T192.1(TP-1) UT4.A9

Pads without a net: DE2 3; DL1 3; DV12 4 6; FD1 1; FD2 1; FD3 1; FD4 1; JAPS 16 17 18; JAUDIO 22 35 36 37 38; JDIMM1 87 88 91 92 95 97 100 101 104 105 134 162 165; JDIMM2 87 88 91 92 95 97 100 101 104 105 134 162 165; JEDP1 37; JHDD 1 2 3 16; JNGFF1 6 8 9 11 12 13 14 17 18 19 20 23 24 26 36 38 40 50 51 52 53 54 56 57 58 59 60 62 63 65; JNGFF2 6 8 10 20 22 24 26 28 30 32 34 36 40 42 44 46 48 56 58 59; JSPI1 4 19 20 21; PU203 3; PU300 4 13 14; PU500 2; PU700 5; PU800 2; PU1200 4 9 10 13; PU1201 4 9 10 13; PU1202 4 9 10 13; PU1300 4 9 10 13; PU1301 4 9 10 13; PU1400 5; PU1501 14 15 16 17; QV3 3 4 5; QZ7 1 2 6; QZ15 1 2 6; QZ16 1 2 6; RP19 3; RP24 6 7 8; SW1 2 3; UA1 2 4 8 47 48 49 50; UC1 1; UD2 1; UE1 2 5 6 7 10 11 12 15 25 26 30 31; UE3 B15 B62; UE4 7 10 15 16 29; UF1 2 3; UH1 A27 AD2 AD4 AE1 AE5 AE9 AE10 AE11 AF10 AF29 AF30 AF31 AF32 AF33 AF34 AG13 AG14 AG31 AG32 AG33 AG34 AG35 AG36 AH13 AH14 AH29 AH30 AH31 AH32 AH35 AH36 AJ10 AJ11 AJ13 AJ14 AK3 AL1 AL2 AL3 AM10 AM11 AT3 AT5 AT7 AT11 AT13 AU13 AW7 AW8 AW9 AW10 AW11 AW13 AY1 AY2 AY3 AY4 AY5 AY7 AY8 AY9 AY10 AY11 AY13 B27 B33 B34 B36 BA1 BA2 BA3 BA4 BA5 BJ17 BJ19 BJ20 BJ23 BJ26 BJ27 BJ35 BJ36 BK17 BK19 BK20 BK23 BK26 BK27 BL14 BL15 BL16 BL17 BL18 BL19 BL20 BL21 BL22 BL23 BL24 BL25 BL26 BL27 BL28 BL31 BM14 BM15 BM16 BM17 BM22 BM24 BM31 BN1 BN15 BN16 BN17 BP13 BP15 BP16 BP17 BR15 BR16 BT15 BT16 BT30 C33 C34 D34 E33 F33; UH2 A9 A14 A21 A23 AA44 AA45 AB13 AB33 AB35 AB36 AB39 AB41 AB42 AB43 AC2 AC3 AE17 AE45 AF2 AF3 AF17 AG8 AG10 AG14 AG15 AG44 AH43 AJ7 AJ8 AJ11 AJ13 AJ35 AJ43 AK44 AK45 AL7 AL8 AL27 AL35 AL43 AN17 AN24 AN29 AN36 AN43 AR15 AR17 AR19 AR22 AR27 AT43 AT44 AV4 AV43 AW35 B10 B13 B14 B15 B20 B21 B22 B23 B24 B36 BA4 BA35 BB17 BB36 BB38 BC8 BC18 BC22 BC35 BC36 BC38 BD1 BD18 BD23 BD34 BD35 BD38 BD39 BE2 BE5 BE6 BE34 BE39 C13 C14 C15 C20 C22 C23 C24 C36 D3 D13 D22 E11 E20 E22 E35 E45 F2 F45 G11 G13 G19 G22 G35 G37 G44 G45 H13 H40 H42 H43 H44 J45 K13 K15 K17 K19 K22 K24 K37 K44 L5 L7 L17 L19 L22 L24 L37 L39 L44 M45 N2 N3 N7 N8 N29 N31 N38 N39 N42 N43 N44 P1 P2 P3 P24 P27 P29 P31 P44 R2 R3 R4 R11 R13 R24 R27 R35 R36 R41 R42 T44 T45 U2 U3 U13 U36 U39 V1 V2 W2 W3 W7 W10 W11 W13 W39 Y5; UH8 9; UR1 31; UT1 A7 A9 A11 A13 A23 B7 B9 B11 B13 B23 D19 E18 E19 F22 F23 H22 H23 K22 K23 M22 M23 V18 W16 W19 Y16 Y19; UT4 G10; UV17 1; UV18 A9 A26 A27 A30 AB3 AB4 AB8 AC1 AC2 AC3 AC4 AC5 AC6 AC7 AC8 AC28 AC32 AD1 AD2 AD3 AD4 AD5 AD6 AE3 AE4 AF1 AF2 AF3 AF4 AF5 AF6 AF7 AF8 AF30 AF32 AG1 AG2 AG3 AG4 AG5 AG6 AG7 AG8 AG9 AG10 AH3 AH4 AH6 AH8 AH9 AH31 AJ1 AJ2 AJ3 AJ4 AJ5 AJ6 AJ8 AJ9 AJ11 AJ28 AJ31 AJ32 AJ33 AK1 AK2 AK3 AK4 AK5 AK6 AK8 AK9 AK31 AL3 AL4 AL6 AL7 AL8 AL9 AL10 AL11 AM1 AM2 AM3 AM4 AM5 AM6 AM7 AM8 AM9 AM34 AN2 AN3 AN5 AN6 AN8 AN9 AP3 AP5 AP6 AP8 AP9 B2 B6 B23 C6 C12 C15 C20 D6 D7 D9 D19 D20 D22 D23 D26 D28 E4 E26 E34 F2 F26 G14 G20 H30 H31 J30 J31 J32 J33 K3 K4 L2 M6 M30 M34 N4 N8 P2 P3 P8 R1 R28 R32 U3 V32; UV23 A5 U5; UV24 A5 U5; UV25 A5 U5; UV26 A5 U5; UZ8 3

## Via types
v1: diameter 0.305, hole 0.152, TOP to BOTTOM, 756 vias
v2: diameter 0.457, hole 0.203, TOP to BOTTOM, 8662 vias
v3: diameter 0.406, hole 0.203, TOP to BOTTOM, 427 vias
v4: diameter 0.432, hole 0.203, TOP to BOTTOM, 23 vias
v5: diameter 0.508, hole 0.254, TOP to BOTTOM, 117 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.2V_B+: length 21.1
  IN1 w0.254: v2(277.75,32.08) 278,32.08 278.89,32.97 282.32,32.97 283.02,32.27 286.58,32.27 287.02,32.71 291.72,32.71 292.93,31.5 292.93,28.05 v2(293.16,27.82)
  BOTTOM w0.254: v2(293.16,27.82) 293.16,27.59 PR605.1
  vias: v2(275.21,32.71) v2(275.21,32.08) v2(275.85,32.71) v2(275.85,32.08) v2(276.48,32.71) v2(276.48,32.08) v2(277.12,32.71) v2(277.12,32.08) v2(277.75,32.71) v3(274.09,32.39)
1.2V_FB: length 5.4
  TOP w0.14: v3(290.55,31.94) 290.55,31.47 v2(291.02,31)
  TOP w0.254: v2(291.02,31) 291.21,31.19 PR604.1
  BOTTOM w0.203: PU600.6 290.46,30.44 v2(291.02,31) 291.21,31.19 PR604.1 PR607.1
1V8_3V3_MAIN_EN: length 165.2
  TOP w0.254: RV1119.2 208.12,47.51 RV562.1 207.96,47.89 v2(207.13,48.72) 206.35,49.5 RV1099.2
  TOP w0.381: DA56.2 164.05,112.62 164.34,112.91 v2(164.34,113.74) ; v2(224.97,46.41) 224.97,46.21 224.7,45.94 QV104.5 ; DV16.2 245.35,43.08 245.56,42.87 246.04,42.87 v2(246.95,43.79) 246.95,43.73 v1(247.31,43.37) 247.35,43.4 RZ106.1
  TOP w0.508: v2(164.34,113.74) 164.05,114.03 RV1130.2
  IN3 w0.381: v2(184.16,67.53) 184.16,65.79 184.81,65.15 186.49,65.15 187.55,64.08 187.55,62.87 190.17,60.26 v2(194.22,60.26)
  IN6 w0.381: v2(164.34,113.74) 164.34,114.91 165.2,115.78 168.45,115.78 170.13,114.09 170.13,113.38 172.66,110.85 176.47,110.85 177.05,110.27 177.05,109.79 177.38,109.46 177.38,108.73 178.36,107.76 178.36,93 181.79,89.57 181.79,86.13 181.43,85.77 181.43,81.06 182.2,80.3 182.2,71.81 184.16,69.85 v2(184.16,67.53) ; v2(246.95,43.79) 246.66,44.08 244.41,44.08 243.61,44.88 239.61,44.88 238.56,43.82 236.53,43.82 234.77,45.58 233.87,45.58 232.92,46.53 229.86,46.53 229.5,46.17 226.38,46.17 225.94,45.73 225.3,45.73 224.97,46.06 v2(224.97,46.41) 224.97,46.55 224.63,46.9 222.35,46.9 222.09,46.63 220.23,46.63 219.75,46.15 219.06,46.15 218.63,46.58 213.68,46.58 213.18,47.08 209.44,47.08 208.99,47.52 207.72,47.52 207.13,48.11 v2(207.13,48.72) 207.13,48.73 207.73,49.33 207.73,49.87 207.4,50.19 206.72,50.19 205.98,49.45 205.23,49.45 201.69,45.91 196.34,45.91 195.39,46.86 195.39,56.61 195.82,57.04 195.82,59.56 195.38,60 194.48,60 v2(194.22,60.26)
  BOTTOM w0.508: PR1004.2 164.26,113.81 v2(164.34,113.74)
1V8_3V3_MAIN_RUN_EN: length 54.7
  TOP w0.127: v1(247.21,41.37) 246.78,41.79 DV16.1
  TOP w0.254: UZ24.3 207.31,49.36 v2(207.14,49.53) ; DV16.1 247.2,42.85 v2(247.49,42.85) 248.58,42.85 RZ106.2 249.95,42.59 QZ17.2
  IN6 w0.254: v2(247.49,42.85) 245.02,42.85 243.42,44.45 239.97,44.45 238.9,43.38 236.37,43.38 234.66,45.09 233.68,45.09 232.68,46.1 230.19,46.1 229.85,45.75 226.56,45.75 226.11,45.31 222.86,45.31 222.45,44.9 219.15,44.9 217.91,46.14 214.37,46.14 213.84,45.61 207.71,45.61 206.63,46.69 206.63,49.02 v2(207.14,49.53)
1V8_EN_LS3V3: length 126.6
  TOP w0.14: v2(176.23,110.14) 176.23,109.57 v1(176.07,109.42)
  TOP w0.356: DA55.1 246.26,43.89 v2(245.87,43.51)
  TOP w0.406: RV108.2 224.52,46.8 224.31,46.58 v2(224.31,46.34) 224.05,46.08 QV104.6
  TOP w0.508: v2(176.23,110.14) 176.4,110.32 RV1129.2
  IN1 w0.508: v2(224.31,46.34) 224.31,46.62 224.72,47.02 226.29,47.02 227.22,46.09 228.37,46.09 228.96,45.5 231.31,45.5 232.12,44.69 234.95,44.69 235.39,44.24 243.24,44.24 243.98,43.51 v2(245.87,43.51)
  IN4 w0.381: v2(176.23,110.14) 176.77,110.14 178.32,108.59 178.32,92.76 179.52,91.56 179.52,89.23 180.42,88.32 180.9,88.32 182.22,87 183.59,87 185.5,85.1 185.5,81.3 185.88,80.92 188.04,80.92 189.57,79.38 189.57,71.05 192.93,67.7 192.93,59.79 193.99,58.72 196,58.72 202.12,52.6 203.01,52.6 204.89,50.72 215.08,50.72 215.51,51.15 220.69,51.15 221.12,50.72 223.1,50.72 224.31,49.51 v2(224.31,46.34)
1VS_GFX_PG: length 138.7
  TOP w0.14: UV20.1 196.84,42.87 197.74,41.97 205.25,41.97 v1(205.59,42.31) 209.94,42.31 211.01,43.37 v2(211.01,44.14) DV13.2
  TOP w0.254: PR908.1 241.8,110.12 v2(241.8,109.93)
  IN6 w0.099: v2(211.01,44.14) 211.01,43.77 211.25,43.52 212.82,43.52 213.14,43.85 216.22,43.85 216.43,43.63 232.17,43.63 233.39,42.41 244.35,42.41 245.73,41.03 253.87,41.03 254.48,41.64 254.48,50.24 253.37,51.36 253.37,53.67 252.22,54.81 252.22,59.51 251.65,60.08 251.65,95.64 250.52,96.77 250.52,97.74 248.81,99.45 247.15,99.45 245.31,101.29 245.31,102.2 241.9,105.61 241.9,109.83 v2(241.8,109.93)
1VSP_PG: length 5.9
  TOP w0.14: v1(239.78,112.96) 239.78,112.47 240.13,112.12 v2(241.01,112.12)
  TOP w0.254: v2(241.01,112.12) 241.01,111.82 PR908.2
  BOTTOM w0.254: PR908.2 241.01,111.82 v2(241.01,112.12) 240,112.12 239.65,112.47 239.65,112.78 239.8,112.94 PU900.2
3.3V_CAM_EN#: length 381.8
  TOP w0.14: v2(46.61,23.57) 44.26,23.57 43.44,24.39 42.8,24.39 42.17,23.76 41.24,23.76 39.62,25.39 QZ9.2
  IN1 w0.099: v2(316.8,8.77) 317.25,9.22 317.25,11.12 314.71,13.65 314.71,16.5 325.17,26.96 327.67,26.96 331.81,31.1 339.19,31.1 341.57,33.47 343.09,33.47 344.23,34.62 344.23,36.14 346.65,38.55 346.65,40.32 347.17,40.84 v2(347.17,45.4)
  IN2 w0.089: 75.06,1.41 82.93,1.41 83.38,1.85 84.08,1.85 84.33,2.1 84.33,2.8 84.58,3.05 86.39,3.05 86.83,3.49 87.22,3.49 87.44,3.27 87.44,2.46 87.85,2.05 89.81,2.05 90.27,1.59 90.61,1.59 90.87,1.85 90.87,2.68 91.07,2.88 92.25,2.88 92.67,3.29 93.2,3.29 93.2,3.29 v2(93.2,3.29)
  IN2 w0.099: 75.06,1.41 74.47,1.41 73.9,1.98 73.13,1.98 72.43,1.28 66.34,1.28 65.36,2.27 58.83,2.27 58.69,2.41 58.17,2.41 56.83,3.75 56.83,4.27 55.43,5.67 55.43,8.18 54.27,9.34 54.27,11.13 56.23,13.09 56.23,14.93 56.64,15.35 56.64,18.39 55.66,19.38 54.91,19.38 51.86,22.43 47.75,22.43 v2(46.61,23.57)
  IN5 w0.089: 101.98,3.84 100.13,3.84 97.88,1.58 93.1,1.58 92.73,1.96 92.73,2.82 v2(93.2,3.29)
  IN5 w0.099: 101.98,3.84 104.81,3.84 106.54,2.1 109.22,2.1 109.59,1.74 116.34,1.74 121.96,7.36 135.91,7.36 136.33,6.94 137.68,6.94 138.46,7.72 144.77,7.72 147.47,5.01 159.29,5.01 159.54,4.76 165.23,4.76 165.89,4.1 168.49,4.1 169.67,2.92 180.25,2.92 182.59,5.27 200.52,5.27 203.34,8.09 205.81,8.09 206.45,8.73 210.34,8.73 211.43,7.64 218.7,7.64 218.91,7.86 226.34,7.86 227.63,6.57 234.85,6.57 236.06,7.77 252.26,7.77 253.2,8.71 261.71,8.71 262.89,7.54 274.25,7.54 276.03,5.76 281.81,5.76 282.69,4.87 285.12,4.87 285.27,4.72 285.34,4.72 285.59,4.47 290.86,4.47 291.09,4.7 295.54,4.7 295.54,4.71 297.37,4.71 297.6,4.47 300.76,4.47 301.08,4.15 306.12,4.15 308.15,6.18 309.97,6.18 312.09,8.3 316.33,8.3 v2(316.8,8.77)
  BOTTOM w0.089: UH2.BD14 93.16,4.44 93.35,4.25 93.35,3.44 v2(93.2,3.29)
  BOTTOM w0.14: RZ38.1 346.03,45.19 346.96,45.19 v2(347.17,45.4) 347.18,45.41 347.59,45.41 v3(347.82,45.64)
3.3V_MSATA_EN: length 31.6
  TOP w0.089: v1(85.94,3.03) 86.36,2.62 86.36,2.31 v2(86.41,2.26)
  TOP w0.14: v2(62.24,3.43) 62.17,3.5 RH423.1
  IN5 w0.089: 75.06,3.04 75.9,2.2 81.7,2.2 82.86,3.36 85.29,3.36 86.31,2.34 86.34,2.34 v2(86.41,2.26)
  IN5 w0.099: v2(62.24,3.43) 62.26,3.43 62.59,3.76 63.74,3.76 63.93,3.56 65.56,3.56 66.13,3 68.37,3 69.11,3.74 69.11,4 69.54,4.42 71.65,4.42 72.33,3.75 74.36,3.75 75.06,3.04
  BOTTOM w0.089: v2(86.41,2.26) 86.36,2.31 86.36,3.03 86.6,3.27 86.6,3.59 86.48,3.72 86.48,4.3 86.34,4.43 UH2.BD27
3.3V_TS_EN: length 305.4
  IN2 w0.089: 101.98,10.78 99.93,10.78 99.34,10.18 97.74,10.18 97.12,10.8 92.93,10.8 91.62,9.5 90.46,9.5 90.2,9.24 89.11,9.24 88.83,8.97 87.64,8.97 87.14,9.47 v2(84.9,9.47)
  IN2 w0.099: v2(344.81,44.71) 345.21,44.31 345.21,40.14 344.81,39.74 344.81,36.9 344.93,36.78 346.58,36.78 347.19,36.17 347.19,33.25 346.65,32.71 341.76,32.71 338.89,29.84 330.14,29.84 321.72,21.43 321.72,15.46 318.44,12.17 314.71,12.17 309.56,7.03 296.03,7.03 295.6,6.6 292.85,6.6 292.31,7.15 287.93,7.15 287.78,7.3 282.57,7.3 281.82,6.55 275.09,6.55 273.11,8.53 262.78,8.53 262.57,8.73 256.69,8.73 255.71,7.75 253.22,7.75 252.44,8.53 240.51,8.53 238.31,6.34 227.7,6.34 226.26,7.77 214.72,7.77 211.45,11.04 202.32,11.04 201.4,10.12 200.09,10.12 199.97,10 197.2,10 196.53,9.33 188.67,9.33 187.71,10.28 183.83,10.28 183.67,10.44 178.59,10.44 177.75,11.28 164,11.28 163.21,10.49 160.11,10.49 159.34,11.26 154.74,11.26 153.19,12.81 149.34,12.81 149.15,13 114.49,13 113.41,11.92 104.36,11.92 103.22,10.78 101.98,10.78
  BOTTOM w0.089: UH2.AR29 v2(84.9,9.47)
  BOTTOM w0.14: v1(346.13,46.9) 346.13,46.39 RZ39.1 345.58,45.61 344.81,44.84 v2(344.81,44.71) 344.6,44.5 344.57,44.5 344.34,44.27 UZ5.3
3V/5VALW_EN: length 14.2
  TOP w0.14: v3(349.39,25.92) 349.39,25.65 349.15,25.41 v2(348.93,25.41)
  TOP w0.254: PR408.1 346.08,24.9 346.56,25.38 PR326.2 348.02,25.38 PC335.1 v2(348.93,25.41)
  BOTTOM w0.254: PR409.2 347.68,18.06 346.33,19.4 346.33,21.9 347.16,22.73 347.16,24.58 347.98,25.41 v2(348.93,25.41)
5VS_FAN1: length 4.3
  TOP w0.14: v2(96.79,36.66) 96.18,36.66 v3(95.8,36.28)
  TOP w0.508: v2(96.79,36.66) 97.03,36.42 RE104.2
  BOTTOM w0.508: JFAN1.2 97.25,36.2 v2(96.79,36.66)
5VS_FAN2: length 5.8
  TOP w0.14: v3(323.51,41.63) 323.23,41.91 RE105.2
  TOP w0.508: v2(322.14,41.03) 322.2,41.09 RE105.2
  BOTTOM w0.508: v2(322.14,41.03) 323.91,41.03 324.5,40.44 JFAN2.2
+0.6VS: length 131.2
  TOP w1.524: 256.8,14.93 258.13,13.6 259.53,13.6 260.41,12.71 260.41,9.91 257.82,7.32 257.82,4.25 258.69,3.37 262.19,3.37 265.23,6.42 265.23,8.53 265.05,8.72 265.05,11.06 266.37,12.38 266.37,13.99 268.77,16.39 269.5,16.39 275.49,22.39 277.87,22.39 278.82,23.34 280.96,23.34 283.52,25.89
  IN4 w1.524: 249.62,15.06 249.02,14.46 244.26,14.46 243.49,15.24 223.3,15.24 222.58,14.51 221.02,14.51 220.03,15.5 177.51,15.5 176.44,16.57
  BOTTOM w0.305: v2(173.91,16.86) 173.91,16.98 173.63,17.27 JDIMM1.258 ; v2(249.57,16.8) 249.57,16.93 249.65,17.01 249.65,17.01 249.93,17.28 JDIMM2.258
  vias: v2(174.57,16.87) v2(175.15,16.87) v2(250.16,16.78) v2(250.16,16.2) v3(175.24,16.19)
+0.6VSP: length 2.9
  TOP w0.508: v2(287.66,32.01) 287.66,31.38 287.08,30.81 286.64,30.81
  BOTTOM w0.203: PU600.2 287.87,31.68 287.66,31.89 v2(287.66,32.01)
  vias: v2(285.41,30.81) v2(286.01,30.81) v3(286.06,30.16)
+0.95VSP: length 99
  TOP w0.254: PC807.1 106.17,65.54 105.86,65.86 v2(105.86,66.05) ; PR813.1 171.82,72.46 v2(172.3,72.94)
  IN1 w0.254: v2(115.57,61.54) 116.37,60.74 116.37,57.1 114.58,55.32 104.78,55.32 103.76,56.33 103.76,64.78 104.46,65.48 105.52,65.48 105.86,65.82 v2(105.86,66.05)
  IN2 w0.508: v2(130.39,67.73) 130.39,67.56 129.09,66.25 124.42,66.25 123.52,65.35 120.14,65.35 117.6,62.81 v2(116.21,62.81)
  IN6 w0.508: v2(130.39,67.73) 130.84,68.18 130.84,69.47 132.42,71.05 136.97,71.05 138.14,72.22 141.45,72.22 143.66,74.43 143.66,77.31 144.96,78.61 155.62,78.61 157.1,77.14 166.21,77.14 170.64,72.7 172.06,72.7 v2(172.3,72.94)
  vias: v2(115.57,62.81) v2(115.57,62.18) v2(116.21,62.18) v3(117.26,62.44)
+1.0V_+1.8V_PLLVDD: length 50.1
  TOP w0.508: RV575.2 203.33,60.97 v2(204.15,60.14) ; v2(199.2,60.1) v1(198.03,61.26) 197.35,61.95 RV576.2 197.33,62.76 RV582.2 ; v2(212.61,81.86) 212.71,81.76 RV574.2
  IN1 w0.508: v2(204.15,60.14) 203.63,60.67 199.78,60.67 v2(199.2,60.1)
  IN2 w0.508: v2(201.93,67.26) 202.38,67.7 202.38,77.16 202.82,77.61 202.82,78.49 ; 194.57,79.76 191.05,83.28 191.05,84.29 191.27,84.51 191.27,93.56 192.34,94.63
  IN4 w0.508: v2(201.93,67.26) 201.91,67.23 201.91,65.56 202.44,65.03 203.58,65.03 204.79,63.83 204.79,61.51 204.15,60.88 v2(204.15,60.14)
  vias: v2(192.9,95.2) v2(193.51,95.2)
+1.2V_DDR: length 170.9
  TOP w0.381: CH197.1 121.4,53.21 UC1.5
  TOP w0.508: v2(145.1,16.86) 145.52,17.28 CD70.1 ; 127.23,52.41 127.09,52.27 v2(122.66,52.27) 122.12,52.27 121.37,53.01 CH197.1 ; v2(149.54,16.87) 149.14,17.28 CD71.1
  IN2 w0.508: v2(110.17,16.66) 110.17,17.03 110.86,17.71 119.56,17.71 120.42,16.85 v2(120.42,16.68) ; v2(122.66,52.27) 124.07,53.68 124.07,63.51 126.14,65.58 129.42,65.58 130.01,66.18 v2(132.84,66.18)
  IN4 w0.508: v2(120.42,16.68) 120.42,16.86 121.48,17.92 130.43,17.92 131.13,17.22 v2(131.13,16.9)
  BOTTOM w0.203: UH1.AJ12 156.96,66.9 v2(156.68,66.61) 156.31,66.25 UH1.AL11 ; UH1.AY6 149.37,62.65 v2(149.42,62.65) 149.77,62.99 UH1.AW6 ; UH1.L6 171.66,62.99 171.85,63.18 172.3,63.18 UH1.K6 ; UH1.AF5 159.79,62.34 v2(159.48,62.65) ; v2(159.48,62.65) 159.58,62.65 UH1.AF6 ; v2(159.48,62.65) 159.17,62.34 UH1.AG5 ; UH1.AG9 v2(159.42,65.4)
  BOTTOM w0.254: UH1.AE12 160.68,66.9 v2(160.39,67.19) ; v2(151.94,62.62) 152.01,62.62 UH1.AR6 UH1.AP6 153.48,63.25 UH1.AP7 ; UH1.AT12 151.78,66.9 v2(152.1,66.57) 152.43,66.9 UH1.AR12 ; UH1.K6 UH1.J6 173.4,62.99 v2(173.73,62.65) 173.42,62.34 UH1.J5 ; v2(173.01,66.59) 172.91,66.59 UH1.K12 172.4,67.1 171.96,67.1 UH1.L12 ; v2(167.02,62.66) 167.35,62.99 UH1.T6 ; UH1.W6 164.88,62.99 v2(164.5,62.6) 164.11,62.98 UH1.AA6
  BOTTOM w0.305: v2(210.6,29.21) 210.8,29.21 211.18,28.83 JDIMM2.111 ; v2(224.16,16.87) 223.93,17.11 JDIMM2.154 ; JDIMM1.148 146.12,17.29 145.69,16.86 v2(145.1,16.86) ; JDIMM1.54 120.62,16.88 v2(120.42,16.68) ; JDIMM1.112 135.12,17.12 v2(135.35,16.9) ; UH1.R6 UH1.T6 ; v2(230.31,19.8) 229.93,19.41 JDIMM2.178 ; JDIMM2.123 214.18,27.22 214.52,27.56 214.52,27.95 214.1,28.37 v2(214.06,28.37) ; v2(136.78,28.44) 136.6,28.44 136.25,28.09 136.25,27.44 136.39,27.3 136.39,26.37 JDIMM1.117 ; JDIMM2.199 235.18,27.55 v2(235.6,27.97) ; JDIMM2.220 240.42,17.01 240.35,16.93 v2(240.35,16.87) ; v2(150.5,27.67) 149.93,27.67 149.87,27.61 ; v2(191.16,28.26) 191.41,28.26 191.74,27.93 191.74,27.37 191.68,27.3 JDIMM2.33 ; v2(110.17,16.66) 110.17,16.83 110.13,16.88 JDIMM1.12 ; JDIMM1.130 v2(139.63,16.9) ; JDIMM2.148 222.43,17.29 221.99,16.86 v2(221.36,16.86) ; v2(214.44,16.86) 214.43,16.88 JDIMM2.124 ; JDIMM2.117 212.67,27.32 212.55,27.44 212.55,28.06 212.93,28.44 v2(213.11,28.44) ; v2(114.86,28.21) 115.16,28.21 115.44,27.93 115.44,27.45 115.37,27.38 JDIMM1.33 ; v2(186.64,16.87) 186.64,16.88 186.43,17.09 JDIMM2.12 ; JDIMM2.160 225.42,17.27 225.84,16.86 v2(225.84,16.86) ; v2(159.72,28.24) 159.55,28.24 158.89,27.58 JDIMM1.199 ; JDIMM2.54 196.92,16.92 v2(196.98,16.87) ; JDIMM2.75 202.18,27.51 v2(202.02,27.67) ; JDIMM1.147 145.87,27.46 146.11,27.7 v2(146.56,27.7) 147,27.7 147.37,27.33 JDIMM1.153 ; v2(131.13,16.9) 131.12,16.9 JDIMM1.96 ; JDIMM2.163 226.18,27.49 226.33,27.65 v2(226.69,27.65) ; v2(125.71,27.69) 125.88,27.52 JDIMM1.75 ; v2(142.86,28.3) 142.72,28.3 142.3,27.88 142.3,27.43 142.37,27.37 JDIMM1.141 ; JDIMM2.129 215.67,27.39 215.62,27.44 215.62,28.07 215.95,28.4 v2(216.23,28.4) 216.44,28.4 217.18,27.66 JDIMM2.135 ; JDIMM2.118 212.92,16.87 v2(212.94,16.86) ; v2(219.16,28.24) 218.97,28.24 218.6,27.87 218.6,27.43 218.67,27.37 JDIMM2.141 ; v2(138.12,16.9) JDIMM1.124 ; v2(142.63,16.88) JDIMM1.142 ; v2(211.65,16.86) 211.43,17.08 JDIMM2.112 ; JDIMM2.159 225.18,27.49 v2(225.02,27.64) ; JDIMM2.142 218.93,16.98 v2(219.04,16.86) ; v2(207.46,16.86) 207.44,16.87 JDIMM2.96 ; v2(163.87,16.86) 163.87,16.99 164.12,17.24 JDIMM1.220 ; v2(169.48,27.75) 169.37,27.64 JDIMM1.241 ; v2(215.93,16.86) JDIMM2.130 ; v2(147.84,16.9) 147.63,17.11 JDIMM1.154 ; v2(245.29,27.68) 245.67,27.3 JDIMM2.241 ; JDIMM1.123 137.88,27.75 v2(138.08,27.95) ; JDIMM1.160 149.12,17.29 v2(149.54,16.87) ; v2(153.1,16.89) 153.26,16.89 153.63,17.25 JDIMM1.178 ; 149.87,27.61 JDIMM1.163 ; 149.87,27.61 149.87,27.61 149.12,27.61 148.87,27.36 JDIMM1.159 ; v2(217.43,16.86) 217.43,18.15 ; JDIMM1.111 v2(134.88,29.64) ; JDIMM1.129 139.37,27.39 139.32,27.44 139.32,28.6 v2(139.88,29.16) 140.88,28.16 JDIMM1.135 ; v2(141.14,19.43) 141.12,19.42 JDIMM1.136 ; JDIMM2.153 223.67,27.33 223.39,27.61 v2(222.72,27.61) 222.59,27.61 222.18,27.2 JDIMM2.147 ; JDIMM1.118 v2(136.62,16.9)
  vias: v2(254.92,23.63) v2(254.92,23) v2(255.55,23.63) v2(255.55,23) v2(256.22,23.62) v2(256.22,22.98) v2(256.86,23.62) v2(256.86,22.98) v2(257.49,23.62) v2(257.49,22.98) v3(158.34,34.2)
+1.2V_MEN_P: length 64.3
  TOP w0.254: PR604.2 v2(291.19,32.1)
  IN1 w0.254: v2(291.19,32.1) 290.51,31.43 290.51,30.31 288.59,28.39 286.88,28.39 286.33,27.85 286.3,27.85 285.26,26.81 281.04,26.81 279.63,25.4 278.11,25.4 277.64,24.93 269.46,24.93 267.7,26.68 258.89,26.68 v2(258.83,26.62)
  IN1 w1.016: 282.45,30.54 282.45,29.19 280.73,27.48 278.64,27.48 276.86,25.7 269.91,25.7 268.2,27.42 264.12,27.42 263.02,28.52
  BOTTOM w0.203: PR604.2 v2(291.19,32.1) 289.46,32.1 289.07,31.71 PU600.5
  vias: v2(262.32,29.35) v2(262.95,29.35) v2(282.13,31.44) v2(282.78,31.44)
+1.2V_PWROK: length 3.9
  TOP w0.102: PR609.2 v1(291.01,25.76)
  TOP w0.254: v2(290.39,28.01) 291.01,27.39 PR609.2
  BOTTOM w0.203: v2(290.39,28.01) 290.39,28.65 290.2,28.84 PU600.10
+1.2V_VCCPLL_OC: length 21.8
  TOP w0.089: v2(142.96,67.25) 143.18,67.25 v3(143.45,67.52)
  TOP w0.508: v2(173.85,66.02) 174.06,66.23 CZ49.1 ; RH530.1 v2(165.85,66.65) ; v2(131.57,65.16) 131.13,65.6 RZ67.2
  IN1 w0.508: v2(131.57,65.16) 131.57,68.02 132.11,68.55 133.94,68.55 134.51,67.98 138.54,67.98 140.14,69.57 141.26,69.57 141.61,69.21 141.61,68 142.37,67.25 v2(142.96,67.25)
  BOTTOM w0.203: UH1.BH13 142.83,67.25 v2(142.96,67.25)
  BOTTOM w0.229: v2(173.85,66.02) 174.18,66.35 UH1.G11
+1.8V_3.3V_GFX_AON: length 314.2
  TOP w0.381: CV917.1 175.02,113.24 175.64,113.24 175.88,113.48 UV28.5
  TOP w0.508: CV794.1 CV363.1 ; CV794.1 CV796.1 CV798.1 242.08,106.84 PR988.1 ; CV794.1 243.41,104.45 243.63,104.24 RV511.2 244.69,104.77 244.69,106.36 245.81,107.48 ; CV917.1 174.66,113.45 174.11,114 v2(174.11,114.03) ; v2(245.37,46.11) RV1112.1 ; RV11.1 v2(253.56,41.79) ; v2(201.74,64.34) 201.77,64.34 202.71,65.27 RV1074.2 ; PR725.1 200.22,108.71 v2(200.22,109.74) ; PR1500.1 178.25,112.4 v2(178.5,112.66)
  TOP w0.762: 195.68,58.38 194.46,58.38 192.96,59.88 192.96,62.58 193.82,63.43 195.63,63.43 RV1056.2
  IN1 w0.508: v2(215.2,54.56) 216.73,56.09 216.73,58.23 216.03,58.94 216.03,60.73 v2(215.84,60.92) ; v2(215.2,54.56) 217.68,54.56 218.31,53.92 220.16,53.92 221.46,52.62 221.46,50.35 v2(223.46,48.34) ; v2(215.2,54.56) 215.2,53.73 215.77,53.16 215.77,52.65 214.61,51.49 214.61,48.73 v2(215.02,48.32) ; v2(253.68,47.65) 253.68,51.96 253.2,52.45 253.2,53.91 251.88,55.23 251.88,59.45 251.53,59.8 251.53,93.83 250.3,95.06 250.3,96.71 249.56,97.46 ; v2(199.67,55.82) 195.9,59.6 195.9,61.41 196.64,62.15 198.63,62.15 198.89,61.89 200.46,61.89 201.74,63.17 v2(201.74,64.34) ; v2(178.5,112.66) 177.86,112.66 177.28,112.07 176.53,112.07 176.13,112.47 175.32,112.47 174.11,113.69 v2(174.11,114.03)
  IN1 w0.762: 248.49,98.88 248.49,104.81 246.29,107.01 246.29,107.53
  IN2 w0.508: v2(200.22,109.74) 200.09,109.61 199.01,109.61 194.79,113.83 194.79,117.48 194.31,117.97 187.87,117.97 186.75,116.85 186.75,114.31 185.61,113.17 182.72,113.17 182.21,113.67 179.12,113.67 178.5,113.05 v2(178.5,112.66) ; v2(199.67,55.82) 199.67,55.14 202.58,52.23 203.37,52.23 205.11,50.49 205.11,49.74 206.02,48.83 v2(206.11,48.83)
  IN5 w0.102: 213.75,61.13 213.75,60.6
  IN5 w0.762: 243.4,110.65 242.96,111.08 240.91,111.08 240.23,111.76 239.46,111.76 239.24,111.54 229.42,111.54 229.4,111.56 227.56,111.56 226.57,112.56 222.42,112.56 221.48,111.62 220.23,111.62 219.36,110.75 211.61,110.75 210.74,111.62 204.83,111.62 201.42,108.21 200.69,108.21 200.22,108.68 v2(200.22,109.74)
  IN6 w0.508: v2(163.2,117.42) 164.29,116.32 168.67,116.32 169.4,115.59 170.89,115.59 172.14,114.35 172.14,112.94 173.67,111.4 177.24,111.4 v2(178.5,112.66)
  BOTTOM w0.508: 249.76,98 251.46,96.3 251.46,78.18 250.83,77.54 245.89,77.54 243.79,75.45 243.79,71.65 245.97,69.47 250.74,69.47 251.37,68.83 251.37,55.03 252.12,54.28 252.12,51.48 252.06,51.42 252.06,47.52 252.93,46.64 v2(253.12,46.64) ; v2(163.2,117.42) 163.2,116.98 163.77,116.4 PR1000.1
  vias: v2(197.55,46.49) v2(199.52,53.48) v2(214.34,64.65) v2(215,64.64) v2(215.01,60.93) v2(231.08,48.33) v2(243.13,109.93) v2(243.71,109.91) v2(245.45,108.62) v2(245.85,108.16) v2(247,97.85) v2(247.59,97.85) v2(248.2,97.85) v2(248.82,97.85) v2(253.14,47.35) v2(253.68,46.99) v3(231.79,49.37)
+1.8V_3.3V_GFX_RUN: length 51.1
  TOP w0.508: v2(232.39,45.52) v3(232.86,45.98) RV1081.1 ; RV1811.1 247.82,41.84 v2(247.51,41.84)
  IN3 w0.508: v2(247.51,41.84) 245.77,40.1 238.74,40.1 236.28,42.55 235.36,42.55 v2(232.39,45.52) 228.3,49.62 223.38,49.62 219.98,53.02 219.13,53.02 218.38,53.77 214.99,53.77 214.03,52.82 211.8,52.82 v2(211.39,53.22)
  BOTTOM w0.305: UV18.L8 213.33,63.39 v2(213.32,63.39) 212.94,63.77 UV18.M8
  vias: v2(194.88,95.13) v2(195.39,95.58) v2(201.11,65.03)
+1.8VS: length 0.9
  BOTTOM w0.14: 6.49,14.73 6.69,14.73 v1(7.19,14.23)
+1.8VS_AUDIO: length 19.6
  TOP w0.14: v3(4.41,29.69) 3.71,30.39 3.2,30.39
  TOP w0.508: v2(3.27,29.75) 3.27,30.32 RA2.1
  IN6 w0.508: v2(3.27,29.75) 3.85,29.75 4.38,29.22 4.38,28.62 5.04,27.97 5.04,27.8 7.88,24.96 7.88,22.31 6.02,20.46 5.14,20.46 4.45,19.76 4.45,18.55 4.03,18.13 v2(3.62,18.13)
  BOTTOM w0.508: RA78.1 v2(3.62,18.13)
+1.8VSP: length 13.5
  BOTTOM w0.254: 247.27,99.96 244.92,99.96 243.74,101.14 243.74,101.94 242.51,103.17 242.51,105.56 242.96,106.02 242.96,106.62 242.48,107.11 242.48,108.16 242.66,108.34 PR1402.1 PC1401.1
  vias: v1(249.48,101.81) v2(247.4,102.24) v2(247.4,101.55) v2(247.4,100.96)
+1.8VSP_ON: length 4.9
  BOTTOM w0.14: 245,103.91 245,104.1 244.35,104.75 v1(243.99,104.75)
  BOTTOM w0.254: PU1400.7 245.67,104.59 245,103.91 PR1403.2 PR1404.1 PC1406.1
+1.35V_RUN_B+:
  vias: v1(189.33,114.31) v2(188.15,114.94) v2(188.15,114.31) v2(188.15,113.7) v2(188.79,114.31) v2(188.79,113.7)
+1.35V_VSNS: length 22.4
  TOP w0.305: PR729.1 v2(192.28,119.58)
  TOP w0.508: PC756.2 201.92,117.94 201.93,117.93
  IN5 w0.305: v2(210.29,118.02) 209.73,118.58 209.73,119.2 209.6,119.33 197.22,119.33 196.86,118.97 192.89,118.97 v2(192.28,119.58)
  vias: v1(207.86,119.87) v2(202.5,117.29) v2(202.5,116.66) v2(202.5,116.02) v2(202.5,115.39) v2(202.5,114.75) v2(202.5,114.12) v2(203.14,117.29) v2(203.14,116.66) v2(203.14,116.02) v2(203.14,115.39) v2(203.14,114.75) v2(203.14,114.12) v2(204.09,118.82) v2(204.09,118.18) v2(204.73,118.82) v2(204.73,118.18) v2(205.36,118.82) v2(205.36,118.18) v2(206,118.82) v2(206,118.18) v2(206.8,118.06) v2(207.27,118.82) v2(207.27,116.4) v2(207.43,118.06) v2(207.9,118.82) v2(207.9,116.4) v2(208.45,118.06) v2(208.54,118.82) v2(208.6,116.4) v2(209.08,118.06) v2(209.17,118.82) v2(209.23,116.4) v2(209.87,116.4) v2(210.31,118.82) v2(210.5,116.4) v2(210.95,118.82) v2(210.92,118.02) v2(211.14,116.4) v2(211.58,118.82) v2(211.77,116.4) v2(212.08,117.86) v2(212.22,118.82) v2(212.41,116.4) v2(213.04,119.13) v2(212.98,118.06) v2(212.98,117.46) v2(212.98,116.85) v2(213.36,118.59) v2(213.62,118.06) v2(213.62,117.46) v2(213.68,119.13) v2(214,118.59) v2(214.25,118.06) v2(214.31,119.13) v2(214.63,118.59) v2(214.95,119.13) v2(214.89,118.06) v2(215.27,118.59) v2(215.52,118.06) v2(215.58,119.13) v2(215.9,118.59) v2(216.22,119.13) v2(216.16,118.06) v2(216.54,118.59) v2(216.79,118.06) v2(216.85,119.13) v2(217.17,118.59) v2(217.43,118.06) v2(217.49,119.13)
+1.35VSDGPU: length 318.6
  TOP w0.102: 216.66,69.29 216.79,69.29 CV885.1 ; v2(225.3,61.6) v3(226,61.6)
  TOP w0.254: v2(246.12,62.33) 245.57,61.78 CV1010.1 245.94,61.41 246.11,61.24 CV1000.1 246.51,61.96 246.64,62.09 246.64,62.49 246.41,62.72 CV1044.1 ; v2(244.12,58.5) 244.21,58.5 244.87,57.84 CV1041.1 ; v2(236.92,56.1) 237.05,55.97 CV1017.1 ; v2(245.72,57.7) 245,56.98 CV1047.1 ; CV1018.1 243.97,65.76 244.38,66.17 244.38,66.28 v2(244.78,66.67) 244.78,67.44 CV1042.1 ; CV1009.1 CV1006.1 CV1005.1 248.81,63.3 v2(248.12,63.3) ; v2(238.52,56.1) 239.14,55.48 CV1012.1 CV1014.1 ; CV1017.1 CV1011.1 236.14,55.19 235.14,55.19 CV1001.1 ; CV1017.1 CV1016.1 ; CV1007.1 246,59.02 v2(246.52,58.5) ; v2(248.92,57.7) 249.02,57.6 CV1004.1 ; CV1015.1 248.85,64.04 v2(248.94,64.04) ; CV1045.1 240.98,56.04 v2(240.92,56.1)
  TOP w0.381: CV886.1 204.01,81.24 204.85,80.4 CV883.2 ; v2(222.31,80.15) 222.31,81.67 CV872.1 ; v2(214.12,84.34) 214.12,83.64 214.3,83.46 RV600.1 ; RV607.1 211.18,105.04 210.99,104.85 210.44,104.85 210,105.29 210,106.63 210.52,107.15 CV931.1 ; v2(245.08,78.84) 245.63,79.39 RV608.1
  TOP w0.508: v2(215.7,65.29) 215.58,65.4 CV884.2 ; CV1003.1 CV1002.1 248.1,66.87 v2(248.32,66.65) ; CV994.1 238.86,90.36 239.32,89.9 v2(239.32,89.84) ; CV994.1 238.01,90.56 CV997.1 ; CV994.1 238.86,92.31 238.58,92.59 238.58,93.63 ; CV936.1 206.96,107.04 206.75,107.25 v2(206.75,107.58) ; v2(237.61,101.98) 237.64,102 CV953.1 238.33,101.99 CV941.1 ; CV969.1 214.81,110.98 215.31,111.48 v2(215.33,111.48) 215.53,111.69 216.49,111.69 216.85,111.32 CV960.1 CV958.1 ; CV902.1 212.58,79.45 v2(212.46,79.33) ; RV623.1 226.11,108.4 CV981.1 226.36,108.15 226.92,108.15 v2(227.08,107.99) ; CV932.1 204.47,110.45 204.98,109.94 v2(205.14,109.94) ; v2(244.12,87.43) 244.03,87.43 CV1036.1 ; CV1021.1 236.08,90.57 CV1038.1 CV997.1 ; CV1039.1 245.72,87.46 v2(245.72,88.33) ; CV956.1 238.88,109.31 v2(238.61,109.58) 238.61,110.1 CV937.1 238.95,110.53 238.13,111.36 238.13,111.39 237.68,111.83 CV951.1 237.38,111.7 235.33,111.7 235.14,111.51 CV938.1 ; CV1046.1 237.5,67.09 237.5,66.72 v2(237.72,66.51) ; CV949.1 229.43,105.41 v2(229.64,105.2) ; CV980.1 227.79,106.27 v2(228.09,105.96) ; CV1048.1 245.73,64.89 v2(245.72,64.91) ; v2(250.45,81.73) 250.64,81.92 CV1013.1 CV1034.1 ; v2(215.86,76.82) 215.86,76.33 CV900.1 ; CV952.1 228.78,106.89 v2(228.86,106.82) ; v2(238.36,98.78) 238.35,98.77 CV985.1 238.96,97.85 CV955.1 239.52,98.13 240.03,97.62 CV939.1 240.77,97.21 242.67,97.21 243.55,96.34 RV634.1 ; v2(229.61,109.98) 229.61,111.27 228.28,112.59 CV947.1 ; CV996.1 249.73,89.86 CV1031.1 249.92,89.98 250.57,90.62 250.57,91.13 250,91.69 CV1037.1 248.36,91.58 CV1020.1 246.8,91.11 246.8,90.39 247.32,89.88 v2(247.32,89.84) ; v2(239.32,66.51) 239.53,66.51 239.95,66.93 CV1019.1 CV1043.1 ; CV888.1 215.96,66.96 v2(215.96,67.6) ; v2(214.75,98.78) 214.98,98.55 CV974.1 215.81,98.45 CV971.1 ; CV946.1 v2(224.54,111.76) ; CV970.1 213.87,109.26 v2(213.95,109.18) ; CV986.1 227.22,97.62 CV940.1 227.62,97.61 v2(228.02,98.01) ; CV997.1 237.97,90.55 237.97,90.28 237.72,90.02 v2(237.72,89.84) ; v2(237.72,80.23) 237.72,79.54 CV995.1 ; v2(208.35,107.57) 208.82,108.04 CV935.1 ; CV984.1 236.09,109.1 v2(236.01,109.18) ; CV999.1 246.76,55.31 v2(246.92,55.16) 246.44,54.68 CV1008.1 ; v2(245.24,91.15) 245.03,90.94 CV1032.1 ; CV978.1 216.47,108.28 215.6,109.16 v2(215.57,109.16) ; CV975.1 207.33,111.26 206.82,110.75 v2(206.76,110.75) 206.31,111.2 CV976.1 ; v2(234.32,107.01) 234.19,107.01 234.07,107.12 CV979.1 233.44,107.01 CV948.1 ; CV1033.1 239.92,86.43 v2(240.12,86.63) ; 238.58,93.63 CV1027.1 CV1030.1 ; 238.58,93.63 CV1029.1 CV1028.1 CV1026.1 ; CV942.1 233.4,109.15 CV943.1 ; CV942.1 v2(231.43,109.83) ; CV942.1 231.76,108.8 CV950.1 ; RV8.1 250.86,56.12 v2(250.38,55.63) ; CV870.1 222.24,80.07 v2(222.31,80.15) ; v2(211.41,107.15) 211.4,107.15 CV931.1 ; v2(240.12,83.57) 240.07,83.52 CV1040.1 ; RV605.1 231.34,101.56 231.01,101.23 230.46,101.23 v2(230.41,101.18) ; CV896.2 220.17,64.92 221.35,64.92 222.19,64.08 224.08,64.08 224.55,63.61 224.58,63.61 CV897.2 225.25,61.65 v2(225.3,61.6) ; CV954.1 238.81,106.36 v2(238.53,106.08) ; v2(202.54,79.36) 202.63,79.28 CV898.1 ; v2(214.75,100.38) 214.77,100.39 CV973.1 ; CV961.1 216.54,105.52 v2(216.6,105.58) 216.24,105.94 RV618.2 ; CV983.1 230.71,99.07 v2(230.41,98.77) ; v2(245.95,83.68) 246.14,83.86 CV1035.1 ; CV991.1 247.89,82.42 v2(248.11,82.64) ; CV944.1 CV945.1 v2(220.92,112.59) ; CV965.1 CV962.1 211.39,109.32 212.33,108.38 v2(212.35,108.38) ; CV899.1 CV873.2 222.31,87.7 221.93,87.32 v2(221.49,87.32) 221.49,87.64 CV863.1 220.79,87.7 CV864.2 ; CV1022.1 238.56,79.18 239.32,79.94 v2(239.32,80.23) ; CV930.1 207.86,108.38 v2(207.55,108.38) ; CV957.1 236.78,105.24 236.83,105.19 v2(236.83,105.16) ; v2(247.32,87.43) 247.26,87.37 CV993.1 247.46,86.61 CV1024.1 249.3,85.61 CV1025.1 ; v2(205.15,108.38) 204.92,108.61 CV977.1 ; CV972.1 214.06,106.88 v2(213.95,106.78) ; v2(208.35,101.18) 209.04,100.49 CV929.1 ; CV982.1 226.33,110.23 226.95,109.61 v2(227.11,109.61) ; v2(248.91,79.45) 248.81,79.35 CV998.1 ; 216.66,69.29 v2(215.9,69.29)
  IN6 w0.508: v2(236.83,105.16) 236.86,105.19 236.86,105.24 237.37,105.75 238.2,105.75 v2(238.53,106.08)
  BOTTOM w0.254: UV24.R10 v2(207.55,99.58) ; UV26.D1 v2(246.55,79.47) ; v2(240.92,65.71) UV25.G1 ; v2(240.92,65.71) UV25.G2 ; v2(240.92,65.71) UV25.F1 ; UV24.R5 211.57,98.8 v2(211.56,98.8) ; UV23.K3 v2(228.81,104.38) ; UV26.F14 245.32,91.07 v2(245.24,91.15) ; UV25.C5 238.12,62.68 v2(238.38,62.42) ; UV23.F12 v2(236.81,101.98) UV23.G13 ; UV26.D3 v2(246.56,81.79) ; UV25.B14 v2(236.92,56.1) ; UV25.M12 v2(245.72,57.7) ; UV26.L13 v2(241.72,89.04) UV26.K12 ; v2(248.32,66.65) 248.39,66.57 248.39,66.23 UV25.T1 ; UV24.T12 v2(206.75,98.78) ; UV23.G1 v2(228.01,101.98) ; v2(228.01,101.98) UV23.G2 ; v2(228.01,101.98) UV23.F1 ; v2(227.11,109.61) 227.14,109.58 UV23.T1 ; v2(245.71,80.98) 245.32,81.37 UV26.F3 v2(244.92,81.83) UV26.G4 ; UV24.T3 v2(213.15,98.78) ; UV26.N10 v2(240.12,86.63) ; UV25.L14 244.59,55.78 244.59,56.43 UV25.L13 244.15,56.87 ; UV25.R10 v2(248.12,58.5) ; UV23.L2 228.09,105.9 v2(228.09,105.96) ; v2(216.35,102.24) 215.68,101.58 UV24.M1 215.24,101.67 215.24,102.29 UV24.L1 ; UV23.H3 v2(229.61,102.78) UV23.G4 ; UV24.F1 215.15,106.42 214.8,106.78 v2(213.95,106.78) UV24.F3 v2(213.15,105.98) UV24.G4 ; UV23.L4 v2(229.64,105.2) ; UV23.E10 v2(235.21,101.18) ; UV26.M14 v2(240.92,89.84) UV26.L14 ; UV23.M3 228.86,106.73 v2(228.86,106.82) ; UV26.P11 v2(239.32,88.24) UV26.P12 ; UV23.D3 v2(229.61,99.58) ; UV25.L1 244.52,66.41 244.78,66.67 v2(244.78,66.67) ; UV23.D11 v2(236.01,100.38) UV23.D12 ; UV24.L13 v2(205.95,102.78) UV24.K12 ; UV24.D12 v2(206.75,107.58) UV24.D11 ; UV24.C5 v2(212.35,108.38) ; UV23.F3 v2(228.81,101.18) ; UV26.T14 v2(237.72,89.84) ; UV25.M3 v2(245.72,64.91) ; UV26.H12 v2(244.12,89.04) UV26.G13 UV26.G14 ; v2(212.35,102.78) UV24.L4 UV24.K3 ; UV25.C10 v2(237.72,58.5) ; UV23.T14 v2(238.61,109.58) ; v2(248.91,79.45) 248.91,79.45 UV26.B1 ; UV26.F1 245.32,79.07 245.11,78.87 ; UV24.D1 v2(215.6,107.53) ; 239.3,57.71 239.3,57.68 UV25.D12 ; 239.3,57.71 239.3,57.73 UV25.D11 ; 239.3,57.71 v2(239.31,57.71) ; UV26.G1 244.52,79.41 245.06,78.87 245.11,78.87 ; UV26.M12 v2(240.92,88.24) UV26.L11 ; UV25.P14 v2(246.92,55.16) ; UV24.P3 v2(213.15,100.38) ; UV24.M3 v2(213.95,101.98) UV24.L2 ; UV23.C5 v2(230.41,98.77) ; UV23.K12 236.8,105.16 v2(236.83,105.16) 236.86,105.19 236.86,105.2 237.21,105.56 UV23.L13 237.29,105.65 237.77,105.65 237.85,105.58 UV23.L14 ; UV26.C10 v2(247.32,87.43) ; UV26.F12 245.32,88.6 245.58,88.33 v2(245.72,88.33) 245.72,87.59 246.12,87.19 UV26.E10 ; UV23.M14 238.28,106.38 238.53,106.12 v2(238.53,106.08) ; UV23.P14 v2(237.63,108.36) ; UV24.P12 v2(206.75,100.38) UV24.P11 ; v2(204.38,97.98) 204.38,98 UV24.T14 ; UV25.M14 v2(245.32,55.17) ; UV26.D14 v2(247.32,89.84) ; UV25.L11 v2(244.12,58.5) ; UV25.N10 v2(246.52,58.5) ; UV24.H3 v2(213.95,105.18) UV24.G2 ; UV26.R10 v2(238.52,87.43) ; 244.15,56.87 v2(244.15,56.9) ; 244.15,56.87 UV25.K12 ; UV25.D14 v2(238.52,56.1) ; UV25.P12 v2(247.32,57.7) UV25.P11 ; UV23.P1 227.31,107.98 227.29,107.99 v2(227.08,107.99) ; UV23.B3 v2(228.81,98.78) ; v2(240.92,79.3) 240.9,79.32 240.86,79.32 240.52,79.66 UV26.M1 240.57,79.78 241.26,79.78 UV26.L1 241.38,79.89 241.38,80.58 UV26.L2 ; UV25.K3 v2(243.32,64.91) ; 241.71,57.71 UV25.H12 ; 241.71,57.71 UV25.G11 ; 241.71,57.71 v2(241.71,57.74) ; UV23.R5 v2(230.41,109.18) ; UV24.E5 211.48,107.18 211.46,107.15 v2(211.41,107.15) ; UV26.G11 v2(244.12,87.43) ; UV25.F3 v2(240.12,64.91) ; v2(230.41,107.64) 230.41,107.43 230.67,107.18 UV23.N5 ; UV26.R5 v2(237.72,83.43) ; v2(248.68,55.18) 248.68,55.54 UV25.T14 ; UV26.P3 v2(239.32,81.83) ; v2(235.21,105.18) 235.21,105.32 235.47,105.58 UV23.L11 ; UV23.C10 v2(235.21,98.78) ; UV25.G14 v2(240.92,56.1) UV25.F14 ; UV24.C10 v2(207.55,108.38) ; UV24.L14 v2(205.15,101.98) UV24.M14 ; v2(208.35,107.57) 207.96,107.18 UV24.E10 207.8,107.18 207.4,106.78 206.79,106.78 206.39,106.38 UV24.F12 ; v2(245.95,83.68) 245.95,83.2 UV26.E5 ; UV26.H3 v2(244.12,81.03) UV26.G2 v2(244.92,81.03) ; UV25.P1 v2(247.32,65.71) ; UV25.G4 v2(241.72,64.11) UV25.H3 ; v2(227.14,105.36) 227.36,105.58 UV23.L1 UV23.M1 ; v2(237.72,57.74) 237.72,57.71 UV25.B12 ; UV25.E5 v2(240.12,63.3) ; UV24.B14 v2(205.14,109.94) ; v2(204.42,85.22) 204.42,85.21 204.59,85.05 UV18.AB33 ; UV25.B1 v2(237.72,66.51) ; UV25.L2 v2(244.12,64.91) ; UV26.N5 239.72,83.17 v2(240.12,83.57) ; 245.11,78.87 v2(245.08,78.84) ; UV25.L4 v2(244.12,64.1) ; UV25.T12 v2(248.92,57.7) ; UV23.D14 238.46,99.53 238.46,98.87 v2(238.36,98.78) 238.01,98.43 UV23.B14 ; UV24.P1 v2(214.75,100.38) ; UV24.B3 v2(213.95,109.18) ; UV26.K3 v2(241.72,81.83) UV26.L4 ; UV24.G2 v2(213.95,105.98) ; UV24.G2 UV24.G1 ; UV24.G14 205.14,105.96 v2(205.17,105.96) UV24.F14 ; v2(240.92,56.87) 240.92,56.9 ; 240.92,56.9 UV25.F12 ; 240.92,56.9 UV25.G13 ; UV23.G11 v2(236.01,102.78) UV23.H12 ; UV26.B14 v2(248.12,90.64) ; UV24.T1 v2(214.75,98.78) ; UV23.T12 v2(236.01,109.18) ; UV25.B3 v2(237.72,64.91) ; v2(234.32,107.01) 234.49,107.18 UV23.N10 234.81,107.03 235.07,106.78 235.86,106.78 236.26,106.38 UV23.M12 ; v2(245.37,66.62) 245.32,66.57 UV25.M1 ; UV26.B3 v2(248.92,81.03) ; UV24.H12 v2(205.95,105.18) UV24.G13 ; v2(222.3,67.93) 222.18,68.05 UV18.B13 ; UV23.B1 227.98,98.01 v2(228.02,98.01) ; UV24.N5 v2(212.35,101.18) ; UV25.N5 v2(246.12,62.33) ; UV25.D1 v2(239.32,66.51) ; UV24.D3 v2(213.15,107.58) ; UV23.T3 v2(229.61,109.98) ; UV23.E5 v2(230.41,101.18) ; v2(228.04,100.38) 228.04,100.37 228.01,100.37 UV23.D1 ; UV25.E10 v2(240.09,58.53) ; UV23.B12 v2(236.01,98.78) ; UV25.D3 v2(238.52,64.11) ; UV23.F14 v2(237.61,101.98) UV23.G14 ; UV23.R10 v2(235.21,109.18) ; UV26.T12 v2(237.72,88.24) ; UV26.T1 v2(237.72,80.23) ; v2(209.69,85.21) 209.68,85.2 209.68,84.79 UV18.T33 ; UV26.M3 v2(240.92,81.03) ; UV24.G11 v2(207.55,105.18) ; UV24.B1 v2(215.57,109.16) ; UV26.D12 v2(247.32,88.24) UV26.D11 ; UV25.R5 v2(248.12,63.3) ; UV24.D14 v2(205.15,108.38) ; UV26.T3 v2(237.72,81.83) ; UV25.P3 v2(247.32,64.11) ; UV26.B12 v2(248.92,88.24) ; UV24.N10 v2(208.35,101.18) ; UV23.P12 v2(236.01,107.58) UV23.P11 ; v2(222.6,72.76) 222.31,73.05 UV18.B19 ; UV26.P14 v2(239.32,89.84) ; UV26.P1 v2(239.32,80.23) ; UV24.B12 v2(206.75,109.18) ; UV23.P3 v2(229.61,108.38) ; UV24.P14 v2(205.15,100.38) ; UV26.C5 v2(248.11,82.64)
  BOTTOM w0.3: v2(222.62,70.18) 222.34,70.46 221.32,70.46 UV18.B16
  BOTTOM w0.305: UV18.AA30 205.44,82.3 v2(205.01,81.87) ; UV18.P27 211.63,79.41 v2(211.63,79.39) 211.68,79.39 UV18.N27 ; v2(207.51,81.95) 207.5,81.95 207.15,82.3 UV18.W30 ; v2(210.01,79.39) 210.01,79.46 210.1,79.46 UV18.R27 ; v2(210.01,79.39) 210.04,79.39 ; v2(210.01,79.39) 209.61,79.8 UV18.T27 ; v2(207.23,86.25) 207.2,86.28 207.2,84.81 UV18.W33 ; UV24.L11 207.15,102.32 v2(206.75,101.92) 206.41,101.58 UV24.M12 ; v2(218.41,70.12) 218.41,70.12 UV18.E16 ; v2(248.94,64.04) 248.52,64.46 UV25.T3 ; UV18.E19 218.63,72.84 218.19,72.84 217.63,73.4 v2(217.6,73.4) ; UV18.T30 209.59,82.29 209.59,82.24 v2(210,81.83) ; UV18.E13 218.82,68.05 218.47,68.4 v2(218.36,68.4)
  BOTTOM w0.508: v2(204.38,97.98) 203.97,98.38 CV934.1 CV933.1 ; v2(243.84,78.43) 243.98,78.28 RV630.2 ; CV862.1 CV871.1 225.74,61.16 v2(225.3,61.6)
  vias: v2(204.16,79.36) v2(204.75,113.14) v2(205.04,79.37) v2(206.02,113.14) v2(206.66,79.37) v2(206.89,78.74) v2(207.29,113.14) v2(208.66,113.18) v2(209.98,113.18) v2(211.38,113.17) v2(214.06,116.02) v2(214.06,115.39) v2(214.06,114.75) v2(214.06,114.12) v2(214.06,113.48) v2(214.06,112.85) v2(214.69,116.02) v2(214.69,115.39) v2(214.69,114.75) v2(214.69,114.12) v2(214.69,113.48) v2(214.69,112.85) v2(215.33,116.02) v2(215.33,115.39) v2(215.33,114.75) v2(215.33,114.12) v2(215.33,113.48) v2(215.33,112.85) v2(215.94,75.11) v2(215.94,72.6) v2(215.86,64.26) v2(215.96,116.02) v2(215.96,115.39) v2(215.96,114.75) v2(215.96,114.12) v2(215.96,113.48) v2(215.96,112.85) v2(215.97,73.47) v2(216.6,116.02) v2(216.6,115.39) v2(216.6,114.75) v2(216.6,114.12) v2(216.6,113.48) v2(216.6,112.85) v2(217.23,116.02) v2(217.23,115.39) v2(217.23,114.75) v2(217.23,114.12) v2(217.23,113.48) v2(217.23,112.85)
+1V_MPHY: length 3.3
  BOTTOM w0.127: UH2.V28 v2(85.81,16.87)
  BOTTOM w0.152: v2(87.36,17.64) UH2.U25 ; UH2.U21 v2(88.91,17.64) ; UH2.U26 v2(86.58,17.64) ; UH2.U23 v2(88.13,17.64) ; UH2.V26 v2(86.58,16.87)
  vias: v2(110.52,14.07) v2(111.1,14.07) v2(111.68,14.07) v2(112.27,14.07) v3(83.21,30.44)
+1V_MPHY_MPHYPLL:
  vias: v2(76.01,25.9) v2(78.69,26.22) v3(80.78,29.32)
+1V_PCH: length 115.4
  TOP w0.279: v2(129.76,95.56) 129.71,95.56 129.26,96.01 JXDP.43 ; RH492.1 119.66,95.39 120.27,95.39 120.81,95.93 121.32,95.93 121.4,96.01 JXDP.44 123.94,96.01 v2(124.11,96.17)
  TOP w0.381: RH196.1 88.02,10.92 v2(88.49,10.92)
  IN1 w0.508: v2(129.76,95.56) 128.73,95.56 126.68,97.61 125.42,97.61 124.11,96.29 v2(124.11,96.17)
  IN4 w0.508: 102.87,22.93 102.68,23.12 102.68,27.5 102.11,28.08 102.11,28.8 102.93,29.63 103.81,29.63 106.4,32.22 106.4,33.98 118.07,45.66 118.07,51.98 118.9,52.8 118.9,62.9 122.42,66.42 122.42,68.12 125.67,71.36 125.67,78.93 128.61,81.87 128.61,87.17 128.25,87.53 128.25,96.6 127.31,97.54 125.68,97.54 124.31,96.17 v2(124.11,96.17)
  BOTTOM w0.152: v2(92.58,13.77) 92.34,14.26 UH2.AD15 ; v2(89.72,18.98) 89.96,18.74 UH2.R19 ; v2(91.95,19.63) 91.62,19.96 UH2.N17 ; UH2.U20 v2(89.68,17.64) ; UH2.V17 v2(91.23,16.87) ; v2(91.23,14.54) UH2.AC17 ; v2(90.77,18.97) 91,18.74 UH2.R17
  BOTTOM w0.203: UH2.AL22 88.7,11.12 v2(88.49,10.92)
  BOTTOM w0.508: CH3.1 121.79,95.65 122.31,96.17 v2(124.11,96.17) ; v2(104.54,23.52) 104.07,23.05 RH71.1
  vias: v3(90.36,21.1)
+1V_PCH_AZPLL: length 24.2
  TOP w0.14: v1(109.35,12.39) v2(108.9,12.84)
  TOP w0.508: v2(90.75,10.18) 91.2,10.18 91.44,10.42 CH203.1 ; v2(108.9,12.84) 108.61,12.54 LH2.2
  IN2 w0.508: v2(108.9,12.84) 104.42,12.84 102.97,11.38 99.74,11.38 99.1,10.75 97.98,10.75 96.79,11.93 92.25,11.93 91.63,11.32 91.63,10.55 91.27,10.18 v2(90.75,10.18)
  BOTTOM w0.152: v2(90.75,10.18) 90.67,10.18 UH2.AN19
+1V_PCH_CLK5: length 11.5
  TOP w0.457: v2(102.74,16.39) 102.74,16.26 103.23,15.78 RH584.2
  BOTTOM w0.152: UH2.K3 98.85,21.27 UH2.K2
  BOTTOM w0.381: UH2.K2 100.41,21.36 100.55,21.5 101.49,21.5 CH179.1
  BOTTOM w0.508: CH179.1 101.84,20.87 102.3,20.42 CH178.1 101.11,20.04 100.81,19.75 100.81,17.7 v3(100.88,17.63) 101.1,17.41 102.01,17.41 CH177.1
+1V_PCH_PRIM: length 8.8
  BOTTOM w0.152: UH2.AA23 v2(88.13,16.09) UH2.Y23 ; UH2.AC23 v2(88.13,14.54) UH2.AE23 ; UH2.AE26 v2(87.36,14.54) ; UH2.AA28 v2(86.58,15.32) ; UH2.AC26 v2(87.36,15.32) ; UH2.AC28 v2(86.58,14.54) ; UH2.AJ25 v2(88.13,12.22) UH2.AJ23 v2(88.91,12.22) UH2.AJ21 v2(89.68,12.22) UH2.AJ20 ; UH2.Y25 v2(87.36,16.09) UH2.AA26
  vias: v3(87.67,13.62)
+1V_PCH_USBPLL: length 11.6
  TOP w0.508: RH583.2 105.92,13.05 CH201.1 104.4,12.58 104.14,12.33 102.68,12.33 CH202.1 100.65,11.5 100.46,11.69 99.82,11.69 98.91,10.78 97.85,10.78 v3(97.56,11.07) 97.28,11.07 97,10.8 v2(97,10.16)
+1V_VCCDSW: length 8
  TOP w0.089: RH196.2 88.02,9.88 88.98,10.83 v1(88.98,10.97)
  TOP w0.381: CH176.1 86.37,6.57 86.68,6.88 86.68,7.58 86.77,7.66 86.77,9 87.28,9.51 87.53,9.51 RH196.2
  TOP w0.508: CH176.1 84.99,6.57 v2(84.87,6.45)
  BOTTOM w0.254: UH2.BA29 v2(84.87,6.45)
+1VALW: length 135.5
  TOP w0.127: v3(119.44,13.85) 119.23,14.07 v2(118.87,14.07)
  IN4 w1.524: 183.71,83.96 184.11,83.55 184.11,79.92 182.97,78.77 182.97,72.12 184.09,71 188.13,71 191.87,67.26 191.87,58.97 192.55,58.3
  BOTTOM w2.032: 124.47,12.58 124.69,12.8 129.07,12.8 130.96,14.69 146.31,14.69 146.54,14.92 148.81,14.92 149.04,14.69 171.53,14.69 171.88,14.34 175.9,14.34 179.02,17.46 179.02,23.91 180.18,25.07 180.18,31.1 179.72,31.55 179.72,37.17 193.36,50.81 193.36,54.94 192.41,55.89
  vias: v2(103.63,16.84) v2(103.63,16.25) v2(104.5,16.79) v2(104.51,16.21) v2(106.74,14.07) v2(107.33,14.07) v2(107.91,14.07) v2(117.02,14.07) v2(117.02,13.48) v2(117.6,14.07) v2(117.6,13.48) v2(118.24,14.07) v2(118.24,13.48) v2(118.87,13.48) v2(182.8,85.68) v2(182.8,85.1) v2(183.39,85.1) v2(183.97,85.1) v2(192.14,56.6) v2(192.43,57.15) v2(192.76,56.61)
+1VS_GFX: length 34
  TOP w0.508: RV112.1 221.44,116.12 221.9,116.58 v2(222.12,116.58) ; v2(195.64,86.62) 195.77,86.5 CV869.1 ; CV869.1 197.68,87.64 RV1067.2 ; CV869.1 196.53,86.18 196.05,85.7 194.59,85.7 194.31,85.42 RV1078.2 ; CV860.1 200.97,72.72 v2(201.03,72.78) ; v2(199.94,77.62) 200.16,77.4 200.16,77.37 200.36,77.17 CV865.1 ; CV859.1 200.12,75.27 v2(199.95,75.1) ; v2(195.05,59.29) 195.49,59.74 195.49,61.18 195.47,61.21 CV866.1
  BOTTOM w0.254: UV18.AH21 199.55,74.7 v2(199.95,75.1) ; UV18.AG19 200.58,73.05 200.85,72.78 v2(201.03,72.78) ; UV18.AG22 200.34,75.48 v2(199.95,75.1) ; UV18.AG21 200.34,74.71 v2(199.95,75.1) ; UV18.AH25 199.54,78.02 v2(199.94,77.62) 200.34,77.22 UV18.AG24
  BOTTOM w0.508: v2(195.64,86.62) 196.47,87.45 196.47,93.61 201.3,98.43 CV868.2 CV867.1 CV861.1
  vias: v2(199.33,103.83) v2(199.33,103.23) v2(222.12,115.95) v2(222.12,115.31) v2(222.12,114.68) v2(222.82,116.58) v2(222.82,115.95) v2(222.82,115.31) v2(222.82,114.68) v3(199.2,102.5)
+1VSP: length 22.1
  TOP w0.508: v2(134.79,1.53) 134.76,1.56 PR504.1
  IN1 w0.254: v2(119.19,5.6) 119.06,5.6 118.68,5.22 118.68,2.42 119.8,1.3 129.57,1.3 130.37,2.1 134.43,2.1 134.79,1.75 v2(134.79,1.53)
  BOTTOM w0.508: PC507.1 v2(134.79,1.53)
  vias: v2(122.87,5.66) v2(123.46,5.66) v2(124.04,5.66) v2(124.63,5.66) v2(125.21,5.66) v2(125.79,5.66) v3(124.77,6.3)
+2.5V_MEM: length 75.3
  IN5 w1.016: 175.6,31.05 175.98,31.43 179.62,31.43 180.55,30.5 224.15,30.5 225.21,29.43 249.76,29.43 249.85,29.35
  vias: v2(174.42,30.18) v2(175.06,30.18) v2(175.71,30.18) v2(250.71,29.83) v2(250.69,29.23) v3(179.82,26.29)
+2.5V_MEMB: length 2.7
  TOP w0.14: v1(248.55,28.3) 248.55,27.22 CD34.1
  TOP w0.508: CD34.1 249.02,26.76 CD35.1
+2.5VSP_ON: length 3.7
  TOP w0.14: PC1800.1 178.28,10.61 v1(177.9,10.23)
  TOP w0.254: PR1801.2 178.77,9.78 178.77,10.56 PC1800.1 179.21,10.61 179.55,10.27 179.83,10.27 180.03,10.46 PU1800.6
+3.3V_ALW_DEG: length 5
  TOP w0.102: RE60.2 v3(314.29,28.66)
  TOP w0.508: RE60.2 312.5,28.66 312.26,28.9 312.26,29.5 311.75,30.01 v2(311.75,30.18)
  BOTTOM w0.305: v2(311.75,30.18) 311.11,30.82 JDEG1.1
+3.3VDX_SSD: length 13.5
  TOP w0.508: v2(269.96,4.91) 269.96,4.58 269.52,4.14 268.75,4.14 CD40.1 ; CD39.1 268.77,18.21 269.63,18.21 269.96,18.54 v2(269.96,18.79) ; v2(269.24,18.87) 268.54,19.57 CD38.1 ; v2(269.32,21.93) 269.2,22.04 CD36.1 ; v2(269.24,8.99) 268.95,9.28 RD8.2 v3(268.43,10.49) RD7.1 268.98,13.34 v2(269.18,13.15) ; CD41.1 268.72,5.47 v2(269.27,4.92)
  vias: v2(244.54,9.34) v2(245.16,9.34) v2(245.76,9.34) v2(246.38,9.34) v2(247.02,9.34) v2(269.24,11.5) v2(269.81,13.15) v2(269.84,11.5) v2(270.45,11.5) v3(245.3,9.98) v3(246.7,8.84)
+3V_LDO: length 32.5
  TOP w0.508: PU203.5 25.35,20.34 25.02,20.01 PC218.1 24.78,18.31 24.19,17.73 v3(24.19,14.87) 24.19,12.49 24.76,11.92 v2(24.76,10.61) ; v2(15.88,22.23) 15.69,22.42 PQ224.1 13.85,22.42 12.98,23.3 12.42,23.3 12.07,23.66 12.07,23.68 PR281.1
  IN5 w0.508: v2(15.88,22.23) 16.3,22.23 18.97,19.56 21.03,19.56 24.76,15.83 v2(24.76,10.61)
+3V_PCH: length 339.1
  TOP w0.356: v2(178.03,5.27) 178.03,6.35 UZ11.5
  TOP w0.381: 111.53,5.76 111,5.76 110.85,5.92 109.31,5.92 109.15,6.08 107.16,6.08 106.3,5.22 RH571.2 ; QE19.5 v2(193.88,11.84) QE19.2 ; UZ20.5 183.34,6.44 v2(183.55,6.22) ; UZ12.5 173.13,5.97 v2(172.58,5.42) ; v2(77.17,5.13) 77.09,5.05 CH192.1 ; RH458.1 76.63,6.47 77.15,6.47 RH461.1 ; CH204.1 84.58,5.83 83.96,6.45 v2(83.83,6.45)
  TOP w0.406: RZ84.1 120.51,60.25 120.24,59.98 UZ19.5
  TOP w0.508: RH504.1 RH130.1 84.49,11.29 v2(83.74,11.29) 83.74,10.38 RH546.2 ; LH1.1 v2(113.92,8.37) 113.98,8.31 RH536.1 113.69,6.37 113.08,5.76 111.53,5.76 ; RH524.1 82.36,4.21 81.93,4.64 81.92,4.63 RH505.1 79.87,4.63 RH136.1 79.44,4.77 79.22,4.99 78.96,4.99 v2(78.81,5.14) 78,5.14 77.47,5.67 RH461.1 ; RH554.2 75.11,15.54 75.67,16.1 v2(75.83,16.1) ; v2(80,11.28) 79.65,10.93 CH191.1 ; v2(90.75,5.89) 91.27,6.41 CH186.1 91.44,5.6 91.19,5.34 RH558.2 ; v2(97.01,9.16) 97.65,9.8 CH189.1 ; v2(80.05,14.93) 79.96,14.93 CH190.1 ; v2(74.11,13.03) 74.42,13.03 74.87,12.58 RH110.2 ; RE121.1 150.31,15 159.6,15 v3(161.53,13.06) 163.16,11.43 163.16,10.68 164.19,9.66 164.78,9.66 165.69,8.76 168.1,8.76 169.52,7.34 169.52,5.43 169.98,4.98 UZ21.5 v2(170.37,6.42) ; v2(98.6,3.63) 98.68,3.7 CH187.1 ; RH459.1 71.13,4.42 v2(72.52,4.42) 73.05,4.42 73.2,4.26 RH506.2 RH82.1 ; RH119.1 68.66,14.1 69.34,13.42 v2(69.34,13.15) ; RZ84.1 120.51,61.18 119.95,61.73 v2(119.51,61.73)
  IN4 w0.508: v2(126.7,95.14) 127.64,94.2 127.64,85.3 126.7,84.36 v2(126.7,81.58) ; v2(116.41,53.32) 116.14,53.32 112.92,50.1 112.92,48.01 113.83,47.1 113.83,42.27 105.79,34.24 105.79,32.47 103.56,30.23 102.19,30.23 97.74,25.79 96.22,25.79 94.51,24.09 90.7,24.09 88.75,22.13 88.75,21.12 86.11,18.47 84.76,18.47 84.2,17.92 81.38,17.92 80.19,19.11 78.54,19.11 77.73,18.3 73.1,18.3 72.56,17.75 v2(70.35,17.75)
  IN5 w0.508: v2(97.01,9.16) 97.52,8.64 101.81,8.64 103.06,9.9 105.95,9.9 106.56,10.51 107.06,10.51 107.77,9.81 112.63,9.81 113.92,8.52 v2(113.92,8.37) 113.92,8.24 114.62,7.54 116.27,7.54 118.36,9.63 125.72,9.63 126.62,10.52 146.2,10.52 149.16,7.56 151.28,7.56 152.21,8.49 153.73,8.49 154.39,9.15 155.77,9.15 156.66,8.26 169.86,8.26 170.37,7.76 v2(170.37,6.42) 170.37,5.98 170.79,5.56 172.44,5.56 v2(172.58,5.42) 172.82,5.66 172.82,6.99 173.24,7.41 175.89,7.41 v2(178.03,5.27) 178.03,5.46 181.29,8.72 183.67,8.72 186.03,11.08 193.41,11.08 193.88,11.55 v2(193.88,11.84)
  BOTTOM w0.203: v2(83.83,6.45) 84.18,6.1 UH2.BA31 ; UH2.AN5 97,9.46 97,9.17 v2(97.01,9.16)
  BOTTOM w0.254: v2(90.75,5.89) 90.6,6.04 UH2.BA20 ; RH586.2 67.59,12.38 69.05,12.38 69.34,12.67 v2(69.34,13.15) ; UH2.BC42 79.94,4.77 UH2.BD40 ; RP8.6 70.45,17.86 v2(70.35,17.75) 70.35,17.57 70.56,17.36 RP8.5 ; RP8.8 70.24,18.86 69.72,18.34 v2(69.72,17.87) 69.78,17.87 70.27,18.36 RP8.7 ; UH2.AD41 79.58,14.46 v2(80.05,14.93)
  BOTTOM w0.305: JAPS.1 178.62,5.86 v2(178.03,5.27)
  BOTTOM w0.508: RH493.1 127.13,94.71 v2(126.7,95.14) ; RH553.2 RH555.2 v2(71.81,14.76) ; RH502.1 RH501.1 69.91,7.77 v2(69.89,7.74) ; RH120.1 70.94,10.85 v2(71.39,11.29) 71.87,10.81 RH523.1 ; RH552.2 v2(69.34,13.15) ; v2(116.41,53.32) 119.84,53.32 120.28,53.75 120.28,55.35 119.51,56.12 v2(119.51,61.73) 121.08,61.73 122.73,63.38 122.73,64.63 123.51,65.41 125.18,65.41 126.94,67.17 126.94,68.69 129.08,70.84 129.08,78.37 126.7,80.75 v2(126.7,81.58) ; v2(183.55,6.22) 182.11,4.78 182.11,3.32 181.7,2.92 178.8,2.92 178.03,3.69 v2(178.03,5.27)
  vias: v2(59.02,4.89) v2(59.44,5.34) v2(79.39,10.33) v2(80.71,8.37) v2(97.97,3.63)
